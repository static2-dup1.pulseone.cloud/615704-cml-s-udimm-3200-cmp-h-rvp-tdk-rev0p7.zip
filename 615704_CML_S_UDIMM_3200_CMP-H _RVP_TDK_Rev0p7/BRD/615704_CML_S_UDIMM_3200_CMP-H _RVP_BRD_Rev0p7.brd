# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LFRAME_ESPI_CS0_HDR_N: length 127.8
  TOP w0.1: v1(94.2,37.29) 93.9,36.98 90.88,36.98 90.04,36.14 86.02,36.14 84.93,35.05 84.93,31.22 84.09,30.38 81.05,30.38 80.89,30.22 J7J1.3
  LAY8 w0.1: v1(85.06,92.84) 83.56,92.84 83.36,92.64 83.36,88.57 83.46,88.47 83.66,88.47 83.76,88.57 83.76,92.29 83.86,92.39 84.19,92.39 84.29,92.29 84.29,89.46 84.39,89.36 84.59,89.36 84.69,89.46 84.69,90.76 84.79,90.86 84.99,90.86 85.09,90.76 85.09,88.18 85.19,88.08 85.52,88.08 85.62,88.18 85.62,94.52 85.72,94.62 85.92,94.62 86.02,94.52 86.02,84.91 86.12,84.81 86.32,84.81 86.42,84.91 86.42,94.73 86.52,94.83 86.72,94.83 86.82,94.73 86.82,79.65 88.69,77.77 88.69,76.27 89.76,75.21 89.76,68.98 92.14,66.6 92.14,58.04 92.96,57.22 92.96,46.23 93.09,46.1 93.09,39.88 94.2,38.77 v1(94.2,37.29)
  BOTTOM w0.1: R7U14.2 v1(85.06,92.84)
LFRAME_ESPI_CS0_N: length 78.3
  TOP w0.089: 81.78,135.89 84.95,139.06 87.04,139.06 88.02,140.03 90.42,140.03 90.55,140.17 91.56,140.17 91.6,140.2 92.14,140.2 U6E1.BE38
  TOP w0.1: v1(69.46,131.32) 69.46,131.44 70.28,132.26 72.82,132.26 73.27,132.71 74.06,132.71 74.16,132.81 74.16,132.84 75.48,134.16 77.13,134.16 78.7,135.73 81.63,135.73 81.78,135.89
  BOTTOM w0.1: v1(69.46,131.32) 68.7,130.55 68.7,124.74 66.45,122.49 66.45,114.93 67.7,113.69 67.7,107.11 72.16,102.64 72.16,101.47 74.98,98.66 74.98,97.49 77.93,94.54 78.27,94.54 78.94,93.87 82.4,93.87 R7U12.1 83.69,92.58 84.32,92.58 84.58,92.33 85.47,92.33 R7U18.1
LFRAME_ESPI_CS0_R_N: length 1.5
  BOTTOM w0.1: R7U10.1 R7U14.1 R7U18.2
LINE1_L: length 40
  TOP w0.2: v1(120.14,282.7) 120.77,282.07 121.41,282.07 121.75,281.73 EU6A1.36 ; v1(147.44,279.53) 147.44,279.27 C5A10.1
  BOTTOM w0.2: v1(147.44,279.53) 146.93,280.03 146.93,283.9 146.61,284.22 146.61,285.06 143.83,287.83 134.03,287.83 128.14,281.94 124.96,281.94 124.2,282.7 v1(120.14,282.7)
LINE1_R: length 49.6
  TOP w0.2: EU6A1.35 122.15,282.21 121.79,282.57 121.03,282.57 120.26,283.34 v1(120.26,283.59) ; C5A9.1 155.32,279.02 v1(155.32,280.16)
  BOTTOM w0.2: v1(155.32,280.16) 154.43,280.16 151.13,283.46 151.13,284.86 149.6,286.38 149.6,287.78 147.06,290.32 130.81,290.32 127,286.51 121.53,286.51 120.39,285.37 120.39,283.72 v1(120.26,283.59)
LPC_CLK1: length 107.9
  TOP w0.089: U6E1.BB34 v1(93.85,141.92)
  BOTTOM w0.089: v1(93.85,141.92) 93.78,141.99 92.43,141.99 91.92,141.48 91.75,141.48
  BOTTOM w0.1: R7U8.1 88.39,93.85 88.03,94.21 82.82,94.21 82.69,94.34 79.14,94.34 78.47,95.01 78.13,95.01 75.46,97.68 75.46,98.85 72.64,101.67 72.64,102.84 71.2,104.28 71.2,106.7 71.1,106.8 69.57,106.8 69.47,106.9 69.47,107.1 69.57,107.2 71.1,107.2 71.2,107.3 71.2,107.5 71.1,107.6 68.92,107.6 68.82,107.7 68.82,107.9 68.92,108 71.1,108 71.2,108.1 71.2,108.3 71.1,108.4 68.92,108.4 68.82,108.5 68.82,108.7 68.92,108.8 71.1,108.8 71.2,108.9 71.2,109.1 71.1,109.2 68.92,109.2 68.82,109.3 68.82,109.5 68.92,109.6 71.1,109.6 71.2,109.7 71.2,109.9 71.1,110 68.92,110 68.82,110.1 68.82,110.3 68.92,110.4 71.1,110.4 71.2,110.5 71.2,110.86 66.92,115.13 66.92,122.3 69.18,124.55 69.18,129.07 71.33,131.23 71.33,131.63 71.55,131.84 71.55,131.98 70.53,133 70.53,133.14 70.67,133.28 70.81,133.28 71.83,132.26 71.97,132.26 72.11,132.41 72.11,132.55 71.22,133.44 71.22,133.58 72.39,134.75 75.53,134.75 75.81,134.46 77.62,134.46 78.13,134.97 79.89,134.97 80.81,135.88 82.16,135.88 85.6,139.32 87.12,139.32 88.64,140.84 90.78,140.84 91.41,141.48 91.75,141.48
LPC_CLK1_R: length 1.8
  BOTTOM w0.1: R7U17.1 C7U1.1 R7U8.2
LPC_ESPI_CLK: length 83.9
  BOTTOM w0.1: R7R59.2 C7R4.1 74.29,132.21 74.29,131.92 74.39,131.82 76.59,131.82 76.69,131.72 76.69,127.96 76.59,127.86 76.39,127.86 76.29,127.96 76.29,131.32 76.19,131.42 75.99,131.42 75.89,131.32 75.89,127.96 75.79,127.86 75.59,127.86 75.49,127.96 75.49,131.32 75.39,131.42 75.19,131.42 75.09,131.32 75.09,127.96 74.99,127.86 74.79,127.86 74.69,127.96 74.69,131.32 74.59,131.42 74.39,131.42 74.29,131.32 74.29,130.15 71.7,127.56 71.58,127.56 70.99,126.96 70.99,121.25 69.88,120.14 69.88,115.04 73.01,111.91 73.01,104.13 73.82,103.33 73.82,102.16 76.63,99.34 76.63,98.17 78.62,96.19 78.95,96.19 79.55,95.59 81.62,95.59 82.15,96.12 84.04,96.12 84.47,96.55 86.92,96.55 87.17,96.3 90.14,96.3 90.93,95.52 90.93,93.72 R7U13.1
LPC_ESPI_CLK_EC: length 97
  TOP w0.1: v1(27.68,97.79) 25.72,97.79 23.5,95.57 19.15,95.57 18.66,95.09 U8F6.57
  LAY3 w0.1: v1(63.11,117.35) 62.65,116.88 62.65,116.24 69.07,109.82 69.07,106.54 79.6,96.01 85.33,96.01 86.74,94.6 86.74,92.1 87.52,91.31 v1(87.8,91.31)
  BOTTOM w0.1: v1(63.11,117.35) 58.52,117.35 55.51,114.34 48.7,114.34 44.37,110.01 42.88,110.01 38.41,105.54 36.83,105.54 36.3,105.01 34.16,105.01 30,100.85 30,99.18 29.11,98.3 28.19,98.3 v1(27.68,97.79) ; v1(87.8,91.31) 87.8,91.16 88.64,90.32 R7U22.2
LPC_ESPI_CLK_EC_AIC: length 98.8
  TOP w0.1: J6J2.46 117.22,14.64 117.22,15.49 116.84,15.87 116.33,15.87 115.95,16.25 115.95,16.64 115.44,17.14 115.06,17.14 114.68,17.52 114.68,17.91 114.15,18.43 111.23,18.43 110.99,18.67 110.99,20.7 111.5,21.21 111.5,21.84 111.12,22.22 107.69,22.22 107.31,21.84 105.41,21.84 104.52,22.73 104.52,24.26 104.9,24.64 104.9,28.07 v1(103.12,29.84)
  LAY8 w0.1: v1(103.12,29.84) 102.31,29.84 95.11,37.05 95.11,38.6 94.85,38.87 94.85,48.28 94.23,48.89 94.23,58.16 92.62,59.78 92.62,66.79 90.23,69.18 90.23,76.91 88.42,78.72 88.42,91.46 v1(87.8,92.07)
  BOTTOM w0.1: R7U21.2 v1(87.8,92.07)
LPC_ESPI_CLK_HDR: length 97.9
  TOP w0.1: J7J1.1 78.35,30.35 79.75,31.75 80.77,31.75 81.78,30.73 83.94,30.73 84.58,31.37 84.58,35.56 85.59,36.57 89.53,36.57 91,38.05 96.08,38.05 v1(96.9,37.23)
  LAY8 w0.1: v1(90.29,91.18) 90.93,90.55 91.38,90.55 96,85.93 96,80.47 96.1,80.37 96.3,80.37 96.4,80.47 96.4,85.04 96.5,85.14 96.7,85.14 96.8,85.04 96.8,61.25 99.62,58.43 99.62,54.19 96.18,50.75 96.18,39.34 96.39,39.13 96.39,37.72 96.87,37.23 v1(96.9,37.23)
  BOTTOM w0.1: R7U27.2 v1(90.29,91.18)
LPC_ESPI_CLK_PCH: length 21.7
  TOP w0.089: U6E1.BB36 v1(93.85,140.52)
  BOTTOM w0.1: R7R59.1 76.7,132.96 79.62,132.96 80.01,133.35 81.2,133.35 81.43,133.12 81.81,133.12 86.61,137.92 87.62,137.92 89.27,139.56 91.52,139.56 91.98,140.03 92.35,140.4 93.32,140.4 93.45,140.52 v1(93.85,140.52)
LPC_ESPI_CLK_R: length 4.5
  BOTTOM w0.1: R7U22.1 R7U27.1 90.42,90.3 90.8,90.68 90.8,91.95 90.42,92.33
LPC_ESPI_EC_DETECT: length 180.6
  TOP w0.1: R9G14.2 R9G10.1 v1(18.16,88.77) 18.66,88.77 19.62,89.73 U8F6.66 ; v1(108.58,13.59) 108.58,13.97 110.36,15.75 113.15,15.75 113.36,15.95 113.36,16.66 112.85,17.16 J6J2.11
  LAY3 w0.1: v1(108.58,13.59) 106.61,15.56 85.98,15.56 84.78,16.76 82.85,16.76 82.26,16.17 71.98,16.17 71.4,16.76 69.39,16.76 69.08,16.45 61.66,16.45 60.89,15.69 58.6,15.69 57.84,16.45 27.11,16.45 24.57,18.99 22.21,18.99 20.95,20.25 20.95,29.97 12.22,38.7 12.22,49.24 10.29,51.17 10.29,68.94 12.34,70.99 12.34,71.6 14.6,73.85 14.6,81.91 15.36,82.68 15.36,84.71 16.75,86.1 16.75,87.37 v1(18.16,88.77)
LPSS_GSPI0_CLK: length 13.6
  TOP w0.089: U6E1.BF29 91.52,144.82 91.48,144.77 88.75,144.77 88.65,144.67 84.97,144.67 84.29,143.99 83.41,143.99 83.22,143.8 83.01,143.8
  TOP w0.1: 83.01,143.8 80.68,143.8 79.55,142.67 R7E25.1
LPSS_GSPI0_CLK_R: length 175.5
  TOP w0.1: J9J2.1 6.22,22.73 v1(9.27,22.73) R9J13.2 ; v1(62.7,138.94) 63.5,139.74 66.25,139.74 66.8,140.29 68.82,140.29 70.24,141.71 72.33,141.71 72.64,142.02 75.12,142.02 75.4,142.3 77.66,142.3 78.02,142.67 R7E25.2
  LAY8 w0.1: v1(9.27,22.73) 10.25,23.71 10.25,69.73 15.83,75.31 15.83,85.18 16.25,85.6 16.25,92.58 17.17,93.5 17.17,110.69 20.89,114.4 20.89,118.05 24,121.16 24,122.26 29.93,128.2 29.93,130.78 v1(32.76,133.6)
  BOTTOM w0.1: v1(32.76,133.6) 37.86,133.6 38.59,134.33 42.89,134.33 43.87,135.31 51.75,135.31 54.9,138.47 62.41,138.47 62.7,138.76 v1(62.7,138.94)
LPSS_GSPI0_CS0_N: length 21.5
  TOP w0.089: U6E1.BB26 v1(93.77,145.56)
  BOTTOM w0.1: v1(93.77,145.56) 93.24,145.03 91.94,145.03 91.31,144.4 85.47,144.4 84.9,143.83 84.36,143.83 81.19,140.66 75.13,140.66 R7R49.1
LPSS_GSPI0_CS0_R_N: length 166.6
  TOP w0.1: R9J12.2 v1(9.27,25.02) 8.25,24 J9J2.2
  LAY8 w0.1: v1(32.76,134.36) 29.46,131.06 29.46,128.4 20.42,119.35 20.42,117.3 18.66,115.54 18.66,114.3 15.62,111.25 15.62,101.98 16,101.6 16,99.95 15.62,99.57 15.62,90.17 14.35,88.9 14.35,74.5 9.77,69.93 9.77,25.53 v1(9.27,25.02)
  BOTTOM w0.1: R7R49.2 73.7,140.8 69.04,140.8 68.78,140.54 64.65,140.54 63.56,139.44 61.79,139.44 61.52,139.17 54.61,139.17 51.46,136.02 42.39,136.02 42.13,136.27 37.4,136.27 35.5,134.36 v1(32.76,134.36)
LPSS_GSPI0_CS1_N: length 17.8
  TOP w0.089: 82.96,143.32 83.31,143.32 83.79,143.8 84.37,143.8 85.05,144.48 88.73,144.48 88.83,144.58 91.98,144.58 92.18,144.79 U6E1.BE29
  TOP w0.1: R7E29.1 76.31,142.1 79.77,142.1 81,143.32 82.96,143.32
LPSS_GSPI0_CS1_R_N: length 168.7
  TOP w0.1: J9J2.4 8.89,21.46 9.01,21.59 v1(9.27,21.59) R9J15.2 ; R7E29.2 74.86,141.54 72.83,141.54 72.53,141.24 70.44,141.24 69.02,139.82 66.99,139.82 66.45,139.27 63.72,139.27 62.91,138.46 62.45,138.46 v1(61.97,138.94)
  LAY8 w0.1: v1(36.44,134.24) 35.94,134.24 30.41,128.71 30.41,127.7 25.96,123.25 25.96,119.25 21.37,114.66 21.37,114.21 17.65,110.49 17.65,93.09 17.01,92.45 17.01,75.82 10.72,69.54 10.72,23.05 v1(9.27,21.59)
  BOTTOM w0.1: v1(36.44,134.24) 37.46,135.25 40.45,135.25 40.98,135.79 51.55,135.79 54.71,138.94 61.96,138.94 v1(61.97,138.94)
LPSS_GSPI0_MISO: length 19.3
  TOP w0.089: 83.33,144.29 83.95,144.91 84.06,144.91 84.27,145.12 88.37,145.12 88.52,145.27 91.46,145.27 91.67,145.05 92.24,145.05 92.27,145.02 92.48,145.02 92.63,144.87 U6E1.BD29
  TOP w0.1: 83.33,144.29 80.28,144.29 79.5,143.51 78.43,143.51 78.1,143.18 77.14,143.18 76.79,142.83 75.14,142.83 R7E27.1
LPSS_GSPI0_MISO_R: length 177.5
  TOP w0.1: J9J2.5 6.09,17.78 8.12,17.78 8.48,18.13 v1(9.27,18.13) R9J19.2 ; R7E27.2 72.44,142.49 72.13,142.19 70.05,142.19 68.63,140.77 66.6,140.77 66.05,140.22 62.16,140.22 v1(61.28,141.1)
  LAY8 w0.1: v1(9.27,18.13) 11.18,20.05 11.18,69.35 17.65,75.82 17.65,89.15 18.82,90.33 18.82,109.88 21.82,112.88 21.82,114.47 26.41,119.06 26.41,120.17 31.62,125.37 31.62,126.24 37.08,131.7 37.08,136.4 v1(36.57,136.9)
  BOTTOM w0.1: v1(36.57,136.9) 37.08,137.41 37.58,137.41 39.9,139.74 43.91,139.74 43.94,139.76 47.37,139.76 47.62,139.51 47.62,139.19 47.93,138.88 48.38,138.88 49.26,139.76 52.78,139.76 53.88,140.87 61.05,140.87 v1(61.28,141.1)
LPSS_GSPI0_MOSI: length 24.5
  TOP w0.089: 82.93,143.08 83.33,143.08 83.87,143.61 84.44,143.61 85.13,144.29 88.81,144.29 88.91,144.39 92.06,144.39 92.27,144.39 92.33,144.32 U6E1.BE30
  TOP w0.1: R7E39.2 R7E37.1 71.75,140.71 72,140.97 R7E32.1 R7E36.2 73.91,141.1 75.94,141.1 76.17,140.87 78.35,140.87 78.86,141.37 79.33,141.37 81.04,143.08 82.93,143.08
LPSS_GSPI0_MOSI_HDR: length 161.2
  TOP w0.1: v1(62.58,136.57) 62.63,136.52 65.63,136.52 67.48,138.38 71.31,138.38 72.48,139.54 73.24,139.54 R7E36.1 ; v1(38.35,24.26) 38.1,24.26 J8J3.3
  LAY6 w0.125: v1(38.35,131.31) 38.35,124.61 38.99,123.97 38.99,112.4 37.97,111.38 37.97,103.61 36.78,102.42 36.78,98.93 38.22,97.49 38.22,95.54 36.95,94.27 36.95,90.17 37.21,89.91 37.21,87.76 38.35,86.61 38.35,80.21 41.14,77.42 41.14,69.32 41.78,68.68 41.78,65.46 44.77,62.46 44.77,61.1 43.94,60.27 43.94,55.72 44.55,55.11 45.72,55.11 46.57,54.26 46.57,51.45 41.6,46.48 40.99,46.48 39.24,44.73 39.24,40 38.35,39.11 38.35,37.84 38.99,37.21 38.99,24.89 v1(38.35,24.26)
  BOTTOM w0.1: v1(62.58,136.57) 62.09,136.09 57.57,136.09 53.15,131.66 41.11,131.66 40.33,130.88 39.55,130.88 39.11,131.31 v1(38.35,131.31)
LPSS_GSPI0_MOSI_R: length 171.3
  TOP w0.1: v1(63.75,137.06) 64.03,136.78 65.53,136.78 67.35,138.6 71.22,138.6 72.7,140.08 R7E32.2 ; R9J17.2 v1(9.27,19.28) 8.35,20.19 6.22,20.19 J9J2.3
  LAY8 w0.1: v1(9.27,19.28) 10.95,20.96 10.95,69.44 17.42,75.91 17.42,89.25 18.6,90.42 18.6,109.98 21.59,112.98 21.59,114.57 26.18,119.16 26.18,120.36 30.25,124.43 30.25,125.63 33.02,128.4 v1(33.02,130.65)
  BOTTOM w0.1: v1(33.02,130.65) 40.42,130.65 41.2,131.44 53.25,131.44 57.67,135.86 62.55,135.86 v1(63.75,137.06)
LPSS_GSPI1_CLK: length 20.4
  TOP w0.089: U6E1.AU26 v1(96.06,145.56)
  BOTTOM w0.1: R7R38.1 78.94,145.79 79.22,145.52 81.01,145.52 81.71,144.81 82.68,144.81 83.5,145.63 90.51,145.63 91.44,146.56 95.06,146.56 v1(96.06,145.56)
LPSS_GSPI1_CLK_R: length 180.4
  TOP w0.1: J9H2.1 6.09,49.15 R9H6.2
  LAY5 w0.125: v1(4.31,146.56) 4.82,146.05 4.82,145.41 3.92,144.52 3.92,49.03 J9H2.1
  BOTTOM w0.1: v1(4.31,146.56) 10.28,146.56 10.54,146.81 13.33,146.81 13.73,146.41 35.33,146.41 37.73,144.02 38.73,144.02 39.52,143.22 41.34,143.22 42.39,144.27 54.72,144.27 56.18,145.73 64.43,145.73 64.65,145.95 76.67,145.95 R7R38.2
LPSS_GSPI1_CS0_N: length 21.5
  TOP w0.089: U6E1.AW26 v1(95.29,145.56)
  BOTTOM w0.1: R7R39.1 76.04,145.32 78.75,145.32 79.02,145.04 80.81,145.04 81.52,144.34 82.88,144.34 83.7,145.16 90.4,145.16 91.54,146.3 94.56,146.3 v1(95.29,145.56)
LPSS_GSPI1_CS0_R_N: length 176.4
  TOP w0.1: R9H8.2 v1(9.32,48) J9H2.2
  LAY5 w0.125: v1(7.62,142.49) 6.98,141.86 6.98,139.17 9.65,136.5 9.65,134.11 9,133.47 9,119.75 9.77,118.97 9.77,108.86 8.76,107.85 8.76,102.49 9.9,101.34 9.9,100.58 10.79,99.69 10.79,95.88 9.77,94.87 9.77,81.15 10.79,80.14 10.79,79.75 10.28,79.25 10.28,73.4 10.79,72.9 10.79,71.1 9.89,70.21 9.89,48.58 v1(9.32,48)
  BOTTOM w0.1: R7R39.2 74.99,145.47 64.95,145.47 63.27,143.79 59.62,143.79 58.45,142.62 47.85,142.62 47.52,142.29 45.74,142.29 45.18,141.73 38.35,141.73 34.85,145.24 15.31,145.24 14.17,144.09 13.64,144.09 13.23,144.5 13.23,145.88 13,146.11 11.1,146.11 10.16,145.16 10.16,144.91 7.74,142.49 v1(7.62,142.49)
LPSS_GSPI1_CS1_N: length 19.1
  TOP w0.089: 82.42,140.67 83.21,140.67 84.63,142.09 86.06,142.09 86.49,142.51 89.54,142.51 89.6,142.57 91.6,142.57 91.65,142.62 U6E1.BF33
  TOP w0.1: 82.42,140.67 81.48,140.67 78.79,137.97 75.74,137.97 75.18,137.41 R7E45.1
LPSS_GSPI1_CS1_R_N: length 172.9
  TOP w0.1: v1(65.04,133.2) 67.96,136.11 69.29,136.11 69.7,136.52 73.65,136.52 R7E45.2 ; J9H2.4 8.38,44.58 v1(9.27,44.58) R9H11.2
  LAY5 w0.125: v1(9.14,134.49) 9.01,134.49 8.75,134.23 8.75,119.64 9.52,118.87 9.52,108.96 7.8,107.25 7.8,94.42 9.52,92.71 9.52,76.45 9.27,76.2 9.27,75.56 9.64,75.19 9.64,70.86 8.83,70.05 8.83,47.8 9.27,47.37 v1(9.27,44.58)
  BOTTOM w0.1: v1(9.14,134.49) 14.17,134.49 16.2,136.52 16.92,136.52 17.87,135.57 19.43,135.57 21.81,133.2 21.81,132.97 23.04,131.74 23.04,130.57 26.35,127.25 36.51,127.25 39.56,124.2 50.13,124.2 52.44,126.52 55.9,126.52 61.21,131.82 62.74,131.82 63.63,132.71 64.56,132.71 v1(65.04,133.2)
LPSS_GSPI1_MISO: length 17.1
  TOP w0.089: U6E1.BD30 92.72,144.08 92.3,144.08 92.19,144.2 88.99,144.2 88.89,144.1 85.21,144.1 84.52,143.42 83.96,143.42 83.38,142.85 83.05,142.85
  TOP w0.1: R7E34.1 78.27,140.46 78.98,141.17 79.41,141.17 81.09,142.85 83.05,142.85
LPSS_GSPI1_MISO_R: length 180.7
  TOP w0.1: J9H2.5 5.96,41.91 8.76,41.91 v1(9.27,41.4) R9H14.2 ; v1(67.94,137.67) 68.42,138.15 71.41,138.15 72.57,139.31 73.9,139.31 74.24,139.65 74.24,140.66 74.34,140.77 75.89,140.77 76.2,140.46 R7E34.2
  LAY5 w0.125: v1(9.27,41.4) 8.76,41.91 8.76,47.32 8.58,47.5 8.58,69.19 7.11,70.66 7.11,97.92 7.56,98.36 7.56,105.21 7.11,105.66 7.11,119.81 8.5,121.2 8.5,134.74 v1(9.14,135.38)
  BOTTOM w0.1: v1(67.94,137.67) 67.94,137.54 66.38,135.98 63.33,135.98 62.98,135.63 57.76,135.63 53.34,131.21 41.3,131.21 40.22,130.13 31.01,130.13 29.35,131.78 24.6,131.78 23.11,133.27 23.11,134.34 21.81,135.64 21.81,136.69 21.09,137.41 19.73,137.41 18.59,138.56 16.89,138.56 13.84,135.51 9.27,135.51 v1(9.14,135.38)
LPSS_GSPI1_MOSI: length 20.8
  TOP w0.089: U6E1.BA26 v1(94.53,145.56)
  BOTTOM w0.1: R7R42.2 80.26,141.98 81.39,143.11 81.97,143.11 83.77,144.91 90.5,144.91 91.65,146.05 94.05,146.05 v1(94.53,145.56) ; R7R42.2 79.24,141.98 R7R41.2 ; R7R42.2 79.62,142.11 80.13,142.62 80.13,143.2 R7R40.1
LPSS_GSPI1_MOSI_R: length 189.9
  TOP w0.1: R9H9.2 9.01,45.72 8.12,46.61 6.09,46.61 J9H2.3
  LAY5 w0.125: J9H2.3 3.42,46.99 3.42,144.78 v1(4.31,145.67)
  BOTTOM w0.1: R7R40.2 79.14,144.6 78.76,144.98 69.7,144.98 69.59,145.09 64.95,145.09 63.42,143.56 59.72,143.56 58.45,142.3 53.43,142.3 52.22,141.1 38.67,141.1 34.75,145.01 15.41,145.01 14.26,143.86 11.41,143.86 10.42,142.87 8.76,142.87 7.84,141.95 5.99,141.95 4.31,143.64 v1(4.31,145.67)
LPSS_GSPI2_CLK_HDR: length 83.8
  BOTTOM w0.1: J9D5.1 21.84,166.11 21.84,164.43 22.47,163.8 23.89,163.8 25.81,161.87 26.08,161.87 26.18,161.97 26.18,164.11 26.28,164.21 26.48,164.21 26.58,164.11 26.58,161.97 26.68,161.87 26.88,161.87 26.98,161.97 26.98,164.11 27.08,164.21 27.28,164.21 27.38,164.11 27.38,161.97 27.48,161.87 27.68,161.87 27.78,161.97 27.78,164.11 27.88,164.21 28.08,164.21 28.18,164.11 28.18,161.97 28.28,161.87 28.48,161.87 28.58,161.97 28.58,164.11 28.68,164.21 28.88,164.21 28.98,164.11 28.98,161.97 29.08,161.87 31.29,161.87 31.42,161.74 44.78,161.74 45.18,162.14 54.4,162.14 59.63,156.91 61.01,156.91 61.8,156.12 65.49,156.12 67.56,154.05 68.51,154.05 68.51,154.05 71.63,154.05 73.06,152.62 75.17,152.62 75.76,152.02 78.73,152.02 R7R22.2
LPSS_GSPI2_CS0_HDR_N: length 72.9
  LAY5 w0.125: J9D5.2 21.84,166.11 21.84,158.75 26.28,154.3 27.5,154.3 v1(28.14,153.67)
  BOTTOM w0.1: v1(28.14,153.67) 28.67,154.2 30.07,154.2 30.6,153.67 33.27,153.67 33.52,153.41 40.06,153.41 40.49,153.85 52.26,153.85 53.02,153.09 59.37,153.09 60.13,152.32 65.27,152.32 66.52,153.57 71.68,153.57 72.84,152.41 75.08,152.41 75.68,151.82 77.25,151.82 78.48,150.59 78.48,150.24 78.86,149.86 79.5,149.86 R7R34.2
LPSS_GSPI2_CS1_HDR_N: length 17.1
  TOP w0.1: R8D47.2 24.25,178.18 v1(23.62,178.81)
  BOTTOM w0.1: J9D5.4 24.1,165.84 24.1,178.33 v1(23.62,178.81)
LPSS_GSPI2_MISO_HDR: length 3.4
  TOP w0.1: R9D41.2 19.17,164.21 20.57,162.81 J9D5.5
LPSS_GSPI2_MOSI_HDR: length 2.6
  TOP w0.1: J9D5.3 19.81,165.61 R9D39.2
LPSS_I2C0_SCL: length 668.1
  TOP w0.089: U6E1.BC22 93.01,148.29 92.96,148.25 92.65,148.25 92.56,148.17 92.35,148.17 92.32,148.13 91.75,148.13 91.56,147.95 88.51,147.95 88.39,148.07 86.34,148.07 85.71,148.7 82.29,148.7 82.04,148.95 79.5,148.95 77.71,147.16
  TOP w0.1: R8A22.2 27.68,273.43 24.76,273.43 ; 77.71,147.16 76.61,147.16 76.22,147.54 70.14,147.54 69.5,146.9 62.98,146.9 v1(61.34,145.26) ; R1E24.1 v1(285.24,151)
  LAY5 w0.125: v1(285.24,151) 285.18,151 283.45,152.73 283.45,154.66 284.74,155.95 288.1,155.95 291.37,159.21 291.37,160.63 291.9,161.16 292.73,161.16 293.87,162.3 293.87,171.44 295.15,172.72 295.15,179.02 294.13,180.05 294.13,193.42 294.38,193.67 294.38,196.22 292.96,197.63 292.96,207.15 293.61,207.8 293.61,214.03 292.52,215.12 292.52,217.42 296.6,221.5 296.6,241.87 295.02,243.45 295.02,246.59 296.16,247.72 296.16,249.93 295.46,250.64 295.46,264.23 291.19,268.49 282.24,268.49 281.43,267.68 280.16,267.68 279.66,268.18 278.21,268.18 277.21,267.18 275.23,267.18 274.83,267.58 271.39,267.58 270.56,268.42 267.47,268.42 266.03,269.85 258.54,269.85 257.04,268.35 246.76,268.35 244.47,270.64 235.83,270.64 235.07,269.87 233.42,269.87 233.29,270.01 230.13,270.01 229.62,269.5 229.62,267.83 227.74,265.96 221.76,265.96 221.28,265.48 216.73,265.48 214,268.21 210.68,268.21 210.05,267.59 210.05,267.39 207.47,264.8 202.18,264.8 200.52,266.46 196.3,266.46 195.91,266.07 191.81,266.07 191.44,266.44 179.57,266.44 178.3,265.17 174.87,265.17 172.77,263.07 172.01,263.07 170.94,262 169.03,262 168.02,260.98 162.75,260.98 162.38,260.61 159.18,260.61 157.66,259.1 150.01,259.1 149.23,258.31 143.55,258.31 143.26,258.02 136.16,258.02 132.58,254.44 129.76,254.44 128.41,253.09 126.38,253.09 124.14,250.84 118.14,250.84 117.01,251.97 113.92,251.97 113.21,251.26 98.32,251.26 98.25,251.34 96.72,251.34 96.06,250.67 90.11,250.67 90.05,250.73 88.24,250.73 87.38,251.59 82.74,251.59 81.62,252.71 78.04,252.71 73.83,256.93 70.69,256.93 70.05,256.29 63.58,256.29 62.23,254.94 60.21,254.94 59.87,255.28 53.07,255.28 52.57,255.78 51.05,255.78 50.18,254.9 44.06,254.9 42.81,256.16 37.21,256.16 33.52,259.84 33.52,266.06 33.9,266.44 33.9,273.55 31.49,275.97 27.3,275.97 24.76,273.43
  LAY6 w0.125: 24.76,273.43 24.76,272.53 23.24,271.01 21.51,271.01 20.7,270.21 20.7,254.34 20.44,254.08 20.44,253.29 20.7,253.03 20.7,246.97 20.11,246.37 18.84,246.37 18.15,245.68 18.15,244.85 17.38,244.09 17.38,234.5 19.42,232.47 19.42,225.11 17.51,223.21 17.51,219.8 19.15,218.16 19.15,205.33 16.76,202.94 16.76,196 10.27,189.51 10.27,174.07 11.41,172.93 11.41,159.32 13.07,157.66 13.07,146.31 v1(13.97,145.41)
  BOTTOM w0.1: v1(13.97,145.41) 14.49,145.94 35.14,145.94 37.53,143.54 38.53,143.54 39.33,142.75 41.54,142.75 42.59,143.8 54.92,143.8 56.38,145.26 v1(61.34,145.26)
LPSS_I2C0_SDA: length 670.9
  TOP w0.089: 82.06,148.61 82.16,148.51 85.63,148.51 86.26,147.88 88.31,147.88 88.43,147.76 91.64,147.76 91.77,147.88 U6E1.BF23
  TOP w0.1: R8A23.2 27.43,272.67 v1(26.92,272.67) 26.69,272.44 20.67,272.44 J9A3.1 ; R1E23.1 v1(284.48,151) ; v1(62.1,145.26) 63.26,146.42 69.69,146.42 70.34,147.07 76.03,147.07 76.41,146.68 77.59,146.68 79.66,148.76 81.91,148.76 82.06,148.61
  LAY5 w0.125: v1(26.92,272.67) 26.92,273.82 28.56,275.47 31.28,275.47 32.89,273.86 32.89,259.77 37.01,255.65 42.03,255.65 43.28,254.4 52.45,254.4 52.83,254.78 59.66,254.78 60.04,254.4 62.4,254.4 62.88,254.89 70.47,254.89 71.23,255.65 74.4,255.65 77.83,252.21 81.41,252.21 83.72,249.9 89.4,249.9 89.75,249.55 90.8,249.55 91.94,248.41 92.83,248.41 93.55,249.13 97.26,249.13 97.3,249.17 102.99,249.17 103.49,248.68 110.72,248.68 111.56,247.84 116.17,247.84 116.59,248.26 125.21,248.26 127.46,250.51 129.48,250.51 130.83,251.86 133.65,251.86 136.77,254.97 146.18,254.97 146.93,255.73 150.92,255.73 151.19,255.46 158.02,255.46 159.16,256.6 160.33,256.6 161.51,257.78 163.55,257.78 163.92,258.15 172.55,258.15 174.75,260.35 178.55,260.35 179.7,259.21 180.97,259.21 184.02,262.25 188.72,262.25 189.23,262.76 189.23,263.33 189.4,263.5 192.02,263.5 192.63,262.89 193.54,262.89 193.8,263.14 193.8,263.65 193.97,263.82 197.82,263.82 198.12,263.52 198.12,263.27 199.5,261.89 207.74,261.89 211.23,265.38 213.65,265.38 217.28,261.75 223.32,261.75 224.07,260.99 231.24,260.99 231.64,260.59 232.32,260.59 233.1,261.36 236.6,261.36 237.1,260.86 250.19,260.86 253.09,263.76 259.55,263.76 261.96,266.17 262.17,266.17 263.32,267.33 268.43,267.33 268.95,266.8 272.93,266.8 273.68,266.05 274.47,266.05 274.84,266.43 277.63,266.43 278.63,267.43 279.27,267.43 279.77,266.93 281.74,266.93 282.55,267.74 290.2,267.74 293.75,264.19 293.75,257.05 294.7,256.09 294.7,251.87 294.02,251.18 294.02,249.91 294.64,249.3 294.64,247.26 294.27,246.9 294.27,242.17 295.85,240.59 295.85,222.32 293.75,220.22 293.75,219.58 292.02,217.86 292.02,214.91 293.11,213.82 293.11,208 292.46,207.35 292.46,197.37 293.88,195.96 293.88,194.18 293.49,193.8 293.49,179.97 294.65,178.81 294.65,172.93 293.37,171.65 293.37,162.69 292.98,162.3 292.15,162.3 290.87,161.02 290.87,159.42 287.89,156.45 284.53,156.45 282.95,154.87 282.95,152.53 v1(284.48,151)
  LAY6 w0.125: v1(26.92,272.67) 26.92,272.03 25.4,270.51 21.71,270.51 21.2,270 21.2,254.13 20.94,253.87 20.94,253.5 21.2,253.24 21.2,246.76 20.32,245.87 19.05,245.87 18.65,245.47 18.65,244.65 17.88,243.88 17.88,234.7 19.92,232.67 19.92,224.91 18.01,223 18.01,220 19.65,218.37 19.65,205.13 17.26,202.74 17.26,195.79 13.91,192.44 13.91,190.19 12.34,188.62 12.34,183.67 11.91,183.24 11.91,159.53 13.57,157.87 13.57,146.57 14.47,145.67 14.47,145.16 v1(13.97,144.65)
  BOTTOM w0.1: v1(13.97,144.65) 14.78,145.46 34.94,145.46 37.34,143.07 38.34,143.07 39.13,142.27 45.08,142.27 45.55,142.75 46.99,142.75 47.56,143.32 55.11,143.32 56.57,144.78 61.62,144.78 v1(62.1,145.26)
LPSS_I2C1_SCL: length 292.2
  TOP w0.089: 86.3,149.35 87.21,149.35 87.64,148.92 88.71,148.92 88.82,148.8 91.73,148.8 91.73,148.8 91.97,148.8 92.18,148.59 U6E1.BE21
  TOP w0.1: v1(42.79,133.35) R8E57.1 C8E19.1 R8E62.1 ; v1(55.62,282.32) 55.62,275.59 56.26,274.95 R8A13.2 ; 86.3,149.35 86.05,149.09 82.68,149.09 82.42,149.35 79.12,149.35 77.72,147.95 77.21,147.95 76.67,148.49 69.75,148.49 69.1,147.85 63.09,147.85 v1(62.35,148.59)
  LAY6 w0.125: J9B3.1 5.73,248.71 8.48,251.46 8.48,257.82 8.12,258.18 8.12,259.33 8.5,259.71 8.5,272.41 11.28,275.19 13.26,275.19 20.39,282.32 v1(55.62,282.32) ; v1(42.79,133.35) 42.18,133.97 42.18,135.51 41.1,136.59 41.1,143.47 41.78,144.14 41.78,145.63 41.27,146.13 41.27,147.19 41.78,147.7 41.78,148.08 41.14,148.72 41.14,150.75 v1(40.51,151.38)
  BOTTOM w0.1: J9B3.1 6.24,247.73 6.24,240.59 4.15,238.5 4.15,229.45 3.9,229.2 3.9,201.97 8.18,197.69 8.18,162.5 14.73,155.95 15.62,155.95 18.07,153.5 24.71,153.5 25.5,152.71 28.33,152.71 29.79,151.26 30.98,151.26 32.44,152.71 35.62,152.71 36.83,151.51 37.46,151.51 37.84,151.89 40,151.89 v1(40.51,151.38) 40.51,151.76 41.66,152.92 51.87,152.92 52.63,152.16 56.75,152.16 59.47,149.44 61.88,149.44 62.35,148.97 v1(62.35,148.59)
LPSS_I2C1_SCL_TCHPNL: length 18.2
  TOP w0.1: R8E62.2 v1(40.25,131.57) ; 38.79,146.94 v1(39.49,146.94)
  LAY6 w0.125: v1(39.49,146.94) 39.11,146.56 39.11,143.61 39.6,143.13 39.6,137.24 39.33,136.98 39.33,134.16 40.77,132.71 40.77,132.09 v1(40.25,131.57)
LPSS_I2C1_SCL_USBC_PD: length 4
  TOP w0.1: Q8E9.2 39.85,132.84 40.35,133.35 R8E57.2
LPSS_I2C1_SDA: length 287
  TOP w0.089: 86.41,149.15 87.14,149.15 87.56,148.73 88.63,148.73 88.75,148.6 91.48,148.6 91.52,148.56 U6E1.BF21
  TOP w0.1: v1(62.35,147.83) 62.81,147.37 69.3,147.37 69.95,148.02 76.55,148.02 76.87,147.7 77.89,147.7 79.34,149.15 82.29,149.15 82.55,148.89 86.15,148.89 86.41,149.15 ; R8A12.2 49.14,274.95 48.13,275.97 v1(48.13,281.68) ; v1(42.79,128.01) R8F5.1 C8F1.1 R8F8.1
  LAY6 w0.125: v1(48.13,281.68) 48,281.56 24.38,281.56 22.45,279.63 18.41,279.63 13.47,274.69 11.58,274.69 9.99,273.1 9.99,265.2 9.41,264.61 9.41,258.7 8.98,258.27 8.98,251.26 6.93,249.2 6.93,245.3 J9B3.3 ; v1(40.51,150.62) 40.6,150.53 40.6,136.38 41.68,135.31 41.68,133.59 42.05,133.21 42.05,128.76 v1(42.79,128.01)
  BOTTOM w0.1: v1(62.35,147.83) 61.87,148.31 61.87,148.69 61.6,148.96 59.27,148.96 56.55,151.68 46.69,151.68 45.92,152.44 41.95,152.44 41.14,151.64 41.14,151.26 v1(40.51,150.62) 39.71,151.42 38.04,151.42 37.66,151.03 36.63,151.03 35.43,152.24 32.85,152.24 30.86,150.24 30.13,150.24 28.13,152.24 25.3,152.24 24.52,153.03 17.53,153.03 15.87,154.68 14.98,154.68 7.71,161.96 7.71,197.49 3.42,201.78 3.42,229.61 3.68,229.87 3.68,242.05 J9B3.3
LPSS_I2C1_SDA_TCHPNL: length 24
  TOP w0.1: R8F5.2 v1(40.38,128.01) ; Q8E6.3 v1(39.49,148.72)
  LAY6 w0.125: v1(40.38,128.01) 39.61,128.78 39.61,132.65 38.83,133.43 38.83,137.18 39.1,137.45 39.1,142.92 37.96,144.06 37.96,146.33 38.82,147.19 38.82,148.04 v1(39.49,148.72)
LPSS_I2C1_SDA_USBC_PD: length 6.3
  TOP w0.1: R8F8.2 38.34,126.24 37.33,127.24 Q8E10.2
LPSS_I2C2_SCL_AUDIO: length 106.7
  TOP w0.1: v1(18.92,181.61) 19.3,181.61 R9D12.2
  LAY5 w0.125: v1(16.25,252.73) 17.18,253.66 17.18,263.44 18.66,264.92 18.66,268.48 J9A5.1
  BOTTOM w0.1: v1(16.25,252.73) 15.62,252.73 14.19,251.3 8.65,251.3 7.43,250.08 7.43,231.56 10.14,228.85 10.14,227.39 9.46,226.71 9.46,220.21 4.95,215.69 4.95,203.43 9.93,198.45 9.93,192.85 18.92,183.87 v1(18.92,181.61)
LPSS_I2C2_SDA_AUDIO: length 112.6
  TOP w0.1: R9D16.2 19.17,180.85 v1(18.92,180.85)
  LAY5 w0.125: v1(16.25,251.97) 15.74,252.47 15.74,253.69 16.68,254.63 16.68,263.47 18.12,264.9 18.12,269.58 19.17,270.64 21.08,270.64 J9A5.2
  BOTTOM w0.1: v1(18.92,180.85) 19.43,181.35 19.43,183.85 10.28,193 10.28,198.59 6.39,202.48 6.39,204.55 5.46,205.48 5.46,215.7 9.9,220.15 9.9,226.57 10.5,227.16 10.5,229 7.78,231.71 7.78,249.94 8.79,250.95 14.47,250.95 15.49,251.97 v1(16.25,251.97)
LPSS_I2C3_SCL_TCHPNL: length 132.7
  TOP w0.1: Q8E8.3 v1(35.81,146.94) ; R8H30.2 57.27,50.8 v1(57.02,50.54)
  LAY5 w0.125: v1(57.02,50.54) 57.02,49.66 55.74,48.38 52.4,48.38 50.99,49.78 48.22,49.78 46.55,48.11 43.41,48.11 41.88,46.58 39.77,46.58 v1(38.73,47.62)
  LAY6 w0.125: v1(35.81,146.94) 35.81,142.47 37.34,140.94 37.34,138.18 37.07,137.91 37.07,124.11 37.98,123.2 37.98,113.17 36.57,111.75 36.57,110.74 36.05,110.23 36.05,103.11 35.77,102.83 35.77,98.21 36.09,97.89 36.09,94.53 36.17,94.46 36.17,93.09 35.54,92.46 35.54,90.37 35.25,90.08 35.25,88.23 36.08,87.4 36.08,78.45 39.13,75.4 39.13,70.32 37.72,68.91 37.72,66.79 38.48,66.04 38.48,58.45 43.69,53.24 43.69,51.89 39.42,47.62 v1(38.73,47.62)
LPSS_I2C3_SDA_TCHPNL: length 145.9
  TOP w0.1: v1(34.16,147.45) 34.16,147.79 Q8E5.3 ; R8H31.2 v1(61.34,50.8)
  LAY5 w0.125: v1(34.16,147.45) 31.21,147.45 27.75,143.98 27.75,133.51 32.76,128.5 32.76,125.94 37.66,121.04 37.66,115 34.92,112.27 34.92,109.25 v1(35.56,108.61) ; v1(37.94,47.62) 38.5,48.18 40.07,48.18 41.04,47.21 41.8,47.21 43.2,48.61 46.34,48.61 49.03,51.3 50.1,51.3 51.74,52.94 53.84,52.94 54.59,52.2 55.63,52.2 56.3,52.86 56.63,52.86 57.93,51.56 60.57,51.56 v1(61.34,50.8)
  LAY6 w0.125: v1(35.56,108.61) 35.43,108.48 35.43,105.27 34.99,104.83 34.99,100.43 34.24,99.67 34.24,96.77 35.04,95.97 35.04,90.58 34.75,90.29 34.75,88.03 35.58,87.2 35.58,78.24 38.1,75.73 38.1,69.99 37.22,69.12 37.22,66.59 37.98,65.83 37.98,57.39 40.13,55.24 40.13,52.96 41.27,51.81 41.27,50.67 40.51,49.91 40.23,49.91 v1(37.94,47.62)
LPSS_ISH_UART1_CTS_N: length 114.1
  TOP w0.1: v1(90.98,55.52) 90.95,55.5 90.29,55.5 89.78,54.99 86.86,54.99 R7H42.1 ; v1(93.72,147.83) 93.72,148.33 93.47,148.59 92.91,148.59 U6E1.BD21
  LAY8 w0.1: v1(93.72,147.83) 93.02,147.13 92.77,147.13 79.88,134.24 79.88,132.21 76.96,129.28 76.96,123.57 81.28,119.25 81.28,117.6 82.48,116.39 82.48,112.8 83.18,112.11 83.18,103 82.16,101.98 82.16,94.11 81.15,93.09 81.15,79.48 88.01,72.62 88.01,69.59 90.67,66.93 90.67,62.99 91.69,61.97 91.69,56.51 90.98,55.8 v1(90.98,55.52)
LPSS_ISH_UART1_RTS_N: length 114.8
  TOP w0.089: v1(95.29,147.81) U6E1.AW24
  TOP w0.1: R7H37.1 86.81,56.31 89.83,56.31 90.29,56.77 v1(90.98,56.77)
  LAY8 w0.1: v1(90.98,56.77) 91.46,57.25 91.46,61.88 90.45,62.9 90.45,66.83 87.78,69.5 87.78,72.52 80.92,79.38 80.92,93.18 81.94,94.2 81.94,102.07 82.95,103.09 82.95,112.01 82.26,112.71 82.26,116.3 81.05,117.51 81.05,119.16 76.7,123.5 76.7,131.38 77.81,132.49 78.39,132.49 79.5,133.6 79.5,134.18 92.23,146.91 92.23,147.79 92.72,148.29 94.82,148.29 v1(95.29,147.81)
LPSS_ISH_UART1_RXD: length 113.2
  TOP w0.089: v1(96.06,147.81) U6E1.AU24
  TOP w0.1: R7H26.1 86.86,58.8 89.78,58.8 90.29,59.31 v1(90.98,59.31)
  LAY8 w0.1: v1(96.06,147.81) 95.36,148.51 92.63,148.51 91.88,147.76 91.88,146.88 79.27,134.27 79.27,133.7 78.29,132.72 77.72,132.72 76.48,131.48 76.48,123.41 80.82,119.06 80.82,112.97 82.73,111.07 82.73,103.18 81.71,102.17 81.71,94.29 80.69,93.28 80.69,79.29 87.55,72.43 87.55,69.41 89.4,67.56 89.4,60.88 v1(90.98,59.31)
LPSS_ISH_UART1_TXD: length 116.4
  TOP w0.089: v1(97.41,149.25) 97.43,149.25 97.46,149.22 97.46,148.83 U6E1.AP21
  TOP w0.1: v1(90.98,58.04) 90.29,58.04 89.66,57.4 86.99,57.4 R7H32.1
  LAY8 w0.1: v1(90.98,58.04) 89.18,59.84 89.18,67.46 87.33,69.31 87.33,72.34 80.47,79.19 80.47,93.37 81.48,94.39 81.48,102.26 82.5,103.28 82.5,110.79 80.59,112.69 80.59,118.97 76.25,123.31 76.25,131.57 77.62,132.95 78.2,132.95 79.04,133.79 79.04,134.37 91.65,146.98 91.65,147.86 92.54,148.74 96.9,148.74 v1(97.41,149.25)
LPSS_UART0_CTS_N: length 189.9
  TOP w0.089: v1(97.58,147.81) U6E1.AP24
  TOP w0.1: R9J10.1 v1(22.22,26.03)
  LAY8 w0.1: v1(22.22,26.03) 23.36,27.18 23.36,56.84 20.11,60.1 20.11,81.84 19.73,82.22 19.73,97.08 21.33,98.68 21.33,107.69 22.73,109.09 22.73,112.14 29.59,119 29.59,121.16 39.11,130.68 39.11,143.28 v1(39.62,143.79)
  BOTTOM w0.1: v1(39.62,143.79) 41.23,143.79 42.19,144.75 54.52,144.75 55.98,146.21 64.24,146.21 64.45,146.43 78.98,146.43 79.41,145.99 81.2,145.99 81.78,145.41 82.61,145.41 83.3,146.11 86.47,146.11 86.61,145.97 90.57,145.97 91.41,146.81 96.58,146.81 v1(97.58,147.81)
LPSS_UART0_CTS_R_N: length 9.4
  TOP w0.1: J9J1.3 16.63,26.67 19.93,26.67 R9J10.2 20.57,25.78 20.82,25.53 22.86,25.53 R9J11.2
LPSS_UART0_RTS_N: length 186.6
  TOP w0.089: v1(94.53,147.81) U6E1.BA24
  TOP w0.1: R9J7.1 v1(22.22,27.3)
  LAY8 w0.1: v1(38.6,144.5) 38.6,143.25 38.88,142.97 38.88,130.78 29.36,121.25 29.36,119.09 22.5,112.23 22.5,109.19 21.1,107.79 21.1,98.77 19.5,97.17 19.5,82.13 19.88,81.75 19.88,60 23.14,56.75 23.14,28.22 v1(22.22,27.3)
  BOTTOM w0.1: v1(38.6,144.5) 39.08,144.97 54.16,144.97 55.63,146.43 64.14,146.43 64.36,146.65 78.52,146.65 78.8,146.94 81.4,146.94 82,146.34 82.93,146.34 83.15,146.56 86.86,146.56 87.22,146.2 90.37,146.2 91.18,147.01 93.73,147.01 v1(94.53,147.81)
LPSS_UART0_RTS_R_N: length 6.3
  TOP w0.1: R9J8.2 22.86,26.8 20.82,26.8 20.57,27.05 R9J7.2 19.93,27.94 J9J1.4
LPSS_UART0_RXD: length 182.4
  TOP w0.089: 85.06,148.31 85.56,148.31 86.18,147.69 88.23,147.69 88.35,147.57 91.72,147.57 91.8,147.65 92.11,147.65 92.34,147.88 U6E1.BE23
  TOP w0.1: v1(62.1,144.27) 64.02,146.19 69.79,146.19 70.44,146.84 75.93,146.84 76.32,146.46 77.78,146.46 79.87,148.55 81.66,148.55 81.91,148.31 85.06,148.31 ; R9J4.1 v1(22.22,28.57)
  LAY8 w0.1: v1(38.25,142.49) 37.87,142.11 37.87,131.53 34.92,128.58 34.92,127.13 29.13,121.34 29.13,119.19 22.27,112.33 22.27,109.28 20.88,107.88 20.88,98.87 19.28,97.26 19.28,82.03 19.65,81.65 19.65,59.91 22.91,56.65 22.91,29.26 v1(22.22,28.57)
  BOTTOM w0.1: v1(62.1,144.27) 56.64,144.27 55.37,143 47.71,143 47.23,142.52 45.65,142.52 45.09,141.96 38.78,141.96 v1(38.25,142.49)
LPSS_UART0_RXD_R: length 9.4
  TOP w0.1: R9J5.2 22.86,28.07 20.82,28.07 20.57,28.32 R9J4.2 19.81,29.34 16.51,29.34 J9J1.1
LPSS_UART0_TXD: length 183.9
  TOP w0.1: U6E1.BB24 93.54,147.27 v1(93.01,147.8) ; R9J2.1 v1(22.22,29.84)
  LAY8 w0.1: v1(38.6,145.2) 37.59,144.18 37.59,131.57 34.69,128.68 34.69,127.23 28.91,121.44 28.91,119.28 26,116.38 24.04,116.38 22.05,114.38 22.05,109.37 19.81,107.13 19.81,98.12 19.05,97.36 19.05,81.94 19.43,81.56 19.43,59.82 22.68,56.56 22.68,30.31 v1(22.22,29.84)
  BOTTOM w0.1: v1(38.6,145.2) 54.07,145.2 55.53,146.66 64.05,146.66 64.27,146.88 78.42,146.88 78.71,147.16 81.63,147.16 81.78,147.32 82.83,147.32 83.34,146.81 86.86,146.81 87.37,147.32 92.53,147.32 v1(93.01,147.8)
LPSS_UART0_TXD_R: length 6.3
  TOP w0.1: J9J1.2 19.93,30.48 R9J2.2 20.57,29.59 20.82,29.34 22.86,29.34 R9J3.2
LPSS_UART1_CTS_HDR_N: length 96.9
  TOP w0.1: 85.47,55.5 v1(84.78,55.5) ; v1(13.97,32.38) 10.54,28.95 6.09,28.95 J9H4.3
  BOTTOM w0.1: v1(13.97,32.38) 14.73,31.62 26.16,31.62 26.67,32.13 34.41,32.13 38.9,36.62 45.63,36.62 47.87,38.86 50.29,38.86 54.46,43.03 59.06,43.03 65.53,49.5 65.53,51.03 68.6,54.1 73.7,54.1 75.48,52.32 78.1,52.32 78.86,51.56 82.67,51.56 84.78,53.67 v1(84.78,55.5)
LPSS_UART1_RTS_HDR_N: length 94.9
  TOP w0.1: v1(13.97,33.27) 10.92,30.22 J9H4.4 ; R7H36.2 v1(84.78,56.77)
  BOTTOM w0.1: v1(84.78,56.77) 84.24,56.23 84.24,53.45 82.58,51.79 78.96,51.79 78.19,52.55 75.57,52.55 73.8,54.33 68.51,54.33 65.27,51.09 65.27,49.56 58.97,43.26 54.37,43.26 50.19,39.09 47.78,39.09 45.54,36.85 38.81,36.85 34.32,32.36 26.57,32.36 26.06,31.85 15.39,31.85 v1(13.97,33.27)
LPSS_UART1_RXD_HDR: length 100.9
  TOP w0.1: J9H4.1 5.96,33.91 12.72,33.91 13.61,34.8 v1(13.97,34.8) ; R7H25.2 v1(84.78,59.31)
  BOTTOM w0.1: v1(84.78,59.31) 84.78,58.87 83.79,57.88 83.79,53.64 82.39,52.24 79.14,52.24 78.38,53 75.76,53 73.98,54.78 68.32,54.78 65.58,52.04 64.56,52.04 64.13,51.61 64.13,50.67 61.84,48.39 61.84,48.07 60.86,47.08 60.86,45.79 60.12,45.06 57.56,45.06 56.22,43.72 54.18,43.72 50.01,39.54 47.59,39.54 46.5,38.45 39.77,38.45 34.13,32.81 26.38,32.81 25.88,32.3 23.51,32.3 21.52,34.29 20.7,34.29 19.17,35.81 14.98,35.81 v1(13.97,34.8)
LPSS_UART1_TXD_HDR: length 96.5
  TOP w0.1: v1(13.99,34.03) 12.72,32.76 J9H4.2 ; R7H32.2 v1(84.78,58.04)
  BOTTOM w0.1: v1(13.99,34.03) 16.38,34.03 16.76,33.65 18.41,33.65 18.79,34.03 21.46,34.03 23.42,32.07 25.97,32.07 26.48,32.58 34.22,32.58 35.68,34.04 35.68,34.04 39.87,38.23 46.6,38.23 47.69,39.31 50.1,39.31 54.27,43.49 56.31,43.49 57.65,44.83 60.22,44.83 61.08,45.69 61.08,46.99 61.46,47.37 62.76,47.37 65.05,49.66 65.05,51.19 68.41,54.55 73.89,54.55 75.67,52.78 78.29,52.78 79.05,52.01 82.48,52.01 84.02,53.55 84.02,57.27 v1(84.78,58.04)
LPSS_UART2_CTS_N: length 66.7
  TOP w0.089: U6E1.AV21 v1(95.96,149.25)
  BOTTOM w0.1: R8R12.1 R8R10.2 R8R11.1 37.97,147.45 39.87,147.45 41.14,146.18 42.16,146.18 43.05,147.06 44.87,147.06 47.72,149.91 52.34,149.91 52.7,150.28 53.42,150.28 53.79,149.91 56.32,149.91 58.18,148.05 60.35,148.05 60.47,147.93 60.47,147.48 60.84,147.11 63.86,147.11 64.08,147.33 78.24,147.33 78.52,147.62 81.13,147.62 82.04,148.54 82.82,148.54 84.04,147.32 86.61,147.32 87.24,147.95 91.18,147.95 91.82,148.59 95.3,148.59 v1(95.96,149.25)
LPSS_UART2_CTS_R_N: length 96.9
  TOP w0.1: U9C1.9 16.61,231.67 v1(15.74,232.54)
  LAY8 w0.1: v1(15.74,232.54) 13.97,230.76 13.97,215.64 14.35,215.26 14.35,204.55 15.95,202.94 15.95,193.78 24.28,185.45 24.28,181.77 26.31,179.74 26.31,170.34 28.53,168.12 28.53,157.44 33.4,152.58 v1(33.4,151.13)
  BOTTOM w0.1: v1(33.4,151.13) 33.52,151.13 35.68,148.97 R8R12.2
LPSS_UART2_CTS_TTK_N: length 109
  TOP w0.1: J7G1.11 68.36,66.34 v1(68.67,66.04)
  LAY8 w0.1: v1(68.67,66.04) 68.67,65.05 68.35,64.74 67.67,64.74 67.08,65.33 63.31,65.33 61.27,67.38 57.53,67.38 56.42,66.27 55.94,66.27 54.83,67.38 53.71,67.38 50.73,70.36 50.73,75.24 49.83,76.14 49.83,83.12 49.21,83.75 47.18,83.75 45.77,85.15 45.77,94.3 43.48,96.58 43.48,99.89 41.2,102.17 41.2,143.52 40.25,144.46 40.25,147.19 v1(39.49,147.95)
  BOTTOM w0.1: R8R11.2 v1(39.49,147.95)
LPSS_UART2_RTS_N: length 66.5
  TOP w0.089: U6E1.AW21 v1(95.23,149.44)
  BOTTOM w0.1: R8R5.1 R8R7.2 R8R4.1 37.46,150.52 38.13,151.19 39.05,151.19 40.25,149.99 41.02,149.99 43,148 45.34,148 47.48,150.14 52.24,150.14 52.61,150.5 53.52,150.5 53.88,150.14 56.42,150.14 58.27,148.28 60.45,148.28 60.7,148.03 60.7,147.57 60.93,147.34 63.13,147.34 63.35,147.56 78.14,147.56 78.42,147.84 80.99,147.84 81.97,148.82 82.86,148.82 83.35,148.33 85.59,148.33 86.09,147.84 86.85,147.84 87.16,148.16 91,148.16 91.77,148.93 94.99,148.93 95.23,149.16 v1(95.23,149.44)
LPSS_UART2_RTS_R_N: length 91
  TOP w0.1: 15.96,229.49 15.96,230.78 15.86,230.88 v1(15.74,230.88)
  LAY8 w0.1: v1(34.92,151.64) 34.13,152.43 33.87,152.43 28.76,157.54 28.76,168.21 26.54,170.43 26.54,179.83 24.51,181.86 24.51,185.55 16.18,193.87 16.18,203.83 14.98,205.03 14.98,215.39 15.74,216.15 v1(15.74,230.88)
  BOTTOM w0.1: R8R5.2 35.68,150.87 v1(34.92,151.64)
LPSS_UART2_RTS_TTK_N: length 110.5
  TOP w0.1: v1(69.89,66.01) 69.63,66.27 J7G1.13
  LAY8 w0.1: v1(39.03,150.49) 39.03,145.36 40.97,143.43 40.97,102.08 43.26,99.79 43.26,96.49 45.54,94.2 45.54,85.01 47.37,83.18 47.63,83.18 48.76,82.05 48.76,81.15 49.61,80.31 49.61,76.04 50.5,75.15 50.5,70.27 53.62,67.15 54.73,67.15 55.84,66.04 58.96,66.04 59.89,65.1 66.99,65.1 67.58,64.51 68.45,64.51 69.08,65.15 69.08,65.49 69.61,66.01 v1(69.89,66.01)
  BOTTOM w0.1: R8R4.2 v1(39.03,150.49)
LPSS_UART2_RXD: length 56.2
  TOP w0.089: U6E1.BD20 92.72,149.29 92.3,149.29 92.19,149.18 91.89,149.18 88.98,149.18 88.86,149.3 87.8,149.3 87.34,149.76 86,149.76
  TOP w0.1: v1(61.34,147.8) 60.96,148.18 60.96,148.72 62.23,149.99 69.08,149.99 69.18,149.89 70.19,149.89 70.45,150.14 73.43,150.14 73.77,149.8 76.9,149.8 77.03,149.93 78.15,149.93 78.33,149.76 82.75,149.76 83.01,149.5 85.74,149.5 86,149.76
  BOTTOM w0.1: R8R9.1 R8R6.2 R8R8.1 44.65,149.81 46.83,149.81 48.25,151.23 56.37,151.23 59.09,148.51 60.63,148.51 v1(61.34,147.8)
LPSS_UART2_RXD_R: length 106
  LAY8 w0.1: J9B6.3 11.59,230.59 11.59,212.28 12.16,211.71 12.16,194.34 20.7,185.8 20.7,179.2 21.97,177.93 21.97,170.81 25.78,167 25.78,158.94 32.76,151.96 32.76,151 33.14,150.62 36.7,150.62 38.2,152.12 43.08,152.12 43.81,151.38 43.81,150.75 v1(43.3,150.24)
  BOTTOM w0.1: R8R9.2 42.41,149.86 42.79,150.24 v1(43.3,150.24)
LPSS_UART2_RXD_TTK: length 106.1
  TOP w0.1: J7G1.7 65.82,66.49 v1(65.37,66.04)
  LAY8 w0.1: v1(65.37,66.04) 63.25,66.04 61.46,67.83 53.9,67.83 51.2,70.53 51.2,75.41 50.29,76.33 50.29,83.31 49.4,84.2 47.37,84.2 46.22,85.34 46.22,94.49 43.94,96.77 43.94,100.07 44.57,100.71 44.57,106.04 41.65,108.96 41.65,143.23 42.64,144.22 42.64,147.55 44.44,149.35 v1(45.89,149.35)
  BOTTOM w0.1: R8R8.2 v1(45.89,149.35)
LPSS_UART2_TXD: length 53.7
  TOP w0.089: 85.52,149.3 85.92,149.3 86.18,149.55 87.28,149.55 87.72,149.11 88.78,149.11 88.9,148.99 91.81,148.99 91.81,148.99 92.27,148.99 92.33,149.06 U6E1.BE20
  TOP w0.1: 85.52,149.3 82.93,149.3 82.67,149.55 78.3,149.55 77.72,148.97 64.26,148.97 64.13,149.1 62.02,149.1 v1(61.41,148.49)
  BOTTOM w0.1: R8R2.1 R8R3.2 R8R1.1 44.65,151.43 45.41,151.43 45.51,151.33 45.51,150.95 45.72,150.75 46.35,150.75 47.06,151.46 56.46,151.46 59.18,148.74 61.16,148.74 v1(61.41,148.49)
LPSS_UART2_TXD_R: length 106.4
  LAY8 w0.1: v1(43.3,151) R8R2.2 38.29,151.89 36.79,150.39 33.05,150.39 32.53,150.91 32.53,151.86 25.55,158.85 25.55,166.91 21.74,170.72 21.74,177.83 20.47,179.1 20.47,185.71 11.93,194.24 11.93,211.2 11.36,211.77 11.36,226.63 5.58,232.41 J9B5.3
  BOTTOM w0.1: R8R2.2 42.41,151.64 43.05,151 v1(43.3,151)
LPSS_UART2_TXD_TTK: length 110
  TOP w0.1: v1(67.18,66.04) 67.09,66.13 J7G1.9
  LAY8 w0.1: v1(45.97,151.2) 42.41,147.65 42.41,144.52 41.42,143.54 41.42,108.84 41.46,108.84 44.35,105.95 44.35,100.8 43.71,100.17 43.71,96.68 46,94.39 46,85.25 47.27,83.97 49.3,83.97 50.06,83.22 50.06,76.23 50.96,75.33 50.96,70.45 53.81,67.6 61.36,67.6 63.41,65.56 66.7,65.56 v1(67.18,66.04)
  BOTTOM w0.1: R8R1.2 45.46,151.89 45.97,151.38 v1(45.97,151.2)
LS_PRE: length 2.6
  TOP w0.1: EU2A7.27 252.85,267.33 251.58,268.6 R2A37.1
LS_REXT: length 3.4
  TOP w0.1: R2A68.2 252.22,262 252.22,263.27 252.68,263.73 EU2A7.36
LSPCON_VDD33_AUX: length 1.4
  TOP w0.3: v1(240.41,265.99) 240.01,266.39 U3A5.C5
  BOTTOM w0.3: v1(240.41,265.99) R3L2.2
M2_SSD_DAS_DSS: length 11.2
  TOP w0.1: DS8H1.2 45.58,58.3 44.45,59.43 40.64,59.43 v1(40.51,59.31) ; v1(40.13,62.23) 40.27,62.37 J8H1.10
  LAY6 w0.125: v1(40.51,59.31) 40.76,59.56 40.76,61.59 v1(40.13,62.23)
M2_SSD_LED_PU: length 1.6
  TOP w0.203: DS8H1.1 47.49,58.29 R8H6.2
M2_SSD_PWREN: length 179.3
  TOP w0.089: 93.81,164.21 94.16,164.21 95.37,162.99 97.33,161.04 97.33,160.77 97.33,159.02 97.38,158.97 97.38,158.12 97.29,158.03 97.29,158.02 97.29,158.02 97.29,157.64 97.06,157.4 U6E1.AR3
  TOP w0.1: v1(67.05,185.55) 67.42,185.91 79.33,185.91 80.56,184.68 83.29,184.68 86.48,181.48 86.48,180.34 85.59,179.45 86.48,178.56 86.48,177.89 92.45,171.92 92.45,164.97 93.22,164.21 93.81,164.21 ; v1(47.37,72.64) 48.89,71.12 R8G70.1
  LAY5 w0.125: v1(67.05,185.55) 66.42,185.55 63.11,182.24 63.11,180.31 62.1,179.3 62.1,175.26 61.72,174.88 61.72,170.43 62.73,169.42 62.73,167.51 63.52,166.73 63.52,163.56 60.96,161 60.96,159.38 57.8,156.23 57.8,132.52 57.54,132.25 57.54,127.52 v1(55.24,125.22)
  LAY6 w0.125: v1(47.37,72.64) 47.37,73.66 47.87,74.16 47.87,79.15 46.24,80.78 46.24,94.13 47.61,95.5 47.61,97.4 48.38,98.17 48.38,104.65 47.11,105.91 47.11,109.45 55.24,117.58 v1(55.24,125.22)
M.2_BT_PCMCLK: length 132.2
  TOP w0.1: R9B19.2 v1(15.24,243.71) ; J7C1.8 v1(75.45,228.07)
  LAY6 w0.125: v1(15.24,243.71) 16.63,245.11 16.63,247.14 17.91,248.42 17.91,256.71 16.99,257.63 16.99,259.25 17.39,259.66 17.39,263.65 18.16,264.42 18.16,270.08 19.09,271.01 20.09,271.01 21.2,272.12 21.2,273.82 21.8,274.42 23.52,274.42 24.05,274.95 26.11,274.95 29.79,271.26 37.71,271.26 38.32,271.87 41.69,271.87 43,273.18 61.59,273.18 64,270.76 v1(64,270.64)
  BOTTOM w0.1: v1(64,270.64) 64,270.25 65.77,268.49 65.77,262.4 64.13,260.76 64.13,252.98 72.13,244.98 72.13,244.51 75.94,240.7 75.94,230.38 74.93,229.36 74.93,228.6 v1(75.45,228.07)
M.2_BT_PCMFRM_CRF_RST_N: length 133.9
  TOP w0.1: J7C1.10 77.87,228.57 v1(78.1,228.34) 78.86,227.58 R7B82.1 ; R9B17.2 v1(15.24,245.36)
  LAY6 w0.125: v1(15.24,245.36) 15.74,245.87 15.74,249.81 17.41,251.48 17.41,256.5 16.49,257.43 16.49,259.46 16.89,259.87 16.89,263.86 17.66,264.63 17.66,267.44 17.14,267.97 17.14,269.69 17.53,270.08 17.53,270.94 18.1,271.51 19.88,271.51 20.7,272.33 20.7,274.03 21.59,274.92 23.31,274.92 23.84,275.45 26.97,275.45 30.05,272.37 41.49,272.37 42.79,273.68 62.11,273.68 65.15,270.64 v1(65.65,270.64)
  BOTTOM w0.1: v1(78.1,228.34) 78.61,228.85 78.61,231.27 77.37,232.51 77.37,241.29 73.56,245.1 73.56,245.57 67.31,251.82 67.31,253.49 66.51,254.29 66.51,260.24 67.2,260.93 67.2,269.18 65.74,270.64 v1(65.65,270.64)
M.2_BT_PCMIN: length 139.3
  TOP w0.1: R9B27.2 v1(15.24,240.54) ; J7C1.12 v1(75.47,229.07)
  LAY6 w0.125: v1(15.24,240.54) 14.09,241.68 14.09,251.71 15.88,253.5 15.88,256.28 15.49,256.67 15.49,270.33 15.88,270.72 15.88,272.49 18.81,275.42 19.97,275.42 20.97,276.42 22.69,276.42 23.22,276.95 27.59,276.95 30.37,274.17 32.25,274.17 32.79,274.7 62.86,274.7 v1(64,273.56)
  BOTTOM w0.1: v1(75.47,229.07) 75.47,229.23 76.42,230.18 76.42,240.9 72.61,244.71 72.61,245.18 64.61,253.18 64.61,260.44 64.77,260.6 65.53,260.6 66.25,261.32 66.25,268.68 64.61,270.32 64.61,272.95 v1(64,273.56)
M.2_BT_PCMOUT_CLKREQ0: length 138.3
  TOP w0.1: J7C1.14 77.76,229.57 v1(78.1,229.23) 78.74,228.6 R7B79.1 ; R9B23.2 v1(15.24,242.06)
  LAY6 w0.125: v1(15.24,242.06) 14.59,242.7 14.59,245.74 15.24,246.39 15.24,250.01 16.91,251.68 16.91,253.46 16.38,254 16.38,256.53 15.99,256.92 15.99,270.12 16.53,270.66 16.53,271.35 18.19,273.01 18.19,274.06 19.05,274.92 20.18,274.92 21.18,275.92 22.9,275.92 23.42,276.45 27.39,276.45 30.17,273.67 32.46,273.67 32.99,274.2 62.47,274.2 63.62,273.05 64.38,273.05 v1(64.89,273.56)
  BOTTOM w0.1: v1(64.89,273.56) 65.08,273.37 65.08,270.52 66.72,268.88 66.72,261.12 66.04,260.44 66.04,252.42 73.08,245.38 73.08,244.9 76.89,241.09 76.89,230.44 v1(78.1,229.23)
M.2_BT_RF_KILL_N: length 11.1
  TOP w0.1: Q7B8.3 84.58,242.12 84.58,240.28 R7B50.1 83.56,239.9 83.05,239.39 82.16,239.39 81.17,240.38 78.46,240.38 77.64,239.57 J7C1.54
M.2_BTWIFI_SUS_CLK: length 138.5
  TOP w0.1: v1(73.02,117.22) 73.27,117.47 R7F21.2 ; v1(83.43,238.12) 82.67,238.89 81.78,238.89 81.28,239.39 78.81,239.39 77.99,238.57 J7C1.50
  LAY5 w0.125: v1(84.83,203.07) 85.84,202.06 85.84,198.2 85.22,197.58 85.22,172.71 87.37,170.56 87.37,168.02 85.37,166.02 85.37,154.88 82.79,152.3 82.79,149.47 81.4,148.08 81.4,146.02 82.29,145.13 82.29,137.69 80.02,135.41 80.02,129.68 79.83,129.49 79.83,124.16 73.53,117.86 73.53,117.73 v1(73.02,117.22)
  LAY6 w0.125: v1(83.43,238.12) 84.57,236.99 84.57,223.18 84.98,222.76 84.98,205.74 85.34,205.39 85.34,203.58 v1(84.83,203.07)
M.2_CLINK_CLK_WLAN: length 68.9
  TOP w0.1: J7C1.42 v1(75.46,236.57) ; v1(75.82,184.33) 75.91,184.42 78.71,184.42 80.06,183.07 82.74,183.07 R7D15.2
  BOTTOM w0.1: v1(75.82,184.33) 75.82,185.6 73.96,187.46 73.96,222.53 71.12,225.37 71.12,231.01 73.19,233.09 73.19,236.12 74.15,237.07 74.96,237.07 v1(75.46,236.57)
M.2_CLINK_DATA_WLAN: length 70.7
  TOP w0.1: v1(74.67,236.6) 74.61,236.54 74.61,236.4 74.94,236.07 J7C1.40 ; v1(75.81,182.75) 76.22,183.16 78.31,183.16 79.57,181.89 81.91,181.89 83.43,180.37 83.43,179.45 83.69,179.2 R7D30.2
  BOTTOM w0.1: v1(75.81,182.75) 76.29,183.23 76.29,185.79 74.43,187.65 74.43,222.73 72.35,224.81 72.35,231.4 73.67,232.72 73.67,235.93 74.34,236.6 v1(74.67,236.6)
M.2_CLINK_RST_WLAN_N: length 71.2
  TOP w0.1: J7C1.38 v1(75.44,235.57) ; v1(75.82,181.74) 76.32,181.74 76.79,182.21 77.91,182.21 79.18,180.94 81.51,180.94 82.48,179.97 82.48,179.06 82.74,178.8 82.74,177.48 83.56,176.66 R7D37.2
  BOTTOM w0.1: v1(75.44,235.57) 74.93,236.09 74.51,236.09 74.14,235.73 74.14,232.53 72.83,231.21 72.83,225.01 74.91,222.92 74.91,187.85 76.77,185.99 76.77,182.69 v1(75.82,181.74)
M.2_REFCLK0: length 4
  TOP w0.1: R7B41.1 R7B45.1 78.22,242.07 J7C1.64
M.2_SSD_P0_RX_DN: length 165.2
  TOP w0.1: v1(31.53,51.59) 31.53,51.75 31.32,51.96 31.01,51.96 30.79,52.18 30.79,52.67 31.52,53.39 31.52,53.57 R8H14.1 ; U6E1.K43 v1(109.95,138.09)
  BOTTOM w0.089: 109.47,135.13 109.53,135.19 109.55,135.19 109.71,135.35 109.71,137.34 109.85,137.48 109.85,137.99 v1(109.95,138.09)
  BOTTOM w0.1: 109.47,135.13 109.09,134.74 109.09,132.25 109.65,131.69 109.65,129.2 117.95,120.9 117.95,113.33 118.61,112.67 118.61,108.69 119.7,107.6 119.7,97.04 108.51,85.85 108.23,85.85 105.42,83.05 105.42,80.56 103.81,78.95 103.81,76.63 92.45,65.28 82.04,65.28 81.32,64.56 67.94,64.56 63.77,60.4 62.27,60.4 61.39,59.52 61.39,57.61 56.3,52.52 53,52.52 51.73,51.25 50.46,51.25 49.32,50.11 44.99,50.11 43.6,48.71 32.31,48.71 30.99,50.03 30.99,51.79 31.09,51.89 31.23,51.89 v1(31.53,51.59)
M.2_SSD_P0_RX_DP: length 165.2
  TOP w0.1: R8H15.1 31.72,53.57 31.72,53.31 30.99,52.59 30.99,52.26 31.09,52.16 31.31,52.16 v1(31.53,52.39) ; U6E1.K44 v1(110.28,137.39)
  BOTTOM w0.089: v1(110.28,137.39) 110.03,137.39 109.9,137.26 109.9,135.27 109.63,135 109.63,135 109.61,134.98
  BOTTOM w0.1: 109.61,134.98 109.61,134.99 109.29,134.66 109.29,132.33 109.85,131.77 109.85,129.28 118.15,120.98 118.15,113.42 118.81,112.76 118.81,108.77 119.9,107.68 119.9,96.96 108.59,85.65 108.31,85.65 105.62,82.97 105.62,80.48 104.01,78.87 104.01,76.55 92.53,65.08 82.12,65.08 81.41,64.36 68.02,64.36 63.85,60.2 62.35,60.2 61.59,59.43 61.59,57.53 56.38,52.32 53.08,52.32 51.81,51.05 50.54,51.05 49.4,49.91 45.08,49.91 43.68,48.51 32.22,48.51 30.79,49.94 30.79,51.87 31.01,52.09 31.23,52.09 v1(31.53,52.39)
M.2_SSD_P0_RX_R_DN: length 2.9
  TOP w0.1: J8H1.43 32.02,56.17 32.17,56.02 32.17,55.88 32.07,55.78 31.87,55.78 31.51,55.42 31.51,55.01 R8H14.2
M.2_SSD_P0_RX_R_DP: length 2.9
  TOP w0.1: J8H1.41 32.52,56.17 32.37,56.02 32.37,55.79 32.15,55.58 31.95,55.58 31.71,55.34 31.71,55.03 R8H15.2
M.2_SSD_P0_TX_C_DN: length 1.3
  TOP w0.1: R8H13.1 29.97,53.82 29.97,53.34 C8H10.2
M.2_SSD_P0_TX_C_DP: length 1.3
  TOP w0.1: C8H9.2 29.77,53.27 29.77,53.79 R8H9.2
M.2_SSD_P0_TX_CMC_DN: length 3.4
  TOP w0.1: R8H13.2 29.93,54.8 29.93,55.33 30.18,55.58 30.65,55.58 30.87,55.79 30.87,56.02 31.02,56.17 J8H1.47
M.2_SSD_P0_TX_CMC_DP: length 3.3
  TOP w0.1: R8H9.1 29.73,54.75 29.73,55.41 30.09,55.78 30.57,55.78 30.67,55.88 30.67,56.02 30.52,56.17 J8H1.49
M.2_SSD_P0_TX_DN: length 160.7
  TOP w0.088: 116.35,135.81 116.35,136.49 114.53,138.3 114.05,138.3 U6E1.A42
  TOP w0.1: C8H10.1 30.1,52.07 30,51.97 30,51.68 v1(30.3,51.39) ; 116.35,135.81 116.35,134.47 118.36,132.46 118.36,130.68 121.36,127.68 123.7,127.68 124.23,127.15 124.23,122.2 121.53,119.51 121.53,117.35 122.55,116.33 122.55,108.96 116.56,102.97 115.94,102.97 v1(115.64,102.67)
  BOTTOM w0.1: v1(115.64,102.67) 115.34,102.97 115.2,102.97 114.24,102.01 114.24,97.98 107.06,90.8 106.03,90.8 102.38,87.15 102.38,86.4 98.02,82.04 97.52,82.04 93.09,77.61 93.09,75.94 87.81,70.66 81.23,70.66 80.41,71.49 77.83,71.49 76.89,70.55 64.86,70.55 61.87,67.56 60.7,67.56 59.15,66.01 58.57,66.01 56.43,63.88 55.37,63.88 51.36,59.87 49.23,59.87 48.66,59.31 46,59.31 43.33,56.64 33.02,56.64 29.93,53.55 29.93,51.56 30.1,51.39 v1(30.3,51.39)
