# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+V3P3_LAN_FOX: length 145.9
  TOP w0.2: v1(98.93,260.48) 98.8,260.48 98.58,260.69 EU7A3.23 ; EU7A3.43 90.74,262.69 90.37,263.07 v1(90.29,263.07) ; EU7A3.7 94.26,256.78 94.26,255.3 v1(94.1,255.14) ; v1(93.42,265.17) 93.08,264.84 EU7A3.39 ; v1(95.4,264.49) 95.48,264.4 EU7A3.33 ; v1(97.8,255.87) 97.8,255.91 97.66,256.05 97.66,256.23 EU7A3.14
  TOP w0.203: EU7A3.47 v1(90.32,261.09) ; EU7A3.53 v1(90.32,258.69)
  TOP w0.38: R7A1.1 v1(62.73,286.38) ; v1(88.9,251.46) 88.9,252.22 R7B9.1 R7B10.1 ; R6B9.1 102.59,254.51 v1(102.87,254.79) ; R7A12.1 v1(81.4,259.21) v1(80.39,259.21) 75.81,259.21 75.05,259.97 R7A10.1 ; C6A23.1 102.94,276.68 R6A34.2 ; 91.94,241.55 91.94,240.79 91.95,240.79 95.63,240.79 96.01,241.17 99.44,241.17 99.76,240.85 105.08,240.85 105.53,241.3 R6B23.1 R6B22.1 R6B21.1 ; 91.94,241.55 C7B13.1 R7B39.1 ; 91.94,241.55 94.41,241.55 U6B1.8 ; R7B39.1 90.8,242.44 90.04,243.2 R7B34.1 ; R7B39.1 91.82,242.44 v1(92.07,242.7) ; R6A72.1 98.42,266.19 v1(98.1,265.87) ; v1(32.51,231.39) v1(32.51,232.15) ; R7B12.1 92.96,252.09 v1(92.96,251.66)
  TOP w0.5: v1(102.87,256.92) 102.74,257.05 R6B5.1 R6B2.1 ; v1(95.47,251.66) 95.5,251.69 R7B13.1 R7B14.1
  TOP w0.508: v1(32.51,232.15) 32.63,232.28 R8B29.1
  LAY5 w1: 76.16,261.56 76.16,263.64 74.88,264.92 69.08,264.92 68.07,263.9 64.26,263.9
  LAY6 w0.5: v1(93.42,265.17) 92.25,266.34 89.05,266.34 88.13,265.43 88.13,263.52
  BOTTOM w0.35: v1(90.32,261.09) 90.46,261.24 C7L7.1 ; v1(94.1,255.14) 94.23,255.27 94.23,256.54 C7M6.1 C7M7.1 ; C6L5.1 98.8,260.35 v1(98.93,260.48) 98.93,260.22 98.17,259.46 C6M1.1 ; C7M2.1 90.7,258.32 v1(90.32,258.69) ; C7M4.1 96.77,256.41 97.32,255.87 v1(97.8,255.87) 97.8,256.78 C6M2.1 ; C7L5.1 90.37,263.14 v1(90.29,263.07)
  BOTTOM w0.38: v1(92.07,242.7) 93.72,244.35 93.72,247.65 95.47,249.4 v1(95.47,251.66) ; C7L4.1 95.5,264.39 v1(95.4,264.49) 95.07,264.49 94.48,263.9 C7L2.1 ; v1(93.42,265.17) 92.83,265.17 C7L1.1 ; v1(100.71,278.38) 98.17,275.84 92.45,275.84 86.99,281.3 86.99,283.21 85.34,284.86 64.26,284.86 v1(62.73,286.38)
  vias: v1(39.11,262.51) v1(39.11,261.8) v1(87.04,262.61) v1(87.75,257.4)
+V3P3_LAN_FOX_R: length 1.1
  TOP w0.1: 105.41,277.75 105.28,277.87
  TOP w0.5: 105.28,277.87 R6A34.1
+V3P3_LAN_R: length 1.9
  TOP w0.38: 176.4,254.38 R4B10.1 175.51,255.4
+V3P3_PMON: length 355.9
  TOP w0.203: 284.73,146.68 284.59,146.54 U1E3.A4 ; 291.32,162.67 U1E1.A4 ; 284.22,156.34 284.08,156.2 U1E2.A4 ; U4H1.A4 189.83,55.22 189.99,55.37 ; U3H2.A4 229.98,55.36 ; 203.31,54.48 U4H2.A4 ; 219.31,55.37 U3H1.A4
  TOP w0.38: R1D16.1 295.14,162.69 295.52,162.3 295.52,157.86 293.49,155.83 288.54,155.83 ; 284.73,146.68 285.11,147.06 R1E30.2 ; C1D12.1 291.84,163.19 291.32,162.67 ; 286.89,147.95 286.89,149.22 ; 286.89,149.22 288.54,150.87 288.54,155.83 ; 286.89,149.22 286.89,149.6 286.13,150.37 278.38,150.37 ; R4H32.1 198.93,53.08 v1(198.37,53.64) ; 288.54,155.83 287.9,156.46 R1E15.1 ; C4H6.1 203.83,55 203.31,54.48 ; 284.22,156.34 284.6,156.72 C1E3.1 ; v1(214.37,61.21) 214.37,54.61 R3H25.1 ; R1E3.1 286.25,161.16 ; R2E5.1 279.01,154.94 278.38,154.3 278.38,150.37 ; C4H4.1 190.73,56.12 189.99,55.37 ; 278.38,150.37 278.38,146.43 279.52,145.29 R1E34.1
  TOP w0.5: 229.98,55.36 231.39,56.77 C3H2.1 ; 193.02,55.6 195.8,55.6 197.76,53.64 v1(198.37,53.64) ; C3H3.1 219.83,55.89 219.31,55.37
  TOP w0.508: 285.75,157.61 C1E3.1 ; 285.75,157.61 286,157.61 286.89,156.72 R1E15.1 ; 285.75,157.61 285.49,157.86 285.49,160.4 286.25,161.16 ; R1E30.2 v1(286,147.95) 286.89,147.95 287.4,147.45 R1E31.1 ; v1(226.82,59.82) R3H10.1 225.93,58.04 223.39,55.5 R3H21.1 R3H18.2 R3H17.2 C3H3.1 ; R5J2.1 R5J1.1 v1(169.79,31.88) ; R4H24.1 185.27,55.75 v1(185.27,56.26) ; R4H28.1 206.12,55.88 v1(204.59,57.4) 204.59,56.26 204.08,55.75 C4H6.1 ; C4H4.1 C4H5.1 v1(193.02,56.64) R4H25.1 ; R3H23.1 232.79,57.15 ; 232.79,57.15 v1(232.79,59.82) ; 232.79,57.15 C3H2.1 ; C1D12.1 293.62,163.83 294.13,163.32 R1D16.1
  LAY5 w0.38: v1(193.02,56.64) 185.65,56.64 v1(185.27,56.26) 178.32,56.26 173.11,51.05 v1(169.29,51.05)
  LAY5 w0.5: v1(214.37,61.21) 224.91,61.21 226.31,59.82 v1(226.82,59.82) v1(232.79,59.82) 233.18,60.2 247.13,60.2 250.96,64.03 253.51,64.03 254.12,64.64 255.42,64.64 256.03,64.03 267.74,64.03 271.28,67.57 275.34,67.57 278.52,70.76 280.85,70.76 281.86,71.76 281.86,75.76 282.76,76.66 285.29,76.66 288.52,79.89 288.52,79.89 290.06,81.43 290.06,97.53 290.95,98.42 290.95,99.57 290.49,100.03 290.49,117.42 290.94,117.87 290.94,119.62 290.54,120.01 290.54,137.51 291.59,138.56 291.59,139.83 291.08,140.33 289.22,140.33 286.3,143.25 285.36,143.25 284.6,144.01 284.6,146.56 v1(286,147.95)
  LAY6 w0.5: v1(214.37,61.21) 211.96,58.8 197.73,58.8 194.81,55.88 193.78,55.88 v1(193.02,56.64)
  BOTTOM w0.38: v1(169.29,51.05) 169.29,50.42 168.91,50.04 168.91,32.76 v1(169.79,31.88)
  BOTTOM w0.5: v1(204.59,57.4) 202.94,55.75 200.48,55.75 v1(198.37,53.64)
+V3P3_PPV: length 46.6
  TOP w0.38: R8J5.1 v1(52.83,25.27) ; U8J2.8 v1(62.86,26.54) ; R7J10.1 65.02,26.41 v1(65.4,26.03) ; R8J7.1 53.08,24 v1(52.83,24.26) ; v1(52.83,26.54) R8J3.1
  TOP w0.5: v1(52.83,26.54) 52.83,27.05 51.05,28.83 J8J1.2 ; C7J3.1 R7J10.1
  LAY5 w0.5: v1(52.83,26.54) 53.15,26.22 61.08,26.22 61.4,26.54 v1(62.86,26.54) 62.99,26.41 65.02,26.41 v1(65.4,26.03)
  LAY6 w0.5: v1(52.83,26.54) v1(52.83,25.27) v1(52.83,24.26) ; v1(65.4,26.03) 65.15,26.03 64.64,25.53 64.64,16.89 64,16.25 64,14.1 64.64,13.46 64.64,8.23 J8J13.39
+V3P3_SLOTE: length 3.1
  TOP w0.38: v1(83.31,241.04) R7B46.1 R7B49.1 ; R7B25.2 77.14,246.96 77.21,246.89
  vias: v1(78.35,225.3) v1(78.35,224.15) v1(80.01,246.76) v1(80.89,246.76)
+V3P3_SLOTE_R: length 1.7
  TOP w0.5: R7B25.1 R7B17.2
+V3P3_SLOTM: length 31.8
  TOP w0.38: 44.57,60.83 44.57,60.2 45.97,58.8 R8H6.1 46.1,59.05 46.48,59.43 47.87,59.43 48.38,58.93 48.38,55.24 45.21,52.07 43.68,52.07 40.89,49.27 38.6,49.27 v1(36.95,47.62) ; R8H51.1 v1(37.71,43.18) ; 47.11,63.5 47.19,63.57 R8G86.2 48.26,62.36
  LAY6 w0.38: v1(37.71,43.18) 37.71,44.07 36.95,44.83 v1(36.95,47.62)
+V3P3_SLOTM_LS: length 2.2
  TOP w0.3: 47.75,66.04 47.75,65.53 R8G86.1 48.26,66.04
+V3P3A: length 1723.8
  TOP w0.17: U8D5.6 v1(41.89,171.59)
  TOP w0.18: U8D11.5 35.4,171.93 35.56,172.08 C8D27.1 ; 34.16,201.55 34.16,202.18 34,202.34 U8C3.5 ; C8D29.1 37.46,170.18 37.24,170.4 U8D8.5 ; 155.41,201.9 155.41,201.08 ; U8D9.5 28.41,172.18 27.75,172.85 27.05,172.85 C8D25.1
  TOP w0.2: U8D10.5 33.24,171.86 v1(32.63,172.46) ; U5D1.6 152.67,193.4 ; v1(150.03,157.73) 150.11,157.65 150.11,156.36 150.62,155.85 150.62,154.94 R5E56.1
  TOP w0.25: C8A2.1 33.4,283.51 33.13,283.25 U8A1.1 ; v1(31.75,226.44) 32.39,227.09 U8B3.1
  TOP w0.3: U5E1.5 157.74,157.22 156.84,158.13 C5E3.1 156.47,157.87 150.17,157.87 v1(150.03,157.73)
  TOP w0.305: v1(40,172.85) 40.14,172.71 U8D6.2 ; U2G2.1 249.46,75.98 C2G25.1 ; 33.52,72.52 33.8,72.24 EU8G3.15
  TOP w0.38: R8B20.2 v1(46.48,239.77) ; R8G5.1 v1(42.67,95.5) ; v1(48.13,170.43) C8D28.1 47.37,169.8 47,169.43 U8D12.5 ; v1(27.05,210.95) 26.54,210.95 R8C34.1 26.28,210.44 25.9,210.06 23.41,210.06 20.23,206.88 v1(18.66,206.88) ; v1(43.94,193.67) R8D4.1 R8D3.1 ; 52.83,66.29 R8G85.1 51.94,65.66 ; v1(38.22,169.8) C8D29.1 ; R9C15.1 14.93,205.94 16.56,205.94 v1(17.14,205.36) R9C17.1 ; v1(66.04,234.19) 66.8,234.19 R7B69.2 ; Q7B7.1 R7B36.1 v1(88.13,244.27) ; v1(18.41,47.75) 21.71,51.05 R8H77.1 ; C8D25.1 27.05,173.35 28.44,173.35 29.08,173.99 v1(29.46,173.99) ; R8J15.1 v1(58.8,21.21) ; R5G13.1 168.27,91.57 v1(168.4,91.44) ; v1(32.25,164.06) 32.28,164.08 R8D88.1 ; R8C61.1 50.29,200.81 R8C57.1 ; R8C61.1 50.8,200.79 51.05,201.04 R8C60.1 ; R8C61.1 50.29,200.76 v1(50.29,200.02) ; v1(62.48,49.78) R7H47.2 ; R8D67.1 48.25,174.49 48.25,173.83 v1(48.03,173.61) 48.03,173.23 47.65,172.85 R8D94.1 ; v1(28.95,188.72) 29.21,188.47 R8D15.1 ; R4J5.1 v1(174.87,7.58) ; R6A24.1 105.28,281.94 v1(105.28,282.57) ; R8C63.1 R8C64.1 44.55,200.13 v1(44.55,199.39) ; R6A87.1 104.01,284.48 v1(103.5,283.97) ; R8J17.1 v1(58.8,16.25) ; R7B76.2 v1(89.66,229.87) ; R7B81.1 v1(89.66,227.84) ; U8C2.5 41.52,208.15 C8C17.1 R8C38.1 40,207.26 v1(40.13,207.14) ; v1(88.13,240.66) R7B44.1 Q7B8.1 ; R8E2.1 40.38,161.19 v1(40.1,160.91) ; v1(117.09,35.28) 117.24,35.43 R6H37.1 ; R8G6.1 v1(37.71,94.36) ; v1(41.55,186.43) 41.21,186.43 C8D8.1 ; v1(34.79,172.46) C8D27.1 ; R8E65.1 v1(42.79,130.68) ; J6J2.5 v1(111.07,14.68) ; R5J5.1 v1(137.16,22.1) ; R5J4.1 145.66,25.78 v1(145.66,26.03) 145.79,26.16 C5J1.1 J5J1.17 ; R6J8.1 v1(131.31,24.13) ; v1(62.56,153.8) 62.48,153.8 61.84,153.16 C7E8.1 ; R5C50.1 153.67,201.42 154.68,202.44 v1(154.81,202.44) C5C34.1 ; v1(37.59,174.12) 37.59,173.73 R8D68.1 ; v1(115.44,176.66) 115.44,177.16 R6D51.1 114.68,177.93 114.68,178.05 R6D48.1 ; 33.52,72.52 33.14,72.52 32.51,71.88 C8G13.1 v1(31.87,72.64) ; R6F2.1 v1(99.06,116.28) ; R8D79.1 v1(32.25,168.15) ; J6J2.4 v1(111.07,16.97) ; C5C34.1 155.57,202.06 155.41,201.9 ; C5C34.1 155.7,202.44 156.18,202.92 156.18,203.55 156.71,204.09 157.35,204.09 157.6,204.34 v1(158.06,204.34) ; J9H3.4 J9H3.1 ; v1(140.2,112.39) 140.08,112.27 R5F10.1 ; R8G52.1 v1(32.38,77.6) ; v1(79.88,146.46) 80.41,146.46 R7E21.1 R7E19.1 ; v1(81.78,151.41) 82.39,151.41 82.42,151.38 ; R6F21.1 R6F25.2 113.91,107.31 113.55,106.95 113.55,104.01 112.79,103.25 109.6,103.25 v1(109.02,102.68) ; R5C33.1 v1(165.73,207.26) ; v1(41.78,24.38) 41.78,24.26 R8J8.1 ; R8D81.1 v1(34.67,168.15) ; v1(153.59,193.98) 153.56,193.95 152.8,193.95 C5D1.1 152.78,193.51 152.67,193.4 ; R6A85.1 v1(104.26,278.84) ; 62.73,94.23 62.61,94.36 R8G8.2 ; R6J23.1 v1(132.58,9.78) ; C8A2.1 v1(34.08,284.35) ; v1(87.12,225.55) 86.99,225.42 R7C6.1 87.37,223.9 87.88,223.39 87.88,222.5 85.59,220.22 83.69,220.22 82.29,221.61 82.29,227.33 81.5,228.12 81.5,229 v1(80.89,229.61) R7B77.2 ; v1(22.09,20.95) 21.33,20.95 21.33,19.94 22.22,19.05 22.22,17.65 23.74,16.13 23.74,11.68 22.41,10.35 v1(22.41,7.05) ; R6F8.1 v1(104.9,114.81) ; R8J10.1 v1(34.92,24.26) ; v1(72.51,248.79) 72.51,249.17 R7B20.1 71.5,249.17 v1(71.5,248.79) ; R5A25.1 148.84,273.18 149.35,273.68 R5A20.1 ; R2D1.2 v1(266.82,164.85) ; R8C81.1 v1(57.37,196.21) ; v1(33.65,198.5) C8C21.1 34.16,201.17 34.16,201.55 ; C7F4.1 v1(91.69,124.2) ; v1(32.76,203.33) 32.51,203.58 R8C50.1 R8C49.1 ; C6A7.1 v1(109.65,283.34) 109.71,283.34 110.1,282.94 U6A2.1 ; R7G15.1 v1(68.73,80.9)
  TOP w0.5: J9H3.4 19.05,41.02 22.22,41.02 24.4,43.2 27.55,43.2 28.4,42.35 29.01,42.35 30.03,41.34 30.03,38.07 31.87,36.23 31.87,31.24 30.6,29.97 30.6,25.02 26.03,20.45 v1(26.03,18.79) ; v1(72.51,43.81) 65.78,43.81 63.62,45.97 63.62,48.64 v1(62.48,49.78) ; v1(150.03,157.73) 149.6,157.73 147.94,159.39 141.29,159.39 132.08,168.61 132.08,170.18 133.22,171.32 R6D63.1 ; v1(71.62,123.47) 71.85,123.7 R7F8.1
  TOP w0.508: R6F18.1 v1(109.6,108.2) ; R6F11.1 v1(110.87,112.39) ; R7E50.1 v1(70.23,134.24) ; C2G25.1 248.25,75.18 248.03,75.41 v1(248.03,76.07) R2G23.2 ; v1(64.82,198.25) 64,198.25 R7C37.1 ; R7E42.1 v1(70.23,137.16)
  TOP w1: 143.1,275.97 148.22,275.97 149.6,274.59 R5A20.1
  LAY5 w0.38: v1(87.12,225.55) 87.63,225.04 89.02,225.04 90.29,226.31 90.29,227.2 v1(89.66,227.84) 90.42,228.6 98.04,228.6 v1(99.44,227.2) ; v1(110.87,112.39) 110.87,110.23 R6F18.1 v1(109.6,108.2) ; v1(145.66,26.03) 145.66,25.78 R5J4.1 143,25.02 140.71,22.73 137.79,22.73 v1(137.16,22.1) ; v1(31.87,72.64) 31.87,75.31 33,76.44 33,77.22 32.62,77.6 v1(32.38,77.6) 31.75,78.23 31.75,79.25 33.78,81.28 33.78,83.82 34.79,84.83 v1(34.79,86.1) ; v1(285.62,95.5) 285.31,95.5 283.29,93.48 282.46,93.48 278.12,89.15 278.12,83.41 273.07,78.36 272.08,78.36 266.61,72.89 253.89,72.89 253.13,72.13 249.04,72.13 248.03,73.15 v1(248.03,76.07) ; v1(79.88,146.46) 79.88,148.39 81.07,149.58 v1(81.07,151.41) ; v1(66.04,234.19) 66.29,234.19 67.05,233.42 67.05,232.54 71.5,228.09 74.54,228.09 75.18,227.46 78.61,227.46 80.77,229.61 v1(80.89,229.61) ; v1(158.06,204.34) 159.08,205.36 163.7,205.36 164.84,206.5 165.48,206.5 165.73,206.75 v1(165.73,207.26)
  LAY5 w0.5: v1(140.2,112.39) 139.57,113.03 137.28,113.03 135.02,115.29 131.59,115.29 v1(131.44,115.44) ; v1(215.01,42.92) 215.64,43.56 215.64,45.08 211.38,49.34 205.26,49.34 204.34,48.42 201.71,48.42 196.05,42.76 187.75,42.76 185.43,40.45 176.32,40.45 172.44,36.57 169.32,36.57 166.75,34 166.75,25.31 v1(157.31,15.87) 151.6,10.16 146.55,10.16 146.04,9.65 140.2,9.65 139.57,9.02 133.35,9.02 v1(132.58,9.78) ; v1(67.31,18.79) v1(58.8,18.79) ; v1(59.05,64.85) 56.05,64.85 54.61,66.29 51.56,66.29 51.33,66.06 v1(51.3,66.06) ; v1(28.95,188.72) 39.11,188.72 41.4,186.43 v1(41.55,186.43) ; v1(139.44,97.15) 139.35,97.25 134.2,97.25 121.23,84.28 115.38,84.28 112.85,86.81 107.78,86.81 106.25,85.28 103.18,85.28 95.78,77.88 v1(95.24,77.88) ; v1(76.2,150.49) 76.45,150.75 76.45,162.18 v1(76.58,162.3) ; J8J13.13 36.38,5.97 23.49,5.97 v1(22.41,7.05)
  LAY5 w0.508: v1(76.2,150.49) 76.2,144.02 76.07,143.89 v1(76.07,143.87) ; v1(43.94,193.67) 46.92,193.67 48.57,195.33 56.51,195.33 57.37,196.19 v1(57.37,196.21) ; v1(34.79,86.87) 34.79,89.79 36.57,91.57 36.57,93.22 v1(37.71,94.36) ; v1(93.09,122.96) 93.09,122.93 93.47,122.55 93.47,117.6 96.6,114.47 96.6,110.95 v1(95.75,110.11) ; v1(42.79,130.68) 41.86,131.62 41.86,145.74 42.5,146.39 42.5,147.11 41.91,147.7 41.91,148.13 41.52,148.51 41.52,159.49 v1(40.1,160.91) ; v1(50.29,200.02) 49.53,199.26 47.11,199.26 46.99,199.39 v1(44.55,199.39) 42.01,196.85 39.62,196.85 39.24,196.47 37.21,196.47 36.95,196.72 34.29,196.72 33.65,197.36 v1(33.65,198.5) 33.65,201.17 32.76,202.06 v1(32.76,203.33)
  LAY5 w0.75: v1(72.51,248.79) 72.64,248.92 77.59,248.92 78.53,247.98 80.94,247.98 83.82,245.11 84.96,245.11 85.8,244.27 v1(88.13,244.27)
  LAY5 w1: v1(72.51,248.79) v1(71.5,248.79) 69.13,251.16 52.74,251.16 52.39,250.81 v1(46.7,250.81) v1(45.7,250.81)
  LAY6 w0.38: v1(137.16,22.1) 136.52,22.73 132.2,22.73 131.31,23.62 v1(131.31,24.13) ; 154.55,202.44 154.08,202.91 154.08,206.54 155.17,207.62 155.17,208.41 152.81,210.77 152.81,213.65 156.33,217.17 156.33,218.18 153.28,221.23 153.28,225.76 151.27,227.77 151.27,231.68 152.52,232.93 152.52,235.58 v1(152.14,235.96) ; v1(285.62,95.5) 284,97.12 284,134.17 283.69,134.48 283.69,139.98 280.16,143.51 280.16,145.96 278.07,148.05 278.07,149.71 276.04,151.74 276.04,155.12 266.82,164.34 v1(266.82,164.84) ; v1(99.44,227.2) 98.49,226.25 98.49,201.99 105.53,194.94 105.53,188.86 115.44,178.96 v1(115.44,176.66)
  LAY6 w0.5: v1(103.12,109.73) 104.9,109.73 105.91,110.74 108.58,110.74 110.23,112.39 v1(110.87,112.39) 109.34,113.92 105.79,113.92 v1(104.9,114.81) ; v1(62.48,49.78) 61.21,49.78 60.37,50.62 60.37,54.32 61.59,55.54 61.59,58.58 61.15,59.02 61.15,60.04 59.05,62.14 v1(59.05,64.85) ; v1(139.44,97.15) 138.55,98.04 138.55,103.21 138.05,103.71 137.59,103.71 137.21,104.08 137.21,105.88 139.31,107.99 139.31,109.22 140.08,109.98 140.08,112.27 v1(140.2,112.39) ; v1(154.81,202.44) 154.55,202.44 153.67,201.55 153.67,199.01 154.3,198.37 154.94,198.37 155.53,197.77 155.53,197.07 154.3,195.83 154.3,194.66 153.61,193.98 v1(153.59,193.98) 153.59,193.95 153.41,193.78 153.41,187.32 152.4,186.31 152.4,183.26 153.16,182.5 153.16,177.67 152.78,177.29 152.78,173.47 153.28,172.97 154.3,172.97 154.68,172.59 154.68,171.96 154.3,171.58 153.91,171.58 153.06,170.73 153.06,169.67 153.44,169.29 153.44,168.56 152.45,167.56 152.45,165.04 152.33,164.92 152.33,162.74 151.57,161.99 150.93,161.99 150.03,161.08 v1(150.03,157.73) 150.41,158.11 151.38,158.11 151.89,157.61 151.89,156.69 151.27,156.07 151.27,155.33 150.44,154.51 150.44,150.99 144.39,144.95 144.39,138.81 142.87,137.29 142.87,134.11 140.19,131.43 140.19,131.05 137.92,128.78 137.92,124.43 132.89,119.4 132.89,117.91 131.44,116.46 v1(131.44,115.44)
  LAY6 w0.508: v1(48.03,173.61) 48.03,173.46 48.1,173.38 48.1,170.46 v1(48.13,170.43) ; v1(99.06,116.28) 99.51,115.82 102.97,115.82 103.99,114.81 v1(104.9,114.81)
  LAY6 w1: 34.41,285.24 36.06,286.89 56,286.89 60.32,282.57 60.32,280.03 62.86,280.03 64.51,281.68 68.96,281.68 70.61,283.34 81.53,283.34 83.18,281.68 86.48,281.68 92.32,287.53 97.4,287.53 101.98,282.95 104.26,282.95 104.39,283.08
  BOTTOM w0.2: C8N1.1 30.32,208.44 31.32,208.44
  BOTTOM w0.25: R5M15.1 151.51,235.46 152.01,235.96 v1(152.14,235.96)
  BOTTOM w0.38: v1(152.14,235.96) 152.52,235.96 R5M13.1 ; 75.43,168.27 75.56,168.15 R7P6.1 ; v1(174.87,7.58) 171.7,10.75 J4J3.1 ; R5V8.1 137.6,38.04 137.6,36.19 ; v1(132.58,9.78) 133.6,10.79 133.6,18.54 v1(137.16,22.1) 137.79,21.46 139.31,21.46 139.95,22.1 139.95,26.92 137.6,29.27 137.6,36.19 ; R6T11.1 v1(110.87,112.39) ; v1(117.09,35.28) 117.37,35.28 118.74,33.91 133.73,33.91 136.01,36.19 137.6,36.19 ; R6T3.1 105.02,114.93 v1(104.9,114.81) ; v1(30.65,210.49) 30.58,210.56 R8N1.1 ; v1(215.01,42.92) 219.83,47.75 232.02,47.75 244.98,60.7 244.98,73.02 v1(248.03,76.07) ; R5V1.1 143.25,38.23 143.25,37.08 142.36,36.19 137.6,36.19 ; 110.35,100.2 109.85,100.69 109.85,101.85 v1(109.02,102.68) 108.83,102.87 R6T20.1 107.95,103.25 107.95,108.46 R6T13.2 R6T15.1 108.83,108.96 v1(109.6,108.2) ; v1(97.53,105.03) 97.53,106.04 R7T25.1 ; v1(27.05,210.95) 27.17,210.95 29.33,208.79 29.97,208.79 C8N1.1 ; v1(58.8,18.79) v1(58.8,16.25) ; v1(105.28,282.57) 105.28,280.92 104.26,279.91 v1(104.26,278.84) ; v1(42.67,95.5) 41.17,94.01 39.21,94.01 38.86,94.36 v1(37.71,94.36) ; v1(89.66,229.87) v1(89.66,227.84) ; v1(26.03,18.79) 25.9,18.67 22.98,18.67 22.09,19.56 v1(22.09,20.95) ; v1(18.66,206.88) v1(17.14,205.36) ; J9H3.1 16.51,43.56 16.51,46.99 17.27,47.75 v1(18.41,47.75) ; v1(139.44,97.15) 140.08,96.52 146.43,96.52 147.32,97.41 158.62,97.41 159.33,96.7 166.31,96.7 167.13,95.88 167.13,92.71 v1(168.4,91.44)
  BOTTOM w0.5: v1(111.07,16.97) v1(111.07,14.68) ; v1(111.07,16.97) 112.13,18.03 116.58,18.03 117.72,16.89 118.87,16.89 119.88,15.87 123.31,15.87 129.03,10.16 129.03,9.65 129.66,9.02 131.82,9.02 v1(132.58,9.78) ; v1(111.07,16.97) 108.37,16.97 105.79,19.56 104.39,19.56 103.75,18.92 101.21,18.92 100.71,19.43 87.63,19.43 86.86,18.67 85.59,18.67 82.41,21.85 77.07,21.85 74.39,19.18 67.69,19.18 v1(67.31,18.79) ; v1(72.51,43.81) 72.51,39.88 66.73,34.1 66.23,34.1 62.1,29.97 62.1,23.37 59.94,21.21 v1(58.8,21.21) ; v1(157.31,15.87) 168.91,15.87 J4J3.1 ; v1(76.2,150.49) 76.12,150.49 74.8,151.81 72.59,151.81 71.71,152.69 67.01,152.69 64.89,150.57 R7R32.1 63.37,149.6 62.86,150.11 v1(60.83,150.11) ; v1(58.8,21.21) 56.51,23.49 53.72,23.49 52.83,22.6 43.56,22.6 v1(41.78,24.38) 40.89,23.49 35.68,23.49 v1(34.92,24.26) 33.08,22.41 28,22.41 26.03,20.45 v1(26.03,18.79) ; v1(58.8,21.21) v1(58.8,18.79) ; R7T23.1 95.5,109.85 v1(95.75,110.11)
  BOTTOM w0.508: v1(41.52,168.15) 41.52,170.05 43.18,171.7 45.33,171.7 45.97,171.07 47.49,171.07 v1(48.13,170.43) ; R7R2.1 v1(76.58,162.3) ; v1(29.46,173.99) 30.98,172.46 v1(32.63,172.46) ; v1(89.66,229.87) 89.66,230.38 90.42,231.14 90.42,231.9 88.85,233.47 88.85,235.48 89.49,236.12 89.49,239.31 v1(88.13,240.66) 88.9,241.43 88.9,243.51 v1(88.13,244.27) ; v1(98.29,108.71) 99.06,107.95 R6T17.1 ; v1(76.2,150.49) R7R25.1 ; R6T14.1 103.25,109.85 v1(103.12,109.73) ; R7R43.1 v1(76.07,143.87)
  BOTTOM w0.58: R7T2.1 v1(93.09,122.96)
  BOTTOM w1: 58.8,278.16 58.8,272.03 63.32,267.51 63.32,263.35 61.46,261.49 53.97,261.49 48.7,256.22 48.19,256.22 45.72,253.74 45.72,252.24 45.7,252.22 v1(45.7,250.81) ; 64,72.9 60.38,72.9 54.03,66.55 52.83,66.55
  vias: v1(31.11,284.35) v1(31.11,283.59) v1(34.95,225.93) v1(34.95,225.22) v1(34.95,224.51) v1(40.76,168.15) v1(51.3,65.3) v1(59.43,279.65) v1(59.43,278.89) v1(60.32,200.79) v1(60.45,202.82) v1(61.08,192.91) v1(62.86,94.74) v1(62.86,93.98) v1(62.86,93.22) v1(63.62,191.13) v1(63.62,190.37) v1(63.62,94.74) v1(63.62,93.98) v1(63.62,93.22) v1(64.38,94.74) v1(64.38,93.98) v1(64.38,93.22) v1(73.91,169.67) v1(73.91,168.91) v1(74.67,169.67) v1(74.67,168.91) v1(75.89,75.54) v1(76.6,75.54) v1(106.04,282.57) v1(133.3,280.41) v1(134.23,280.41)
+V3P3A_1P8A_EC: length 3.8
  TOP w0.203: U8F6.43 16.89,100.69
  TOP w0.381: R9F34.1 16.25,101.22 16.78,100.69 16.89,100.69
  TOP w0.5: C9F4.1 15.36,100.2 15.62,100.46 R9F34.1
+V3P3A_1P8A_EC_MIX: length 2.7
  TOP w0.5: R9F31.2 R9F33.2 13.33,101.47 13.58,101.22 R9F34.2
+V3P3A_1P8A_ESPI: length 6.5
  TOP w0.38: v1(97.28,26.8) 96.13,27.94 J7J1.15
  BOTTOM w0.508: v1(97.28,26.8) 97.15,26.92 C7W1.1 96.01,27.05 R7W1.2 R7W2.2
+V3P3A_1P8A_R_SNSR_HDR: length 463.6
  TOP w0.38: 54.48,50.67 54.22,50.93 R8H29.1 55.09,51.43 v1(55.11,51.41)
  TOP w0.5: v1(105.79,278.76) 105.91,278.89 105.91,279.53 R6A24.2 ; R6A24.2 105.02,279.14 v1(105.02,278.76) ; R6A24.2 107.06,279.78 R6A31.2
  LAY5 w1: 99.94,277.62 98.79,276.46 88.35,276.46 87.35,277.45 52.49,277.45 50.67,279.27 v1(49.78,279.27) v1(48.76,279.27)
  LAY6 w0.75: 54.12,21.44 53.62,21.94 53.62,43.46 54.61,44.45 54.61,45.59
  BOTTOM w0.75: v1(54.73,19.79) v1(54.73,20.57) 54.73,20.83 53.84,21.72 40.38,21.72 39.49,22.6 35.3,22.6 34.29,21.59 34.29,15.11 31.36,12.19 22.22,12.19 17.9,7.87 11.17,7.87 2.93,16.12 2.93,135.58 2.55,135.96 2.55,162.82 4.95,165.23 4.95,199.47 2.87,201.55 2.87,272.43 3.73,273.28 9.27,273.28 11.07,275.08 18.92,275.08 22.09,278.26 22.09,280.92 24.89,283.72 29.21,283.72 31.49,281.43 45.72,281.43 47.87,279.27 v1(48.76,279.27) v1(49.78,279.27)
  vias: v1(55.11,50.67)
+V3P3A_1P8A_SNSR_HDR: length 74
  TOP w0.38: 52.78,52.07 R8H29.2 52.07,51.43 ; R7H62.1 R7H66.1 75.05,41.65 73.71,40.31 71.83,40.31 71.13,41 U7H2.2 ; 52.05,67.44 52.05,67.49 51.57,67.96 U8G2.2
  TOP w0.5: R7H51.1 v1(66.04,50.8)
  TOP w0.508: v1(77.08,51.81) 77.68,51.22 77.68,50.5 77.26,50.09 77.26,46.02 R7H62.1 ; 52.83,55.88 52.19,55.88 49.4,58.67 49.4,61.9 51.19,63.69 51.19,64.38 50.54,65.02 50.54,66.42 50.92,66.8 51.41,66.8 52.05,67.44 v1(52.19,67.44) ; R8G49.1 52.24,78.74 v1(52.04,78.53) 51.84,78.74 R8G48.1
  LAY5 w0.508: v1(66.04,50.8) 65.78,50.54 62.23,50.54 61.76,50.08 61.04,50.08 60.07,51.05 57.79,51.05 56.9,51.94 56.26,51.94 55.88,51.56
  LAY6 w0.508: v1(52.04,78.53) 52.04,78.48 51.58,78.03 51.58,73.02 51.94,72.66 51.94,69.47 52.19,69.22 v1(52.19,67.44)
  BOTTOM w0.508: v1(66.04,50.8) 68.91,53.67 73.52,53.67 75.38,51.81 v1(77.08,51.81)
  vias: v1(51.94,52.2)
+V3P3A_1P8A_SPI: length 150.9
  TOP w0.38: v1(87.28,60.96) 87.41,61.09 R7H15.1 ; v1(100.07,30.5) 100.07,24.64 103.82,20.89 CR6J1.3 ; v1(70.71,78.36) 70.71,77.49 71.69,76.51 73.34,76.51 74.04,75.82 75.31,75.82 75.64,76.15 77.02,76.15 77.69,76.82 78.92,76.82 79.74,75.99 81.14,75.99 81.74,76.6 82.5,76.6 83.56,75.54 v1(83.56,75.31)
  TOP w0.5: J7G1.36 83.6,73.62 C7G13.1 C7G11.1 v1(83.56,75.31) ; R7H20.1 R7H19.1 v1(88.68,60.83)
  TOP w0.508: v1(78.23,91.95) 77.97,92.2 CR7G2.1 77.14,92.25 CR7G1.1 ; C7G8.1 87.71,77.21 88.4,76.53 89.15,76.53 89.66,77.04 R7G23.1 90.42,77.21 90.72,77.52 R7G26.2 92.78,77.52 95.37,74.93 95.37,64.9 92.07,61.59 R7H20.1 ; C7G8.1 v1(87.5,78) 87.52,78.03 U7G4.2 87.52,80.87 86.82,81.57 EU7G3.8 88.39,83.73 88.39,86.46 89.02,87.1 v1(89.4,87.1) ; C7G8.1 C7G7.1
  LAY5 w0.5: v1(87.5,78) 86.84,77.34 85.72,77.34 85.61,77.24 85.58,77.24 85.19,76.85 85.19,76.56 83.94,75.31 v1(83.56,75.31)
  LAY6 w0.38: v1(70.71,80.26) 70.1,79.65 70.1,78.97 v1(70.71,78.36)
  BOTTOM w0.38: R7U35.1 v1(70.71,78.36) ; R7U33.1 v1(70.71,80.26) ; v1(87.28,60.96) 88.55,60.96 v1(88.68,60.83) 92.07,60.83 94.48,58.42 94.48,53.21 96.13,51.56 99.18,51.56 100.82,49.93 100.82,42.48 98.55,40.21 98.55,36.96 100.07,35.43 v1(100.07,30.5)
  BOTTOM w0.508: v1(78.23,91.95) 79.5,91.95 80.76,90.68 82.28,90.68 83.31,89.66 86.1,89.66 88.67,87.1 v1(89.4,87.1)
+V3P3A_1P8A_SPI_R: length 2.3
  TOP w0.5: U7G4.3 88.79,77.24 R7G23.2
+V3P3A_1P8A_SPI_TPM: length 6.6
  TOP w0.5: R7G26.1 92.2,76.07 C7G9.1 C7G10.1 91.56,75.06 91.31,74.8 R7G35.1 91.32,74.03 J7G2.18
+V3P3A_1P8A_SPI_TPM_R: length 2.7
  TOP w0.5: R7G35.2 92.71,73.36 92.49,73.15 J7G1.50
+V3P3A_PCH_VAL: length 271.2
  TOP w0.5: R7C50.1 77.08,195.58 v1(76.32,194.82)
  TOP w1: 60.7,166.88 61.21,166.88 65.53,171.19 74.1,171.19 ; 103.75,93.09 113.41,93.09 117.85,88.64 118.74,88.64 119.25,88.14 123.06,88.14 125.47,90.55 125.47,114.43 130.42,119.38 v1(133.85,119.38) v1(134.87,119.38)
  TOP w2: 76.83,104.52 74.16,104.52 72.39,106.3 70.39,106.3 63.25,113.43 61.98,113.43 59.18,116.24 59.18,128.12 59.96,128.9 59.96,131.61 57.63,133.94 57.63,138.76 56.41,139.98 56.41,142.08 54.73,143.76 54.73,145.41
  LAY5 w0.5: v1(76.83,169.54) 76.83,170.69 77.34,171.19 77.34,175.77 76.45,176.66 76.45,178.43 78.23,180.21 78.23,181.61 77.33,182.51 77.33,185 74.92,187.41 74.92,193.03 76.32,194.44 v1(76.32,194.82)
  LAY5 w0.508: v1(75.18,143.87) 75.18,150.37 v1(75.05,150.49) ; v1(90.29,119.51) 91.69,118.11 91.69,114.42 93.84,112.27 v1(95.75,112.27)
  LAY5 w0.75: 75.56,152.02 75.56,163.32
  LAY6 w0.508: v1(102.99,112.65) 102.99,112.27 100.71,109.98 98.04,109.98 v1(95.75,112.27) 92.58,112.27 91.94,111.63 89.91,111.63 89.4,111.12 85.85,111.12 81.91,107.19 81.91,106.23 80.83,105.15 79.52,105.15 v1(79.5,105.13)
  LAY6 w1: 57.37,165.32 57.37,163.29 56.38,162.3 56.38,150.37 54.99,148.97
  BOTTOM w0.5: R7T21.1 95.5,112.52 v1(95.75,112.27) ; v1(75.05,150.49) 75.05,150.67 74.55,151.17 72.34,151.17 71.45,152.06 67.9,152.06 66.42,150.57 R7R31.1
  BOTTOM w0.508: R7P5.1 77.59,168.78 v1(77.34,169.04) ; R7R44.1 74.93,143.62 v1(75.18,143.87) ; R6T10.1 v1(102.99,112.65) ; v1(75.05,150.49) R7R26.1
  BOTTOM w0.58: R7T5.1 v1(90.29,119.51)
  BOTTOM w1: 99.82,94.23 98.55,95.5 94.75,95.5 92.12,98.13 87.93,98.13 87.67,98.39 83.52,98.39 83.18,98.04 82.29,98.04
  vias: v1(54.22,146.94) v1(54.22,146.18) v1(56.89,166.37) v1(57.65,166.37) v1(78.35,105.13) v1(78.35,104.39) v1(79.5,104.39) v1(101.72,93.47) v1(101.72,92.45) v1(102.74,93.47) v1(102.74,92.45) v1(162.05,189.58) v1(162.81,189.58)
+V3P3A_PCH_VAL_OUT: length 5.5
  TOP w0.3: R8E42.1 52.38,140.71 52.88,141.22 52.88,143.88 52.5,144.26 C8E8.1
+V3P3A_PCIEAUX: length 51.2
  TOP w0.38: 36.06,234.44 36.01,234.49 R8B30.2 33.41,234.49 ; v1(134.67,237.23) 134.79,237.36 C5B22.1
  LAY5 w1: 117.34,233.3 115.57,233.3 114.5,234.36 108.26,234.36 102.5,228.6 100.56,228.6 98.86,230.3 95.45,230.3 94.1,231.65 91.44,231.65 89.91,233.17 83.94,233.17 82.42,234.69 82.42,235.2 81.4,236.22 79.24,236.22 76.83,238.63
  vias: v1(37.59,235.58) v1(37.59,234.82) v1(38.48,235.58) v1(53.46,237.01) v1(53.46,236.29) v1(72.51,238.76) v1(73.4,238.76) v1(134.67,238)
+V3P3A_SNSR_HDR: length 2.2
  TOP w0.38: 52.83,63.12 R8G85.2 C8H2.1
+V3P3A_USBC: length 577.8
  TOP w0.203: EU6D1.28 130.42,187.07 130.3,187.2 ; 130.3,180.08 130.42,180.21 EU6D1.1 ; EU6D1.6 132.42,179.87
  TOP w0.28: v1(137.16,268.48) 137.3,268.33 EU5A1.5
  TOP w0.35: R6D23.1 130.37,188.97 129.48,188.09 C6D13.1
  TOP w0.38: 136.9,184.4 R5D11.1 ; 136.9,184.4 137.66,185.16 137.66,186.43 137.16,186.94 135.76,186.94 135.25,186.43 C5D8.1 ; 136.9,184.4 136.9,183.51 R5D12.1 ; v1(145.54,264.16) 145.54,263.27 147.06,261.75 R5A55.1 ; 130.3,180.08 130.04,179.83 128.9,179.83 C6D16.1 128.65,179.96 128.01,179.32 127.12,179.32 126.87,179.07 126.87,177.8 ; R6D37.1 v1(124.2,181.35) ; 132.42,179.87 132.42,179.61 132.69,179.35 132.69,178.84 C6D17.1 132.96,178.61 133.3,178.94 v1(133.3,179.22) ; C6D13.1 130.3,187.2 ; R6A56.1 R6A60.1 118.99,269.49 118.61,269.11 v1(118.61,268.73) ; 126.87,177.8 126.61,177.8 v1(124.71,179.7) ; 126.87,177.8 127,177.67 R6D46.1 127.63,176.91 128.27,176.27 128.77,176.27 129.41,176.91 R6D47.1 ; v1(137.16,268.48) 136.65,268.98 C5A26.1 ; 137.66,181.61 136.9,180.85 R5D15.1 ; R7C42.1 90.67,197.23 91.82,198.37 v1(92.22,198.37) ; R7C42.1 R7C46.1 ; R7C42.1 R7C41.1 ; R6D24.1 133.22,189.53 134.18,190.5 R5D6.1 134.23,191.01 v1(133.98,191.26) ; R9G24.1 v1(23.36,77.47) ; R6D35.1 v1(124.2,183.51)
  TOP w0.5: R6D23.1 130.42,189.43 129.76,190.09 129.76,190.65 128.65,191.77 128.65,193.85 129.26,194.46 133.07,194.46 134.36,193.17 134.36,191.64 v1(133.98,191.26) ; v1(136.27,175.11) 135.61,175.11 134.11,173.61 132.96,173.61 131.69,172.34 129.54,172.34 128.27,173.61 128.27,176.27
  TOP w0.508: R5D27.2 v1(136.27,175.11)
  LAY5 w0.38: v1(124.2,183.51) 124.84,182.88 124.84,181.99 v1(124.2,181.35) 124.71,180.85 v1(124.71,179.7) ; v1(24.51,54.61) 25.52,54.61 26.67,53.47 33.27,53.47 34.03,54.23 44.57,54.23 45.84,55.5 45.84,56 47.26,57.42 47.79,57.42 49.56,59.18 53.08,59.18 54.32,60.42 65.85,60.42 67.8,62.37 69.44,62.37 70.08,63.01 72.62,63.01 73.02,62.61 73.78,62.61 77.6,66.42 82.56,66.42 88.77,72.64 89.63,72.64 92.54,75.54 92.54,77.05 94.23,78.74 95.37,78.74 102.74,86.1 105.91,86.1 107.44,87.63 114.04,87.63 115.57,86.1 117.67,86.1 119.63,88.06 119.63,91.44 118.88,92.19 118.88,107.3 117.93,108.25 117.93,110.72 117.22,111.43 117.22,113.64 120.4,116.83 129.28,116.83 135.88,123.43 135.88,129.15 139.19,132.46 140.46,132.46 142.36,134.36 142.36,157.71 136.49,163.58 136.49,171.61 135.66,172.44 135.66,174.52 136.25,175.11 v1(136.27,175.11)
  LAY5 w0.5: v1(83.82,266.44) 83.92,266.55 88.85,266.55 88.95,266.65 92.88,266.65 93.49,266.04 94.38,266.04 95.04,266.7 96.77,266.7 96.9,266.56 100.44,266.56 100.93,267.05 109.37,267.05 111.05,268.73 114.93,268.73 115.14,268.94 118.4,268.94 v1(118.61,268.73) ; v1(133.3,179.22) 134.46,180.39 134.46,186.08 v1(133.98,186.56) 134.01,186.59 134.01,191.24 v1(133.98,191.26) 135,192.28 135,205.01 134.18,205.83 134.18,211.13 128.49,216.82 121.95,216.82 117.11,211.99 97.44,211.99 94.42,215.01 92.96,215.01 v1(92.45,214.5) 92.07,214.5 83.79,222.78 82.7,222.78 81.15,221.23 80.01,221.23 v1(77.97,223.26)
  LAY6 w0.38: v1(23.36,77.47) 24.24,76.6 24.24,75.62 23.97,75.36 23.97,70.84 23.11,69.98 23.11,64.29 24.91,62.49 24.91,61.08 23.59,59.76 23.59,55.52 v1(24.51,54.61)
  LAY6 w0.5: v1(83.82,266.44) 82.29,264.92 82.29,259.08 77.97,254.76 77.97,240.16 78.86,239.27 78.86,227.58 77.59,226.31 77.59,223.65 v1(77.97,223.26)
  BOTTOM w0.38: 135.25,260.98 126.49,260.98 125.73,260.22 124.07,260.22 123.57,260.73 123.57,263.65 124.2,264.29 124.2,265.76 123.71,266.25 120.58,266.25 120.26,265.94 117.34,265.94 116.96,266.32 116.96,267.21 118.49,268.73 v1(118.61,268.73) ; 135.25,260.98 135.25,262.38 134.23,263.4 134.23,266.13 133.5,266.87 133.5,268.12 134.11,268.73 136.9,268.73 v1(137.16,268.48) ; 135.25,260.98 140.33,260.98 140.97,261.62 143.76,261.62 145.54,263.4 v1(145.54,264.16) ; v1(92.22,198.37) 92.22,204.77 92.45,205 v1(92.45,214.5)
+V3P3A_V1P8A_SPI_DIODE: length 13.2
  TOP w0.375: CR7G2.2 76.69,89.26 76.69,87.87 76.3,87.47 U7G1.3 73.75,87.47 73.25,86.97 v1(73.25,86.8)
  TOP w0.508: CR7G1.2 73.81,92.25 CR7G2.2
  BOTTOM w0.508: v1(73.25,86.8) 73.27,86.82 U7U1.11
+V3P3A_VAL: length 427.1
  TOP w0.305: C7H5.1 EU8H2.1
  TOP w0.38: C7H5.1 61.97,48.39 62.35,48.01 62.35,46.23 61.72,45.59 61.72,41.4 v1(61.59,41.27) ; v1(54.86,38.86) R8H60.1
  TOP w0.5: v1(62.73,38.86) R7H69.1 62.48,39.62 61.59,40.51 v1(61.59,41.27) ; R8H58.1 R8H59.1 R8H60.1 ; R1D3.2 294.76,193.55 v1(293.37,194.94)
  TOP w0.508: v1(220.98,62.61) R3H17.1 ; R6H6.1 v1(119.5,55.37) ; R6H32.1 v1(119.5,39.24)
  LAY5 w0.5: v1(62.73,38.86) 60.19,38.86 59.43,39.62 55.62,39.62 v1(54.86,38.86) ; v1(61.59,41.27) 61.9,41.59 70.92,41.59 71.76,40.75 76.68,40.75 77.16,41.22 83.51,41.22 84.2,41.91 88.57,41.91 91.49,44.83 v1(92.58,44.83) ; v1(293.37,194.94) 293.06,194.63 293.06,179.52 292.43,178.9 292.43,177.46 292.86,177.03 292.86,164.97 291.9,164.02 291.9,163 290.43,161.53 290.43,159.6 287.71,156.89 284.25,156.89 281.43,154.06 281.43,150.76 282.16,150.02 282.16,149 283.98,147.18 283.98,143.75 286.51,141.22 286.51,140 287.13,139.38 288.42,139.38 289.9,137.9 289.9,129.54 289.92,129.52 289.92,119.49 289.43,119 289.43,118.36 289.87,117.92 289.87,100.09 289.44,99.66 289.44,81.69 285.03,77.28 282.5,77.28 281.23,76.02 281.23,72.02 280.59,71.38 278.26,71.38 275.08,68.2 268.47,68.2 265.3,65.02 260.5,65.02 259.86,65.66 251.7,65.66 246.87,60.83 231.01,60.83 227.83,64.01 222.37,64.01 v1(220.98,62.61) 218.94,64.65 181.36,64.65 178.18,61.47 178.18,58.16 173.35,53.34 167.82,53.34 164.09,49.61 160.31,49.61 154.55,43.85 151.51,43.85 151.35,44.01 127.39,44.01 126.71,44.69 120.79,44.69 v1(119.5,45.97)
  LAY5 w1: 93.91,45.7 95.37,45.7 95.74,46.07 99.53,46.07 99.69,46.23 102.48,46.23 103.75,44.96 118.49,44.96 v1(119.5,45.97)
  LAY6 w0.508: v1(89.78,30.66) 88.39,32.05 v1(88.39,37.59)
  BOTTOM w0.508: v1(89.78,30.66) 90.75,30.66 R7W2.1
  vias: v1(89.28,37.59) v1(92.58,45.85) v1(119.5,46.89)
+V3P3A_VR: length 2
  TOP w0.1: 60.07,93.34 60.19,93.47
  TOP w0.5: 59.3,94.36 R8G8.1 60.19,93.47
+V3P3DSW: length 954.7
  TOP w0.18: U8C1.5 32.28,211.36 32.25,211.33 C8C16.1
  TOP w0.2: U8H5.1 36.78,43.89 v1(36.8,43.86)
  TOP w0.203: v1(29.08,195.07) 28.7,195.45 U8C6.1
  TOP w0.38: R8D32.1 v1(48.13,184.66) R8D33.1 ; v1(172.97,254.68) 172.92,254.63 C4B6.1 171.95,255.01 172.33,255.4 ; 69.59,124.71 R7F4.1 69.59,128.76 70.87,130.05 R7E61.1 ; 69.59,124.71 69.59,123.95 R7F9.1 ; 69.59,124.71 70.73,124.71 70.99,124.46 v1(71.62,124.46) 72.13,124.46 R7F6.1 ; R7B6.1 68.7,257.94 68.7,256.16 68.32,255.78 R7B4.1 68.83,255.01 R7B7.1 68.96,254.63 69.46,254.63 69.87,254.23 v1(71.88,254.23) 71.88,254.25 ; R6A35.1 109.22,276.99 C6A19.1 ; v1(116.96,10.26) 116.96,9.9 116.71,9.65 R6J16.1 ; U8D1.5 47.75,189.61 47.37,189.23 C8D5.1 v1(48.13,188.59) ; R7B30.2 90.17,247.23 89.11,248.28 84.58,248.28 81.91,250.95 v1(80.13,250.95) ; 62.99,90.55 R7G4.2 63.77,89.41 ; J8J13.8 29.59,11.05 27.81,11.05 24.89,13.97 24.89,16.38 25.27,16.76 25.27,21.84 26.54,23.11 27.17,23.11 29.71,25.65 29.71,30.61 31.11,32 31.11,36.19 29.47,37.84 29.47,41.1 28.8,41.76 28.19,41.76 27.32,42.64 24.85,42.64 v1(22.22,40) R9H15.1 ; U8D14.5 v1(38.98,165.63) ; R8D39.1 v1(48.13,183.51) ; v1(30.09,162.35) 30.04,162.3 C8D35.1 U8D13.5 ; Q8G7.2 45.33,80.39 C8G11.1 v1(44.5,80.52) ; 156.71,209.83 156.66,209.88 v1(156.66,209.93) ; R8D31.1 v1(44.85,184.66) ; R7F49.1 83.43,110.9 81.82,109.29 81.82,101.77 81.04,100.98 81.04,100.46 80.02,99.44 75.56,99.44 71.37,95.25 v1(71.37,94.99) ; v1(42.03,184.15) C8D14.1 41.52,184.91 41.27,184.66 R8D30.1 ; R8H47.1 v1(33.4,43.31) ; R8D90.1 v1(32.25,162.94) ; R5C18.1 R5C30.1 155.32,209.93 Q5C1.1 ; R5H14.1 v1(144.65,37.59)
  TOP w0.5: R8F18.1 28.7,117.47 32.08,114.09 v1(43.18,114.09) ; v1(150.03,155.57) 149.65,155.95 149.65,156.67 147.56,158.77 141.03,158.77 131.31,168.48 131.31,170.69 133.22,172.59 R6D58.1 ; 46.73,95.88 44.37,95.88 42.67,97.59 v1(42.67,97.66) 42.79,97.79 R8F53.1
  TOP w0.508: v1(28.44,216.53) 30.86,216.53 31.62,215.77 R8C25.1 R8C26.1 33.52,215.01 33.9,214.63 33.9,211.07 33.4,210.56 C8C16.1 ; v1(25.14,219.45) 24.89,219.71 R8C16.1
  TOP w1.5: 172.08,253.24 169.24,253.24 168.78,253.69 163.06,253.69 161.89,254.87 155.59,254.87 153.53,252.81 148.45,252.81 145.83,250.19 123.81,250.19
  LAY5 w0.38: v1(246.63,61.97) 246.63,62.48 239.22,69.89 233.03,69.89 231.07,71.86 198.57,71.86 197.58,70.87 179.14,70.87 172.83,64.55 172.83,61.08 170.89,59.14 169.79,59.14 163.76,53.11 149.75,53.11 v1(145.79,49.15) 145.16,48.51 134.87,48.51 134.74,48.64 v1(134.49,48.64) ; v1(30.09,162.35) 30.68,162.94 v1(32.25,162.94)
  LAY5 w1: 208.07,259.84 199.77,259.84 197.62,257.7 195.92,257.7 ; v1(121.79,114.68) v1(121.79,115.7) 130.04,115.7 132.6,118.25 135.34,118.25 136.01,118.93 136.01,122.05 137.92,123.95 137.92,128.4 139.95,130.43 140.06,130.43 143.43,133.79 143.43,147.29 148,151.86 148,154.12 149.46,155.57 v1(150.03,155.57) 150.17,155.44 151.4,155.44 152.32,156.36 152.32,161.72 153.92,163.32 153.92,168.85 ; 152.4,171.19 152.4,176.15 154.38,178.13 154.38,191.59 155.95,193.17 155.95,195.45 ; v1(134.49,48.64) v1(133.47,48.64) 127.86,48.64 127.02,47.8 124.95,47.8 121.35,51.41 98.86,51.41 97.91,50.46 95.01,50.46 94.34,49.79 92.41,49.79 89.59,46.98
  LAY6 w0.38: v1(144.65,37.59) 145.79,38.73 v1(145.79,49.15) ; v1(44.5,80.52) 44.5,81.22 43.79,81.93 v1(43.79,86.36) ; v1(108.71,278.64) v1(107.95,278.64)
  LAY6 w0.5: v1(71.62,124.46) 72.64,123.44 72.64,121.46 72.26,121.08 71.85,121.08 71.37,120.6 71.37,119.59 69.34,117.56 69.34,111.31 68.25,110.22 68.25,101.93 70.99,99.2 70.99,97.92 71.49,97.41 71.49,96.39 v1(71.37,96.26) v1(71.37,94.99) ; v1(43.18,114.09) 43.18,107.57 44.31,106.43 44.31,102.5 43.05,101.24 43.05,98.04 v1(42.67,97.66)
  LAY6 w1: 71.82,53.75 71.82,52.05 72.06,51.81 72.06,49.84 70.99,48.77 70.99,46.45 ; 133.6,66.93 133.6,68.2 131,70.8 129.85,70.8 124.86,75.8 124.86,78.46 124.84,78.48 ; 71.62,67.31 71.62,68.45 73.64,70.47 73.64,73.88 72.13,75.39 72.13,80.64 72.76,81.27 72.76,82.17 72.34,82.59 72.34,87.42 71.55,88.21 71.55,90.6 71.75,90.8 71.75,92.58 71.37,92.96 v1(71.37,93.98) v1(71.37,94.99) ; v1(121.79,115.7) v1(121.79,114.68) 121.79,103 119.96,101.16 119.96,97.22 123.47,93.71 123.47,88.4 124.46,87.42 124.46,83.18
  BOTTOM w0.38: v1(72.77,253.49) 73.91,253.49 76.45,250.95 v1(80.13,250.95) ; v1(116.96,10.26) 116.96,10.41 118.03,11.48 125.42,11.48 126.23,10.67 126.23,10.16 128.14,8.25 128.14,7.24 128.52,6.86 131.69,6.86 133.47,8.64 138.3,8.64 139.67,10.01 139.67,19.68 140.71,20.72 140.71,22.73 141.6,23.62 141.6,34.54 v1(144.65,37.59) ; v1(36.8,43.86) 36.78,43.89 33.98,43.89 v1(33.4,43.31) 32.89,43.81 31.62,43.81 30.73,42.92 28.82,42.92 28.57,43.18 25.4,43.18 v1(22.22,40)
  BOTTOM w0.5: 64.89,11.3 32.76,11.3 31.52,10.06 J8J13.8
  BOTTOM w0.75: v1(88.01,46.23) v1(87.12,46.23) 87.12,44.96 86.86,44.7 86.86,35.56 77.08,25.78 74.54,25.78 72.89,24.13 72.89,23.75 71.88,22.73 70.99,22.73 70.35,22.1 66.77,22.1 64.89,20.22 64.89,18.29 64,17.4 64,14.35 64.89,13.46 64.89,6.6 63.75,5.46 47.17,5.46 J8J13.21
  BOTTOM w1: 110.23,276.6 110.23,275.08 113.03,272.29 113.91,272.29 115.93,270.27 120.05,270.27 120.37,269.95 123.4,269.95 125.56,267.79 129.16,267.79 129.79,268.42 129.79,270.89 130.68,271.78 131.68,271.78 133.84,273.94 134.87,273.94 136.14,275.21 138.04,275.21 139.19,274.06 144.01,274.06 144.65,273.43 146.43,273.43 147.44,272.41 147.82,272.41
  BOTTOM w1.5: 107.44,253.11 106.76,253.78 106.76,259.5 104.85,261.41 104.85,267.54
  vias: v1(28.32,199.9) v1(29.08,199.9) v1(45,86.49) v1(63.95,91.95) v1(63.95,91.18) v1(63.95,90.42) v1(64.03,89.3) v1(64.68,91.95) v1(64.68,91.18) v1(64.68,90.42) v1(64.68,89.66) v1(70.48,44.83) v1(71.5,44.83) v1(71.88,253.49) v1(72.77,254.23) v1(108.33,277.62) v1(109.47,278.61) v1(119.38,251.46) v1(120.39,251.46) v1(121.41,251.46) v1(149.47,271.52) v1(150.24,271.52) v1(155.93,211.2) v1(155.93,209.93) v1(156.66,211.2) v1(173.73,254.68) v1(212.09,263.9) v1(212.97,263.9)
+V3P3DSW_OUT: length 22.1
  TOP w0.3: R7G4.1 60.19,90.42 58.03,90.42 55.24,93.22 49.4,93.22 49.02,92.84 49.02,90.8 C8G5.1 R8G18.1
  TOP w0.38: 59.39,87.5 61.21,89.32 ; 61.21,89.32 R7G4.1 ; 61.21,89.32 C7G3.1
+V3P3DSW_PCH_VAL: length 50.7
  TOP w0.75: 54.22,163.67 54.22,160.02 55.88,158.37 55.88,152.49 57.95,150.42 57.95,144.73 58.79,143.89 58.79,140.96 60.01,139.75 60.01,134.93 v1(60.96,133.98) v1(61.59,133.35)
  LAY6 w0.75: 70.61,122.55 69.21,122.55 68.32,123.44 68.32,124.33 67.18,125.47 67.18,131.06 65.85,132.39 62.55,132.39 v1(61.59,133.35)
  vias: v1(71.62,122.55) v1(71.62,121.82)
+V3P3DSW_PCH_VAL_OUT: length 5.9
  TOP w0.3: R8E7.1 52.57,159 53.08,159.51 53.08,161.99 52.52,162.55 C8D34.1
+V3P3DSW_USBRD_1: length 53.8
  TOP w0.25: EU3B4.7 219.06,254.24 v1(218.82,254) 218.56,254.25 EU3B4.6 ; EU4B5.21 208.64,257.16 209.04,257.55 v1(209.16,257.55) ; EU3B4.3 217.06,254.15 v1(216.91,254) ; v1(200.91,254) 201.06,254.15 EU4B5.3 ; EU3B4.14 222.56,254.19 v1(222.75,254) 223.06,254.31 EU3B4.15 ; EU4B5.25 206.56,258.51 206.88,258.82 v1(207.06,258.82) EU4B5.24 ; EU3B4.25 222.56,258.51 222.88,258.82 v1(223.06,258.82) EU3B4.24 ; EU3B4.32 219.06,258.57 218.81,258.82 v1(218.56,258.82) EU3B4.33 ; EU4B5.15 207.06,254.31 v1(206.75,254) 206.56,254.19 EU4B5.14 ; v1(200.78,258.82) 201.06,258.55 EU4B5.36 ; EU4B5.33 v1(202.56,258.82) 203.06,258.32 EU4B5.32 ; v1(225.17,257.55) 225.04,257.55 224.65,257.16 EU3B4.21 ; EU4B5.7 203.06,254.24 v1(202.81,254) 202.56,254.25 EU4B5.6 ; EU3B4.36 217.06,258.55 v1(216.78,258.82)
  TOP w0.38: R3B21.1 R3B19.1 227.45,255.01 v1(227.58,255.14) ; R4B9.1 R4B11.1 v1(196.46,255.01) ; R3B12.1 R3B18.1 212.59,255.01 v1(212.47,254.89) v1(211.58,254.89) ; FB3A2.1 213.61,261.24 C3A24.1 C3A23.1 FB3A1.1 ; v1(209.16,257.55) C3B8.1 ; v1(225.17,257.55) C3B9.1
  BOTTOM w0.38: R3M1.1 222.3,259.59 v1(223.06,258.82) 223.01,258.77 C3M1.1 ; R3M7.1 222.12,253.36 v1(222.75,254) ; C3M6.1 216.78,254.3 216.91,254.17 v1(216.91,254) ; R4M3.1 206.88,257.94 C4M1.1 207.01,258.77 v1(207.06,258.82) ; v1(202.56,258.82) 202.56,258.82 C4M2.1 202.69,257.94 R4M4.1 ; C4M3.1 v1(200.78,258.82) ; R4M8.1 203.45,253.36 v1(202.81,254) 202.56,254.25 C4M5.1 ; R3M2.1 219.32,259.59 v1(218.56,258.82) 218.56,258.82 C3M2.1 ; v1(222.75,254) 223.01,254.25 C3M4.1 ; v1(222.75,254) 223.01,253.74 C3M7.1 ; v1(200.91,254) 200.91,254.17 200.78,254.3 C4M6.1 ; C4M7.1 207.01,253.74 v1(206.75,254) ; R3M8.1 219.45,253.36 v1(218.82,254) 218.56,254.25 C3M5.1 ; v1(206.75,254) 207.01,254.25 C4M4.1 ; v1(206.75,254) 206.12,253.36 R4M7.1 ; C3M3.1 215.64,258.7 215.77,258.82 v1(216.78,258.82)
  vias: v1(211.96,258.7) v1(213.23,258.7)
+V3P3DSW_VAL: length 498.1
  TOP w0.203: EU8H1.1 55.11,48.51 55.24,48.39
  TOP w0.38: R8H57.1 51.81,38.86 53.59,38.86 54.22,38.23 55.88,38.23 v1(56.51,38.86) R8H61.1 ; C8H17.1 55.49,48.13 55.24,48.39 ; R7H68.1 96.52,40.13 R7H67.1 96.01,40.38 95.63,40 94.44,40 93.79,40.66 93.79,44.64 94.36,45.21 94.36,46.84 v1(94.38,46.86) ; R8J20.1 v1(35.43,13.33) ; R8J23.1 v1(48.26,13.33) ; 54.1,119.51 R8F55.1 ; Q7H3.2 v1(84.45,41.15) ; R8J24.1 v1(52.32,13.33)
  TOP w0.5: v1(191.64,49.27) 191.64,48.89 189.61,46.86 180.52,46.86 172.88,39.22 163.92,39.22 157.35,45.79 v1(157.35,48.39)
  TOP w0.508: C8H17.1 55.88,49.02 56.43,49.58 57.35,49.58 57.91,49.02 v1(57.91,48.89) ; R1E30.1 285.13,148.86 v1(286,148.86)
  TOP w0.75: v1(69.59,102.49) v1(70.73,102.49)
  TOP w1: v1(54.1,127.22) 54.1,116.01 60.43,109.68 61.7,109.68 68.89,102.49 v1(69.59,102.49) ; 94.23,48.39 94.23,53.85 94.65,54.26 94.65,58.79 97.91,62.06 97.91,82.68 99.82,84.58 99.82,85.47
  LAY5 w0.38: v1(94.38,46.86) 95.38,46.86 96.13,47.61 103.45,47.61 104.42,46.63 113.81,46.63 115.31,48.13 115.31,48.51 115.78,48.98 118.42,48.98 122.15,45.26 126.95,45.26 127.63,44.58 150.87,44.58 151.89,45.59 154.55,45.59 v1(157.35,48.39)
  LAY6 w0.38: v1(191.64,49.27) 194.05,51.69 205.48,51.69 205.86,52.07 212.97,52.07 216,49.05 232.18,49.05 232.43,49.3 250.34,49.3 251.88,50.84 262.72,50.84 264.47,49.09 284.41,49.09 286.13,50.8 286.13,52.83 287.78,54.48 287.78,65.28 294.25,71.75 294.25,80.08 296.4,82.24 296.4,95.64 295.27,96.77 295.27,101.73 294.13,102.87 291.21,102.87 287.3,106.78 287.3,135.75 286.9,136.14 286.9,138.17 288.06,139.33 288.06,142.09 286.91,143.23 286.91,147.95 v1(286,148.86)
  LAY6 w0.508: v1(56.26,13.33) 56.26,13.84 55.96,14.14 55.96,20.66 56.62,21.32 56.62,38.75 v1(56.51,38.86) 58.67,41.02 58.67,45.59 58.92,45.85 58.92,46.48 57.91,47.5 v1(57.91,48.89)
  BOTTOM w1: v1(69.59,102.49) v1(70.73,102.49) 70.99,102.49 70.99,101.37 74.08,98.28 74.08,96.35 77.52,92.91 79.78,92.91 81.13,91.56 82.65,91.56 83.67,90.54 86.47,90.54 88.87,88.14 93.34,88.14 94.99,86.49 97.09,86.49
  vias: v1(52.98,176.66) v1(52.98,175.89) v1(53.08,127.22) v1(53.23,181.74) v1(53.23,180.97) v1(54.1,128.24) v1(54.96,128.27) v1(55.01,127.25) v1(93.67,46.84) v1(99.69,87.76) v1(99.69,86.87)
+V3P3DSW_VAL_OUT: length 9
  TOP w0.3: R8F11.1 48.8,121.76 51.91,121.76 53.08,122.93 53.08,125.6 52.79,125.89 52,125.89 C8F5.1
+V3P3DX_CPU_SSD2: length 109.6
  TOP w0.38: R7C3.1 v1(96.52,226.82) ; 150.87,216.66 151,216.53 R5C17.2 149.93,215.57 149.86,215.64
  LAY5 w0.38: v1(96.52,226.82) 98.83,226.82 103.64,222.01 107.68,222.01 111.25,218.44 114.17,218.44 114.78,219.05 114.78,226.41 115.95,227.58 118.61,227.58 118.99,227.2 118.99,226.44 119.63,225.8 121.66,225.8 123.13,227.28 129.99,227.28 134.53,231.81 134.53,232.24 136.13,233.85 136.13,234.31 138.11,236.29 138.11,238.34 138.55,238.78 139.82,238.78 140.81,239.77 144.3,239.77 145.29,238.78 146.3,238.78 148.2,236.88 148.81,236.88 149.21,236.49 149.21,233.67 151.12,231.76 151.12,228.73 155.44,224.41 167.38,224.41 170.68,221.11 v1(170.68,220.17)
  vias: v1(150.62,217.3) v1(151,220.34) v1(151.38,217.3) v1(151.76,220.34)
+V3P3DX_CPU_SSD2_LS: length 1.1
  TOP w0.3: R5C17.1 151,212.98
+V3P3DX_SDCARD: length 1.3
  TOP w0.5: R8C78.2 23.06,196.59 C9C8.1
+V3P3DX_SDCARD_LS: length 0.9
  TOP w0.5: R8C78.1 26.54,196.59
+V3P3DX_V1P8DX_TCH_PNL: length 151.3
  TOP w0.38: R9D21.1 v1(16.58,178.18) 15.95,177.54 13.97,177.54 13.71,177.8 C9D7.1 C9D6.1 12.31,179.2
  TOP w0.381: R8E11.1 41.14,156.08 v1(40.76,155.7)
  TOP w0.508: R7C43.2 64.44,196.59 65.58,195.45 65.58,194.76 65.07,194.26 61.13,194.26 v1(60.07,195.32) ; SW7C1.4 61.13,205.23 v1(60.07,206.3)
  LAY5 w0.38: v1(21.69,155.3) 21.69,155.61 17.19,160.11 17.19,169.8 16.76,170.23 16.76,173.48 17.27,173.99 17.27,177.49 v1(16.58,178.18)
  LAY5 w0.5: v1(60.07,206.3) 56.33,206.3 55.37,207.26 44.47,207.26 41.79,204.59 37.72,204.59 35.94,206.37 33.79,206.37 32.1,208.05 28.85,208.05 28.06,207.26 25.5,207.26 v1(24.74,208.02)
  LAY6 w0.5: v1(16.58,178.18) 16.71,178.31 16.71,179.76 15.85,180.62 15.85,187.17 17.39,188.72 17.39,192.6 21.84,197.05 21.84,202.01 24.01,204.17 24.01,207.3 v1(24.74,208.02)
  BOTTOM w0.38: v1(21.69,155.3) 21.89,155.1 40.16,155.1 v1(40.76,155.7)
  BOTTOM w0.508: v1(60.07,206.3) 61.34,205.03 61.34,196.34 60.32,195.32 v1(60.07,195.32)
+V3P3DX_V1P8DX_TCH_PNL_IO: length 136.6
  TOP w0.38: R9D22.1 v1(15.36,176.91) ; SW7C1.6 56.64,203.96 v1(56,204.6) 56.64,205.23 SW7C1.5 ; v1(23.43,147.26) 25.52,145.16 R8E39.1 32.51,144.4 33.14,143.76 34.29,143.76 34.92,143.13 40.51,143.13 41.14,143.76 v1(41.14,144.4) R8E40.1 ; R9D14.1 v1(16.51,180.97) ; R8E31.1 v1(41.14,147.95) ; R9D10.1 v1(14.09,182.12) R9D9.1
  LAY5 w0.38: v1(41.14,147.95) v1(41.14,144.4) ; v1(23.43,147.26) 23.43,147.51 22.6,148.33 22.35,148.33 16.25,154.43 16.25,157.68 14.59,159.35 14.59,161.3 14.73,161.44 14.73,167.53 15.34,168.15 15.34,169.59 14.69,170.25 14.69,176.24 v1(15.36,176.91)
  LAY5 w0.5: v1(25.4,206.37) 25.52,206.5 30.22,206.5 30.98,205.74 35.68,205.74 37.46,203.96 43.3,203.96 44.95,205.61 54.99,205.61 v1(56,204.6)
  LAY6 w0.5: v1(16.51,180.97) 18.54,183.01 18.54,192.86 23.33,197.65 23.33,202.6 24.63,203.91 24.63,205.61 v1(25.4,206.37)
  BOTTOM w0.38: v1(15.36,176.91) 14.6,177.67 14.6,179.07 v1(16.51,180.97) 15.36,182.12 v1(14.09,182.12)
+V3P3DX_V1P8DX_TCH_PNL_R: length 0.8
  TOP w0.5: R7C43.1 61.72,196.59
+V3P3S: length 779.4
  TOP w0.2: R7B55.1 96.52,236.6 C7B14.1 ; v1(152.4,153.67) 153.28,153.67 153.79,153.16 154.74,153.16 154.94,153.36 R5E10.1
  TOP w0.3: 12.06,230.76 U9C1.16
  TOP w0.38: R8H75.1 37.59,34.54 38.5,33.63 v1(38.5,33.27) ; R9G20.1 22.27,85.5 v1(22.22,85.44) ; R8H32.2 44.06,50.29 43.86,50.09 v1(43.81,50.09) ; U3A4.5 233.93,277.11 v1(234.82,278) 234.56,278 C3A6.1 ; R2A20.1 v1(268.47,270.64) ; R9G34.1 v1(16.51,69.21) ; v1(45.89,150.27) 44.34,150.27 42.54,148.46 42.54,147.45 v1(41.78,146.68) 42.54,145.92 v1(42.54,140.21) ; R7E39.1 67.29,139.06 65.52,137.29 v1(65.15,137.29) ; R9G39.1 v1(21.97,67.69) ; v1(272.41,258.7) 272.41,258.44 272.03,258.06 R2B4.1 ; v1(90.04,113.41) 90.55,113.92 R7F43.1 ; v1(26.03,15.87) 26.03,14.73 28.19,12.57 R8J19.1 ; v1(297.84,221.74) 297.43,221.74 R1C12.1 297.18,222.5 v1(297.84,222.5) ; R9H3.1 v1(15.87,62.36) ; 12.06,230.76 12.06,231.14 12.31,231.39 C9B4.1 v1(11.65,232.15) ; R9E26.1 v1(16.38,144.52) ; R1A2.1 v1(302.76,274.57) ; R8D16.1 v1(30.86,187.8) ; R2A54.1 R2A50.1 247.52,265.56 247.52,266.44 246.88,267.08 246.88,268.98 248.36,270.46 R2A34.2 ; R5C63.1 156.21,198.25 156.71,198.75 v1(156.71,199.64) ; R2A6.1 275.2,274.57 ; R1B22.1 294.38,240.41 294,240.79 292.6,240.79 291.08,242.31 R1B18.1 ; v1(272.69,270.58) 272.16,270.05 R2A36.1 ; v1(280.92,78.23) 281.81,77.34 284.35,77.34 286,75.69 R1D2.1 ; v1(155.82,178.48) R5D16.1 R5D17.1 ; R8H66.1 v1(44.83,37.72) ; R6H21.1 127.25,41.91 126.87,41.53 126.87,40.44 v1(127.12,40.19) ; v1(283.21,272.16) 283.21,268.22 281.68,266.7 281.68,264.41 280.79,263.52 278.38,263.52 278,263.9 R2A53.1 277.87,264.29 277.24,264.92 277.24,265.56 276.73,266.06 274.73,266.06 274.36,265.7 272.43,265.7 R2A46.1 272.16,264.67 v1(272.28,264.54) ; R8H65.1 v1(43.68,37.72) ; R8F70.1 v1(35.68,126.49) ; R6B14.1 v1(112.39,249.48) ; R3A45.1 v1(234.82,263.02) ; v1(9.27,39.62) 8.52,38.88 8.52,38.34 10.03,36.83 R9G23.1 ; R5C36.1 164.26,205.74 164.36,205.84 v1(165.07,205.84) 165.58,205.84 R5C35.1 ; R7B33.1 82.55,245.87 v1(82.55,245.11) ; v1(96.13,239.61) 95.75,239.23 C7B14.1 95.5,237.36 94.48,238.38 U7B2.5 ; U8F3.5 C8E17.1 33.27,133.22 32.77,132.73 v1(32.77,132.27) ; R5D32.1 152.01,169.92 R5D35.1 151.89,168.78 152.27,168.4 153.03,168.4 153.67,169.04 153.67,169.92 v1(153.72,169.98) 153.67,170.03 153.67,170.56 R5D34.1 ; v1(119.96,19.76) J6J2.57 119.96,20.78 v1(119.72,20.78) J6J2.49 ; v1(279.65,218.01) 279.4,218.26 R2C21.2 R2C20.2 ; 16.89,216.15 v1(17.65,216.15) ; R5F5.1 v1(153.92,114.68) ; v1(105.41,103) 105.41,103.53 104.92,104.01 R6F35.1 ; U1B2.5 288.92,249.55 R1B9.1 C1B3.1 R1B4.1 289.05,250.57 289.43,250.19 289.68,250.19 289.94,249.93 289.94,248.54 290.57,247.9 291.46,247.9 ; R5D38.1 154.55,163.19 R5D40.1 154.43,163.19 R5D39.1 153.41,163.45 v1(153,163.85) ; R5C64.1 159.12,197.62 v1(158.61,197.62) 159.13,198.14 159.13,198.5 R5C58.1 ; R6F9.1 v1(106.04,114.81) ; R8B42.1 30.48,227.33 30.86,227.71 v1(30.86,228.34) 30.86,229.05 v1(30.91,229.11) ; R9H21.2 v1(22.22,32.51) ; v1(300.35,139.06) 300.22,138.94 297.56,138.94 297.05,139.44 R1E45.1 ; R9C8.1 v1(16,211.33) ; R9C11.2 15.26,208.56 v1(16,208.56) ; R9C3.1 v1(17.65,214.63) ; R8D7.1 v1(26.79,194.18) ; R9G40.1 v1(21.97,66.55)
  TOP w0.5: v1(9.27,39.62) R9H16.2 ; R1B18.1 291.08,243.58 291.97,244.47 R1B15.1 291.46,245.49 291.46,249.43 292.6,250.57 R1B8.1 294.64,251.71 296.54,251.71 v1(296.79,251.46) ; R2A34.2 248.36,271.32 v1(248.03,271.65) ; R9J6.2 v1(9.27,27.56)
  TOP w0.508: R7F42.1 v1(95.25,114.81)
  LAY5 w0.38: v1(131.19,98.17) 131.54,98.17 133.06,99.69 144.27,99.69 146.43,101.85 148.2,101.85 153.92,107.57 v1(153.92,114.68) ; v1(11.65,232.15) 11.65,230.15 13.08,228.73 13.08,217.55 13.71,216.91 13.71,212.47 14.85,211.33 v1(16,211.33) ; v1(165.07,205.84) 164.08,204.85 160.65,204.85 159.76,203.96 159.76,201.8 159.13,201.17 159.13,198.14 v1(158.61,197.62)
  LAY5 w0.5: v1(136.27,83.06) 135.5,82.29 134.62,82.29 133.31,83.6 122.53,83.6 122.21,83.29 113.05,83.29 v1(112.26,84.07)
  LAY5 w0.508: v1(63.88,141.86) 63.88,140.84 64.38,140.33 64.38,137.79 64.89,137.29 v1(65.15,137.29)
  LAY5 w1: v1(95.12,239.65) 95.16,239.61 v1(96.13,239.61) 99.06,239.61 100.36,240.9 106.18,240.9 108.45,238.63 v1(108.45,238.12) 117.54,238.12 117.64,238.23 121.85,238.23
  LAY6 w0.38: v1(279.65,218.01) 277.74,216.1 277.74,213.74 276.73,212.72 v1(276.47,212.72) ; v1(106.04,114.81) 105.28,115.57 104.03,115.57 103.21,116.39 100.39,116.39 99.56,117.22 97.66,117.22 v1(95.25,114.81) 94.1,115.95 90.93,115.95 90.04,115.06 v1(90.04,113.41) ; v1(112.39,249.48) 111.3,249.48 107.81,245.99 107.81,240.54 108.45,239.9 v1(108.45,238.12) ; v1(272.41,258.7) 272.54,258.82 272.54,260.86 273.91,262.23 273.91,262.79 272.7,263.99 272.7,264.12 v1(272.28,264.54) ; v1(22.22,15.87) 22.22,15.49 22.6,15.11 25.27,15.11 v1(26.03,15.87) ; v1(32.77,132.27) 34.16,130.88 34.16,128.01 v1(35.68,126.49) ; v1(130.17,31.14) v1(130.17,31.88)
  LAY6 w0.5: v1(105.41,103) 106.04,103 106.93,102.11 106.93,98.97 107.99,97.91 107.99,86.19 109.47,84.71 111.63,84.71 v1(112.26,84.07) ; v1(25.65,29.97) 24.76,29.08 24.76,22.6 22.22,20.06 v1(22.22,15.87)
  LAY6 w1: 96.94,268.81 109.27,268.81 111.76,266.32 114.68,266.32 115.44,267.08 116.71,267.08 117.45,267.82 121.18,267.82 122.45,266.55 124.3,266.55 125.47,267.71 131.37,267.71 134.45,270.8 134.45,273.39 136.38,275.33 137.8,275.33 138.57,274.56 141.71,274.56 142.9,275.74 145.64,275.74 146.82,274.56 157.26,274.56 157.43,274.73 161.24,274.73 161.61,275.09 162.81,275.09 164.08,276.36 ; 90.41,271.02 89.96,271.47 85.79,271.47 85.13,270.81 85.13,269.68 81.89,266.44 79.62,266.44 75.69,262.51 75.69,259.71
  LAY6 w1.5: 144,133.33 144,136.82 145.54,138.36 145.54,144.49 151.89,150.84 ; 133.28,115.29 131.78,113.79 130.17,113.79 128.9,112.52 128.9,99.44 130.17,98.17 v1(131.19,98.17) 132.71,96.65 132.71,84.71 134.74,82.68
  BOTTOM w0.2: v1(63.88,141.86) 64,141.73 68.07,141.73 69.97,143.64 72.64,143.64 73.38,144.38 77.87,144.38 78.61,143.64 R7R41.1
  BOTTOM w0.38: v1(65.15,137.29) 65.27,137.41 R7R52.1 ; v1(16.51,69.21) 17.52,68.2 17.52,67.18 ; v1(135.76,37.46) 136.14,37.84 R5V4.1 R5V5.1 R5V6.1 ; v1(45.89,150.27) 45.84,150.27 45.82,150.24 R8R6.1 R8R3.1 ; v1(41.78,146.68) 41.78,148.46 41.02,149.22 40,149.22 39.62,149.6 R8R7.1 R8R10.1 ; v1(234.82,278) 234.82,277.11 235.45,276.48 236.34,276.48 236.98,275.84 236.98,274.19 232.79,274.19 230.44,271.84 230.44,270.44 229.6,269.61 229.6,265.44 230.37,264.67 232.66,264.67 234.31,263.02 v1(234.82,263.02) ; v1(138.68,37.46) 138.68,38.23 R5V3.1 R5V2.1 R5V7.1 ; v1(32.77,132.27) 32.4,132.64 30.98,132.64 29.51,134.11 v1(29.21,134.11) ; 17.52,67.18 21.46,67.18 v1(21.97,67.69) ; 17.52,67.18 17.52,64.01 v1(15.87,62.36) ; 285.87,271.4 286,271.52 290.19,271.52 290.95,270.76 293.11,270.76 293.87,271.52 299.72,271.52 v1(302.76,274.57) ; v1(105.41,103) 106.04,103.63 106.04,105.03 106.68,105.66 106.68,106.93 106.19,107.42 106.19,114.65 v1(106.04,114.81)
  BOTTOM w0.5: v1(276.47,212.72) 281.12,212.72 282.29,213.89 288.38,213.89 289.68,215.19 289.68,220.6 290.7,221.62 294.75,221.62 296.41,219.96 298.7,219.96 ; v1(22.22,15.87) 20.19,15.87 19.05,17.02 14.85,17.02 13.2,18.67 13.2,20.06 8.38,24.89 8.38,26.67 v1(9.27,27.56) 9.27,36.96 8.29,37.94 8.29,38.64 v1(9.27,39.62) ; 236.98,274.19 242.69,274.19 245.87,271.02 247.14,271.02
  BOTTOM w0.508: v1(30.73,143.31) 35.17,143.31 38.29,140.19 42.53,140.19 v1(42.54,140.21) 42.56,140.19 52.6,140.19 53.8,141.4 60.37,141.4 60.73,141.76 63.77,141.76 v1(63.88,141.86) ; v1(95.25,114.81) R7F42.1
  vias: v1(22.22,212.34) v1(22.22,211.2) v1(30.2,229.11) v1(40.51,80.8) v1(40.51,80.03) v1(41.27,80.8) v1(41.27,80.03) v1(42.03,80.8) v1(42.03,80.03) v1(51.15,227.84) v1(51.18,228.6) v1(70.48,260.35) v1(70.48,259.59) v1(71.24,260.35) v1(71.24,259.59) v1(123.59,236.55) v1(124.33,236.55) v1(136.27,82.04) v1(137.41,83.06) v1(137.41,82.04) v1(157.2,214.02) v1(157.91,214.02) v1(158.62,214.02) v1(159.38,213.99) v1(163.57,42.16) v1(163.57,41.4) v1(163.57,40.64) v1(163.83,277.52) v1(164.33,42.16) v1(164.33,41.4) v1(164.33,40.64) v1(164.59,277.52) v1(165.1,42.16) v1(165.1,41.4) v1(165.1,40.64) v1(171.19,73.15) v1(171.19,72.39) v1(171.95,73.15) v1(171.95,72.39) v1(172.72,73.15) v1(172.72,72.39) v1(172.84,76.58) v1(172.84,74.93) v1(173.48,73.15) v1(173.48,72.39) v1(174.24,73.15) v1(248.79,271.6) v1(276.47,275.46) v1(276.47,274.7) v1(277.24,275.46) v1(277.24,274.7) v1(292.12,94.87) v1(292.12,93.72) v1(293.24,94.87) v1(293.24,93.72) v1(302.64,132.46) v1(302.64,131.7) v1(302.64,130.94) v1(302.64,122.3) v1(302.64,121.54) v1(302.64,120.78)
