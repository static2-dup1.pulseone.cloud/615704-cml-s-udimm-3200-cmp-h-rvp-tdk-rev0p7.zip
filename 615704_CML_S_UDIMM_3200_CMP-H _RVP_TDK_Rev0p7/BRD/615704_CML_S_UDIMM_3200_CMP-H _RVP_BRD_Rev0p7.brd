# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBC_FP3_RX1_R_DN: length 23.1
  TOP w0.115: C6D2.2 126.78,190.95 126.78,191.15 127.12,191.49 R6D6.1 126.93,191.51 126.82,191.63 126.82,192.02 126.18,192.66 126.18,192.81 126.33,192.95 U6D2.5 U6D2.6 126.33,194.42 126.18,194.56 126.18,195.91 126.49,196.21 126.49,202.94 125.63,203.8 123.87,203.8 122.86,202.79 119.24,202.79 119.07,202.96 119.07,203.53 119.2,203.66 J6C4.P6
USBC_FP3_RX1_R_DP: length 23.1
  TOP w0.115: C6D1.2 126.55,190.93 126.55,191.32 R6D5.1 126.59,191.74 126.59,191.93 125.95,192.56 125.95,192.81 125.83,192.94 U6D2.4 U6D2.7 125.83,194.42 125.95,194.54 125.95,196.01 126.26,196.31 126.26,202.85 125.53,203.57 123.96,203.57 122.95,202.56 119.14,202.56 118.84,202.86 118.84,203.33 118.7,203.47 118.53,203.47 118.52,203.47 118.4,203.59 J6C4.P5
USBC_FP3_RX2_DN: length 18
  TOP w0.115: C6D3.1 118.23,189.36 118.23,188.52 118.81,187.94 118.81,185.66 123.98,180.49 126.26,180.49 127.25,181.48 129.54,181.48 129.58,181.44 EU6D1.40
USBC_FP3_RX2_DP: length 18
  TOP w0.115: EU6D1.39 129.54,181.84 129.41,181.71 127.15,181.71 126.16,180.72 124.07,180.72 119.04,185.75 119.04,188.04 118.46,188.62 118.46,189.56 118.6,189.7 118.78,189.7 C6D4.1
USBC_FP3_RX2_R_DN: length 10.5
  TOP w0.115: C6D3.2 118.28,190.79 118.28,191.21 R6D3.1 118.26,191.79 118.26,192.22 118.51,192.47 119.24,192.47 119.41,192.64 119.41,192.8 119.28,192.93 U6D1.6 U6D1.5 119.28,194.42 119.41,194.55 119.41,196.61 119.11,196.92 119.11,198.26 118.8,198.57 J6C4.P16
USBC_FP3_RX2_R_DP: length 10.6
  TOP w0.115: C6D4.2 118.51,190.84 118.51,191.16 R6D4.1 118.49,191.9 118.49,192.12 118.6,192.24 119.34,192.24 119.64,192.55 119.64,192.85 119.78,192.99 U6D1.7 U6D1.4 119.78,194.41 119.64,194.55 119.64,196.71 119.34,197.02 119.34,198.21 119.6,198.47 J6C4.P15
USBC_FP3_SSEQ0_A0: length 2.7
  TOP w0.1: EU6D1.11 134.36,182.24 134.87,181.74 R5D14.1 R5D15.2
USBC_FP3_SSEQ1: length 3.5
  TOP w0.1: EU6D1.3 131.22,179.99 130.3,179.07 R6D44.1 R6D47.2
USBC_FP3_TX1_C_CMC_ESD_DN: length 19.5
  TOP w0.115: J6C4.P3 116.8,203.55 116.53,203.28 116.53,202.74 117.37,201.9 121.83,201.9 124.7,199.04 124.7,194.6 124.83,194.47 U6D2.9 U6D2.2 124.83,193.03 124.69,192.89 124.69,192.51 124.3,192.13 124.3,191.56 R6D21.2
USBC_FP3_TX1_C_CMC_ESD_DP: length 19.5
  TOP w0.115: R6D20.2 124.07,191.51 124.07,192.22 124.46,192.6 124.46,192.91 124.33,193.04 U6D2.1 U6D2.10 124.33,194.47 124.47,194.61 124.47,198.94 121.74,201.67 117.27,201.67 116.3,202.64 116.3,203.22 116,203.52 J6C4.P2
USBC_FP3_TX1_C_DN: length 1.7
  TOP w0.115: R6D21.1 124.34,190.62 124.34,189.72 C6D12.2
USBC_FP3_TX1_C_DP: length 1.7
  TOP w0.115: R6D20.1 124.11,190.59 124.11,189.65 C6D11.2
USBC_FP3_TX1_DN: length 9.6
  TOP w0.115: EU6D1.33 129.59,184.24 129.51,184.15 127.32,184.15 126.3,185.16 124.84,185.16 124.28,185.72 124.28,188.43 124.39,188.54 124.63,188.54 C6D12.1
USBC_FP3_TX1_DP: length 9.6
  TOP w0.115: C6D11.1 124.05,188.24 124.05,185.63 124.74,184.93 126.21,184.93 127.22,183.92 129.49,183.92 129.57,183.84 EU6D1.34
USBC_FP3_TX2_C_CMC_ESD_DN: length 8.5
  TOP w0.115: R6D18.2 120.97,191.49 120.97,192.71 120.78,192.9 U6D1.9 U6D1.2 120.78,194.38 120.92,194.52 120.92,196.03 121.51,196.62 121.51,198.27 121.2,198.58 J6C4.P13
USBC_FP3_TX2_C_CMC_ESD_DP: length 8.5
  TOP w0.115: R6D19.2 121.2,191.62 121.2,192.81 121.19,192.82 121.28,192.91 U6D1.10 U6D1.1 121.28,194.4 121.15,194.53 121.15,195.94 121.74,196.52 121.74,198.32 122,198.59 J6C4.P12
USBC_FP3_TX2_C_DN: length 1.7
  TOP w0.115: C6D9.2 121,189.71 121,190.67 R6D18.1
USBC_FP3_TX2_C_DP: length 1.7
  TOP w0.115: C6D10.2 121.23,189.66 121.23,190.6 R6D19.1
USBC_FP3_TX2_DN: length 13.2
  TOP w0.115: EU6D1.37 129.65,182.64 129.51,182.78 123.79,182.78 120.87,185.7 120.87,188.24 C6D9.1
USBC_FP3_TX2_DP: length 13.2
  TOP w0.115: C6D10.1 121.42,188.58 121.23,188.58 121.1,188.45 121.1,185.79 121.38,185.52 123.89,183.01 129.51,183.01 129.51,183.01 129.93,183.01 EU6D1.36
USBC_FP_VBUS_SENSE_EC: length 143.9
  TOP w0.1: v1(32,108.08) 31.49,108.08 30.98,107.57 30.98,107.06 30.82,106.89 U8F6.3 ; R6D56.2 119.12,174.88 118.61,174.37 v1(118.36,174.37)
  LAY8 w0.1: v1(118.36,174.37) 117.47,175.26 117.47,178.05 113.03,182.5 104.39,182.5 102.87,180.97 102.87,168.78 90.8,156.72 90.8,153.92 83.18,146.3 83.18,140.08 77.72,134.62 72,134.62 69.97,132.59 62.61,132.59 61.46,131.44 61.46,126.87 v1(62.23,126.11)
  BOTTOM w0.1: v1(32,108.08) 32,108.27 33.56,109.83 33.56,111.23 35.07,112.74 38.55,112.74 42.38,116.57 43.72,116.57 45.47,118.32 54.81,118.32 62.23,125.73 v1(62.23,126.11)
USBC_FPAIC_OC_N: length 54.3
  TOP w0.1: CR6H1.1 v1(108.71,58.8)
  LAY5 w0.125: J6J1.11 121.21,28.28 115.12,28.28 114.75,28.65 108.66,28.65 v1(105.66,25.65)
  LAY6 w0.125: v1(108.71,58.8) 108.71,54.48 107.5,53.27 107.5,35.74 106.43,34.68 106.43,30.23 105.66,29.46 v1(105.66,25.65)
USBC_PD_I2C2_CLK: length 168.3
  TOP w0.1: R8E51.2 40.25,136.02 40,135.76 39.87,135.76 v1(39.85,135.74)
  LAY5 w0.125: J6J1.3 116.63,28.78 115.33,28.78 114.14,29.97 112.34,29.97 111.57,29.21 104.9,29.21 104.14,28.45 102.1,28.45 100.88,29.67 80.18,29.67 v1(79.62,30.22)
  LAY8 w0.1: v1(39.85,135.74) 40.38,135.2 40.38,133.6 39.7,132.92 39.7,126.49 38.6,125.39 38.6,109.73 38.98,109.35 38.98,98.9 42.03,95.85 42.03,95.25 42.29,94.99 42.92,94.99 43.3,94.61 43.3,85.69 46.26,82.73 46.26,80.32 48.16,78.41 48.16,73.4 48.56,73.01 48.56,69.42 49.02,68.96 49.02,68.07 50.41,66.67 51.56,66.67 52.1,66.14 54.47,66.14 60.03,60.58 60.45,60.58 61.89,59.14 61.89,57.07 67.56,51.4 67.56,50.43 73.25,44.74 74.47,44.74 76.1,43.11 76.1,42.56 78.9,39.76 78.9,30.95 v1(79.62,30.22)
USBC_PD_I2C2_DATA: length 155.7
  TOP w0.1: v1(40.13,125.47) 40.25,125.6 42.54,125.6 43.05,126.11 R8F7.2
  LAY5 w0.125: v1(79.75,30.99) 80.13,31.37 99.89,31.37 102.31,28.95 103.93,28.95 104.69,29.71 111.37,29.71 112.13,30.47 114.35,30.47 115.2,29.62 J6J1.1
  LAY8 w0.1: v1(40.13,125.47) 39.75,125.09 39.75,110.23 39.46,109.95 39.46,102.65 40.38,101.73 40.38,98.17 42.54,96.01 42.92,96.01 44.32,94.61 44.32,85.34 46.73,82.93 46.73,80.52 48.64,78.61 48.64,73.79 49.5,72.92 49.5,70.95 53.84,66.61 54.67,66.61 60.07,61.21 61.59,61.21 64.77,58.04 64.77,55.75 68.83,51.69 68.83,49.83 73.45,45.21 74.67,45.21 76.58,43.31 76.58,42.75 79.37,39.96 79.37,31.37 v1(79.75,30.99)
USBC_PD_I2C_CLK: length 260.9
  TOP w0.1: R8E55.1 R8E54.1 ; R8E54.1 R8E51.1 ; R8E54.1 v1(42.79,135.13) ; v1(145.54,259.79) 145.54,260.48 R5A61.1
  LAY5 w0.125: v1(145.54,259.79) 145.07,260.26 140.93,260.26 140.07,259.4 134.86,259.4 131.43,255.97 129.34,255.97 128.51,255.14 127.47,255.14 126.84,254.5 125.85,254.5 125.31,253.96 112.62,253.96 111.89,253.23 107.59,253.23 107.07,253.75 104.32,253.75 103.66,253.09 96.88,253.09 96.57,252.79 93.37,252.79 93.2,252.61 82.96,252.61 81.98,253.59 77.87,253.59 74.04,257.43 70.48,257.43 69.85,256.79 63.37,256.79 62.02,255.44 60.42,255.44 60.07,255.78 53.27,255.78 52.78,256.28 46.72,256.28 v1(45.97,255.52)
  LAY6 w0.125: v1(45.97,255.52) 44.7,254.25 44.7,248.05 42.51,245.86 39.08,245.86 38.07,244.85 37.18,244.85 34.55,242.22 34.55,239.04 34.04,238.53 34.04,236.49 32.96,235.41 32.96,232.7 33.41,232.26 33.41,220.06 33.79,219.69 33.79,212.18 38.74,207.23 38.74,204.19 39.37,203.55 39.37,197.99 39.75,197.6 39.75,197.21 40.64,196.32 40.64,189.26 40.07,188.69 40.07,187.39 39.75,187.08 39.75,178.15 41.28,176.63 41.28,174.4 40.77,173.89 40.77,170.4 42.17,169.01 42.17,167.55 42.04,167.42 40.27,167.42 40.15,167.3 40.15,167.05 40.27,166.92 42.04,166.92 42.17,166.8 42.17,166.55 42.04,166.42 40.27,166.42 40.15,166.3 40.15,166.05 40.27,165.92 42.04,165.92 42.17,165.8 42.17,165.55 42.04,165.42 40.27,165.42 40.15,165.3 40.15,165.05 40.27,164.92 42.04,164.92 42.17,164.8 42.17,164.55 42.04,164.42 40.27,164.42 40.15,164.3 40.15,164.05 40.27,163.92 42.04,163.92 42.17,163.8 42.17,163.35 41.15,162.33 41.15,157.61 40.25,156.72 40.25,152.56 41.64,151.17 41.64,148.92 42.28,148.29 42.28,143.94 41.6,143.26 41.6,136.97 42.79,135.78 v1(42.79,135.13)
USBC_PD_I2C_CLK_EC: length 48.2
  TOP w0.1: v1(39.87,134.8) 40.81,134.8 R8E54.2 ; Q8G2.2 41.27,91.31 40.51,92.07 v1(40.13,92.07)
  LAY6 w0.125: v1(40.13,92.07) 40.89,92.84 40.89,97.31 40.02,98.19 40.02,100.6 40.38,100.96 40.38,101.85 40.51,101.98 40.51,104.52 39.99,105.04 39.99,111.39 41.27,112.67 41.27,132.92 39.87,134.32 v1(39.87,134.8)
USBC_PD_I2C_CLK_PCH: length 1.8
  TOP w0.1: Q8E9.3 39.68,133.98 40.76,133.98 41.02,134.24 R8E55.2
USBC_PD_I2C_DATA: length 266
  TOP w0.1: R5A62.1 146.53,260.37 146.53,259.97 146.55,259.94 v1(146.55,259.94) ; R8F7.1 43.3,127.38 43.3,128.27 42.67,128.9 R8F2.1 R8F1.1 42.64,129.79 v1(42.69,129.74)
  LAY5 w0.125: v1(146.55,259.94) 145.86,260.63 140.77,260.63 139.91,259.77 134.7,259.77 131.27,256.34 129.19,256.34 128.36,255.51 127.32,255.51 126.82,255.01 125.98,255.01 125.73,255.27 125.73,256.25 124.8,257.17 109.64,257.17 107.74,255.28 102.1,255.28 100.48,256.9 99.8,256.9 99.57,257.14 93.05,257.14 91.18,255.27 91.18,254.68 90.23,253.73 84.47,253.73 83.93,254.27 83.93,255.06 82.97,256.03 76.91,256.03 73.23,259.71 72.3,259.71 71.41,258.82 61.72,258.82 61.34,259.21 60.48,259.21 59.59,260.09 45.59,260.09 v1(43.56,258.06)
  LAY6 w0.125: v1(43.56,258.06) 44.19,258.06 46.48,255.78 46.48,255 45.59,254.11 45.59,252.6 46.22,251.97 46.22,249.17 45.59,248.54 45.59,247.65 44.45,246.51 43.68,246.51 42.67,245.49 39.24,245.49 38.22,244.47 37.33,244.47 34.92,242.06 34.92,238.89 34.41,238.38 34.41,236.34 33.33,235.26 33.33,232.86 33.78,232.41 33.78,220.22 34.16,219.84 34.16,212.34 39.11,207.39 39.11,204.34 39.75,203.71 39.75,198.14 40.13,197.76 40.13,197.36 41.02,196.47 41.02,189.1 40.45,188.53 40.45,187.13 40.13,186.82 40.13,178.31 41.65,176.78 41.65,174.24 41.14,173.73 41.14,170.56 42.54,169.16 42.54,163.19 41.52,162.18 41.52,152.79 42.02,152.29 42.02,149.08 42.65,148.44 42.65,143.78 41.98,143.1 41.98,137.13 43.3,135.8 43.3,130.35 v1(42.69,129.74)
USBC_PD_I2C_DATA_EC: length 44.5
  TOP w0.1: Q8G3.2 43.18,90.93 41.65,92.45 40.51,92.45 v1(40.13,92.84) ; R8F2.2 v1(40.38,128.9)
  LAY6 w0.125: v1(40.13,92.84) 40.64,93.35 40.64,97.2 39.23,98.62 39.23,105.73 39.73,106.24 39.73,111.49 41.02,112.78 41.02,128.39 40.51,128.9 v1(40.38,128.9)
USBC_PD_I2C_DATA_PCH: length 1.8
  TOP w0.1: R8F1.2 40.64,129.79 40.19,130.24 Q8E10.3
V_0P9_LAN: length 27.8
  TOP w0.2: EU4B1.40 v1(185.94,255.4) ; v1(184.27,255.4) 184.27,255.52 184.74,255.99 EU4B1.37 ; EU4B1.11 190.33,260.94 190.58,261.2 v1(190.58,261.41) ; EU4B1.46 188.34,255.64 v1(188.59,255.4) 188.74,255.55 EU4B1.47 ; EU4B1.43 v1(187.14,255.4) ; v1(187.94,263.12) EU4B1.16 ; v1(185.29,263.02) 185.29,262.76 185.54,262.51 EU4B1.22
  TOP w0.38: v1(188.59,255.4) 188.59,255.14 188.84,254.89 C4B8.1 ; C4B2.1 194.69,257.5 v1(194.66,257.48) ; C4A29.1 191.38,261.91 190.88,261.41 v1(190.58,261.41) ; C4B7.1 183.51,254.76 184.15,255.4 v1(184.27,255.4) ; C4A26.1 188.08,263.66 187.94,263.52 v1(187.94,263.12) ; C4A24.1 v1(185.29,263.02)
  LAY5 w0.38: v1(190.58,261.41) 192.27,259.71 193.62,259.71 v1(193.64,259.69)
  LAY6 w0.38: v1(188.59,255.4) 189.35,254.63 193.04,254.63 194.69,256.28 194.69,257.45 v1(194.66,257.48) ; 189.73,261.36 189.78,261.41 v1(190.58,261.41)
V_3P3_A_APS: length 6.2
  TOP w0.1: J9H3.3 16.51,38.73 19.3,38.73 R9H15.2
V_5P0_STBY_R117BV: length 10.4
  TOP w0.1: CR7B1.1 70.23,249.93 68.26,251.9 Q7B5.3 65.78,252.98 66.67,253.87 R7B8.1 67.94,254.76
V_C_2: length 4
  TOP w0.1: U9C1.2 12.71,222.9 11.93,222.12 11.17,222.12 10.66,221.61 C9C1.1
V_C_6: length 3
  TOP w0.1: C9C4.1 14.45,221.59 15.31,222.45 U9C1.6
V_CPU_VCCIO_R119BV: length 10
  TOP w0.1: Q8C7.5 Q8C7.2 33.4,205.85 R8C50.2 34.03,204.09 34.67,203.45 34.67,201.55 34.81,201.41 Q8C9.2 36.08,201.41 36.19,201.29 36.19,200.91 36.03,200.76 Q8C9.3
V_HDMID_SCL: length 8.3
  TOP w0.1: R2A3.1 245.23,275.33 245.49,275.33 246.15,274.67 248,274.67 248.41,275.08 248.41,275.72 250.44,277.75 CR2A2.1
V_HDMID_SDA: length 2.1
  TOP w0.1: R2A5.1 248.65,277.23 CR2A2.2
V_PPHV_EN-1: length 3.4
  TOP w0.1: Q6A2.5 126.73,266.46 126.61,266.57 125.09,266.57 R6A73.2 R6A75.1
V_PPHV_EN-2: length 7.8
  TOP w0.1: Q6A1.2 121.01,270.24 121.28,270.51 122.42,270.51 124.07,268.86 125.22,268.86 126.08,268 Q6A2.3
V_SA0_DIMM0_CHA: length 4.1
  TOP w0.1: R5E49.2 160.23,134.66 160.23,131.82 160.39,131.66 J1E5.139
V_SA0_DIMM0_CHB: length 13.2
  TOP w0.089: 160.39,113.46 159.8,114.04 159.76,114.04
  TOP w0.1: 160.39,113.46 J1F2.139 ; 159.76,114.04 159.63,114.17 153.67,114.17 153.41,114.43 153.41,116.97 153.03,117.35 151.38,117.35 R5F3.2
V_SA0_DIMM1_CHA: length 15.9
  TOP w0.1: R5E54.1 150.87,132.84 153.42,130.29 153.42,126.51 155.09,124.84 159.43,124.84 160.35,123.92 J1F1.139
V_SA0_DIMM1_CHB: length 10.7
  TOP w0.1: J1F3.139 159.93,104.57 159.26,105.23 159.08,105.23 159.07,105.23 158.42,105.23 158.42,105.23 157.81,105.23 157.8,105.23 157.15,105.23 157.15,105.23 156.54,105.23 156.53,105.23 156,105.23 155.7,105.54 155.19,105.54 154.94,105.28 154.55,105.28 154.3,105.54 154.3,107.06 154.17,107.19 153.36,107.19 R5F15.1 152.86,106.68 R5F14.2
V_SA1_DIMM0_CHA: length 6.5
  TOP w0.1: J1E5.140 159.33,130.06 157.86,131.53 157.86,132.06 157.6,132.32 157.6,134.75 R5E50.1
V_SA1_DIMM0_CHB: length 10.4
  TOP w0.1: J1F2.140 159.54,111.86 158.75,112.65 153.28,112.65 R5F7.2
V_SA1_DIMM1_CHA: length 24.3
  TOP w0.1: J1F1.140 159.54,122.28 159.38,122.44 159.38,124.29 159.06,124.61 154.99,124.61 153.19,126.41 153.19,130.2 151.35,132.05 149.25,132.05 148.84,132.46 148.84,135.51 149.22,135.89 150.11,135.89 150.87,135.13 R5E53.2
V_SA1_DIMM1_CHB: length 8.8
  TOP w0.1: J1F3.140 158.71,103.76 156.59,103.76 155.95,104.39 154.3,104.39 152.9,105.79 R5F17.1 R5F16.2
V_VDDQ_VR_OUT_R: length 3.9
  TOP w0.3: R2G31.2 C2G24.1 R2G22.1 259.58,78.23 R2G25.1 C2G23.1
VBOOT_TYPEC_PG_BP: length 2.1
  TOP w0.3: C6A36.1 116.07,265.81 115.42,265.16 EU6A2.13
VCORE_BT1: length 2
  TOP w0.3: 243.71,244.99 243.71,246.64 C2B7.1
VCORE_BT1_R: length 1.3
  TOP w0.3: 243.96,248.28 242.69,248.28
VCORE_BT2: length 2
  TOP w0.3: C3B23.1 230.4,246.66 EU3B2.5
VCORE_BT2_R: length 1.3
  TOP w0.3: 229.36,248.28 230.63,248.28
VCORE_BT3: length 2
  TOP w0.3: C3B21.1 220.34,246.64 220.34,244.99
VCORE_BT3_R: length 1.3
  TOP w0.3: 220.59,248.28 219.32,248.28
VCORE_BT4: length 2
  TOP w0.3: C3B20.1 207.03,246.66 EU3B1.5
VCORE_BT4_R: length 1.3
  TOP w0.3: 205.99,248.28 207.26,248.28
VCORE_BT5: length 1.9
  TOP w0.3: 266.95,244.99 266.95,246.88 C2B10.1
VCORE_BT5_R: length 1.1
  TOP w0.3: 265.81,248.28 266.95,248.28
VCORE_BT6: length 2
  TOP w0.3: EU2B2.5 253.64,246.66 C2B9.1
VCORE_BT6_R: length 1.3
  TOP w0.3: 252.6,248.28 253.87,248.28
VCORE_BT7: length 2
  TOP w0.3: 197.36,244.99 197.36,246.64 C4B21.1
VCORE_BT7_R: length 1.3
  TOP w0.3: 197.61,248.28 196.34,248.28
VCORE_BT8: length 2
  TOP w0.3: EU4B3.5 184.05,246.66 C4B20.1
VCORE_BT8_R: length 1.3
  TOP w0.3: 183,248.28 184.27,248.28
VCORE_COMP: length 3.7
  TOP w0.2: R2B29.1 C2B20.1 279.27,237.49 279.54,237.22 EU1B1.14
VCORE_DB_VREF1: length 65.2
  TOP w0.2: v1(284.6,239.27) 284.48,239.14 283.97,239.14 283.21,238.38 R1B25.1
  LAY6 w0.2: v1(284.6,239.27) 284.6,239.09 283.5,238 281.43,238 278.8,240.62 273.68,240.62 272.36,241.94 272.36,245.88 270.01,248.23 264.8,248.23 263.78,249.25 259.19,249.25 258.3,248.36 239.97,248.36 239.52,247.9 239.52,244.98 238.63,244.09 237.97,244.09 237.73,243.85 237.73,243.34 v1(238.25,242.82)
  BOTTOM w0.2: v1(238.25,242.82) 238.88,242.82 239.14,242.57 R3M25.1 237.99,242.31 237.43,242.87 EU3M1.16
VCORE_DB_VREF2: length 91.1
  TOP w0.2: v1(283.97,240.79) 283.71,240.54 283.71,239.93 282.85,239.06 282.57,239.06 282.19,238.68 R1B24.1
  LAY6 w0.2: v1(283.97,240.79) 283.97,240.67 283.21,239.91 283.21,239.39 282.7,238.89 282.06,238.89 279.45,241.5 274.2,241.5 273.5,242.2 273.5,248.04 271.22,250.31 236.85,250.31 234.89,248.36 217.49,248.36 216.28,247.14 216.28,244.85 215.51,244.09 214.63,244.09 214.37,243.84 214.37,243.2 214.75,242.82 v1(214.88,242.82)
  BOTTOM w0.2: v1(214.88,242.82) 215.13,242.82 215.39,242.57 R3M24.1 215.26,242.19 214.63,242.19 214.07,242.75 EU3M2.16
VCORE_DB_VREF3: length 37.5
  TOP w0.2: R1B26.1 284.75,238.12 284.93,237.94 v1(285.11,237.94)
  LAY6 w0.2: v1(261.49,242.85) 260.98,243.36 260.98,243.82 261.26,244.09 262.3,244.09 262.8,244.6 264.28,244.6 265.75,246.07 270.56,246.07 271.34,245.29 271.34,241.18 273.26,239.26 278.72,239.26 281,236.98 284.09,236.98 285.06,237.94 v1(285.11,237.94)
  BOTTOM w0.2: EU2M1.16 260.67,242.87 261.36,242.19 262.38,242.19 R2M9.1 261.97,242.85 v1(261.49,242.85)
VCORE_DB_VREF4: length 111.8
  TOP w0.2: R1B28.1 281.05,238.73 282.57,240.26 v1(282.57,240.41)
  LAY6 w0.2: v1(282.57,240.41) 282.14,240.41 280.17,242.39 274.96,242.39 274.52,242.83 274.52,248.55 271.8,251.26 233.48,251.26 232.28,250.06 217.59,250.06 216.14,248.61 207.5,248.61 207,248.1 193.62,248.1 193.16,247.65 193.16,244.85 192.4,244.09 191.64,244.09 191.38,243.84 191.38,243.2 191.77,242.82 v1(191.89,242.82)
  BOTTOM w0.2: EU4M1.16 191.08,242.87 191.64,242.31 R4M17.1 192.65,242.62 192.45,242.82 v1(191.89,242.82)
VCORE_IC_FB: length 10.8
  TOP w0.2: C1B6.1 R1B17.1 282.7,242.44 282.32,242.06 281.17,242.06 281.05,242.19 R1B19.1 C1B10.1 R1B21.1 280.54,239.77 R2B29.2 C2B20.2 279.94,238.36 EU1B1.13
VCORE_IMON: length 3.5
  TOP w0.2: EU1B1.25 276.94,231.61 275.97,230.63 275.46,230.63
VCORE_ISEN1N: length 16.2
  TOP w0.2: ISO3B8.2 243.23,230.88 243.23,233.27 242.82,233.68 241.26,233.68 237.96,236.98 237.44,236.98 v1(237.39,236.92)
  BOTTOM w0.2: v1(237.39,236.92) 237.02,237.29 237.02,239.73 236.72,240.03 C3M25.1 R3M27.1 C3M20.1 236.34,241.94 EU3M1.2
VCORE_ISEN1N_SUM: length 1.8
  TOP w0.2: R1B25.2 283.21,236.98 282.74,236.51 EU1B1.6
VCORE_ISEN1P: length 3.7
  BOTTOM w0.2: R3M31.2 237.36,239.77 R3M27.2 C3M20.2 236.84,242.33 EU3M1.1
VCORE_ISEN1P_SUM: length 63.2
  TOP w0.2: EU1B1.5 283.14,236.4 283.71,236.98 283.71,238.35 284,238.63 v1(284.98,238.63)
  LAY6 w0.2: v1(238.25,243.58) 238.43,243.77 238.76,243.77 239.84,244.85 239.84,247.77 240.11,248.03 258.44,248.03 259.33,248.92 263.65,248.92 264.66,247.9 269.87,247.9 272.03,245.74 272.03,241.81 273.54,240.29 278.62,240.29 281.3,237.62 283.59,237.62 284.6,238.63 v1(284.98,238.63)
  BOTTOM w0.2: v1(238.25,243.58) 237.99,243.84 EU3M1.15
VCORE_ISEN2N: length 16.2
  TOP w0.2: ISO3B7.2 231.26,232.97 231.72,233.42 232.66,233.42 233.8,234.57 233.8,236.02 234,236.22 235.33,236.22 v1(235.45,236.09)
  BOTTOM w0.2: v1(235.45,236.09) 235.96,236.6 235.96,237.11 235.07,238 235.07,239.65 235.45,240.03 C3M26.1 235.68,240.13 R3M26.1 C3M19.1 235.84,241.99 EU3M1.3
VCORE_ISEN2N_SUM: length 1.7
  TOP w0.2: R1B24.2 281.94,237.11 EU1B1.8
VCORE_ISEN2P: length 3.2
  BOTTOM w0.2: R3M32.2 234.79,240.26 R3M26.2 C3M19.2 235.34,242.38 EU3M1.4
VCORE_ISEN2P_SUM: length 88.5
  TOP w0.2: v1(284.22,240.03) 284.22,239.97 282.98,238.74 282.85,238.74 282.7,238.59 282.7,236.98 282.34,236.62 EU1B1.7
  LAY6 w0.2: v1(214.88,243.58) 215.47,243.58 216.6,244.72 216.6,247.01 217.63,248.03 235.07,248.03 237.03,249.99 271.09,249.99 273.17,247.9 273.17,242.06 274.06,241.17 279.27,241.17 281.88,238.56 282.88,238.56 283.53,239.21 283.53,239.77 283.79,240.03 v1(284.22,240.03)
  BOTTOM w0.2: EU3M2.15 214.62,243.84 v1(214.88,243.58)
VCORE_ISEN3N: length 16.3
  TOP w0.2: v1(213.61,237.06) 213.69,236.98 214.47,236.98 217.77,233.68 219.45,233.68 219.86,233.27 219.86,230.88 ISO3B6.2
  BOTTOM w0.2: EU3M2.2 212.97,242.44 213.1,242.31 C3M22.1 R3M29.1 C3M29.1 213.61,239.39 213.61,237.97 213.53,237.89 213.53,237.16 213.61,237.08 v1(213.61,237.06)
VCORE_ISEN3N_SUM: length 1.8
  TOP w0.2: R1B26.2 284.35,237.09 283.54,236.27 EU1B1.4
VCORE_ISEN3P: length 3.5
  BOTTOM w0.2: R3M30.2 213.99,240.03 R3M29.2 C3M22.2 213.47,242.2 EU3M2.1
VCORE_ISEN3P_SUM: length 34.1
  TOP w0.2: EU1B1.3 283.94,236.21 284.45,236.73 284.86,236.73 285.11,236.98 v1(285.11,237.23)
  LAY6 w0.2: v1(261.49,243.58) 261.67,243.77 262.43,243.77 262.94,244.27 264.42,244.27 265.89,245.74 270.38,245.74 271.01,245.11 271.01,241.04 273.13,238.93 278.59,238.93 280.92,236.6 284.18,236.6 284.7,237.12 285,237.12 v1(285.11,237.23)
  BOTTOM w0.2: v1(261.49,243.58) 261.49,243.64 261.29,243.84 EU2M1.15
VCORE_ISEN4N: length 16
  TOP w0.2: v1(211.96,236.09) 211.83,236.22 210.63,236.22 210.43,236.02 210.43,234.57 209.29,233.42 208.35,233.42 207.89,232.97 ISO3B5.2
  BOTTOM w0.2: EU3M2.3 212.47,242.31 212.31,242.16 C3M21.1 R3M28.1 212.31,240 C3M30.1 212.06,239.88 211.7,239.52 211.7,238.12 212.47,237.36 212.47,236.6 v1(211.96,236.09)
VCORE_ISEN4N_SUM: length 1.1
  TOP w0.2: R1B28.2 281.14,236.76 EU1B1.10
VCORE_ISEN4P: length 3.3
  BOTTOM w0.2: R3M33.2 211.42,240.13 R3M28.2 C3M21.2 211.97,242.25 EU3M2.4
VCORE_ISEN4P_SUM: length 108.6
  TOP w0.2: v1(282.62,239.57) 281.54,238.49 EU1B1.9
  LAY6 w0.2: v1(191.89,243.58) 192.07,243.77 192.54,243.77 193.49,244.72 193.49,247.51 193.75,247.78 207.13,247.78 207.64,248.28 216.28,248.28 217.73,249.73 232.46,249.73 233.66,250.94 271.66,250.94 274.19,248.41 274.19,242.7 274.82,242.06 280.03,242.06 282.52,239.57 v1(282.62,239.57)
  BOTTOM w0.2: EU4M1.15 191.63,243.84 v1(191.89,243.58)
VCORE_ISEN5N: length 16
  TOP w0.2: v1(260.35,237.49) 261.04,236.79 261.27,236.79 264.38,233.68 266.06,233.68 266.47,233.27 266.47,230.88 ISO2B5.2
  BOTTOM w0.2: EU2M1.2 259.58,241.94 C2M6.1 R2M11.1 C2M8.1 259.96,240.03 260.35,239.65 v1(260.35,237.49)
VCORE_ISEN5P: length 3.7
  BOTTOM w0.2: R2M12.2 260.6,240.03 R2M11.2 C2M6.2 260.08,242.33 EU2M1.1
VCORE_ISEN6N: length 16.1
  TOP w0.2: ISO2B4.2 254.5,232.97 254.96,233.42 255.9,233.42 257.04,234.57 257.04,236.22 257.28,236.46 258.68,236.46 v1(259.33,237.11)
  BOTTOM w0.2: v1(259.33,237.11) 258.31,238.12 258.31,239.65 258.69,240.03 C2M9.1 258.92,240.13 R2M10.1 C2M5.1 259.08,241.99 EU2M1.3
VCORE_ISEN6P: length 3.2
  BOTTOM w0.2: EU2M1.4 258.58,242.38 C2M5.2 R2M10.2 258.03,240.26 R2M13.2
VCORE_ISEN7N: length 17.1
  TOP w0.2: v1(190.94,236.41) 191.13,236.6 191.99,236.6 194.91,233.68 196.46,233.68 196.87,233.27 196.87,230.88 ISO4B4.2
  BOTTOM w0.2: EU4M1.2 189.98,242.31 190.11,242.18 C4M16.1 R4M18.1 190.24,240.79 C4M19.1 190.5,239.9 190.75,239.65 190.75,237.87 190.37,237.49 190.37,236.85 190.81,236.41 v1(190.94,236.41)
VCORE_ISEN7P: length 3.5
  BOTTOM w0.2: EU4M1.1 190.48,242.33 C4M16.2 R4M18.2 191,240.28 191.51,239.77 R4M20.2
VCORE_ISEN8N: length 16.1
  TOP w0.2: v1(189.1,236.09) 188.97,236.22 187.65,236.22 186.94,235.51 186.94,234.06 186.3,233.42 185.36,233.42 184.91,232.97 ISO4B3.2
  BOTTOM w0.2: v1(189.1,236.09) 189.61,236.6 189.61,237.11 188.84,237.87 188.84,239.65 189.1,239.9 C4M20.1 R4M19.1 C4M17.1 189.35,242.18 189.48,242.31 EU4M1.3
VCORE_ISEN8P: length 3.3
  BOTTOM w0.2: EU4M1.4 188.98,242.33 C4M17.2 R4M19.2 188.46,240.03 R4M21.2
VCORE_NTC1N: length 26.6
  TOP w0.2: RT2B1.1 v1(248.53,234.19) ; ISO2B3.2 v1(271.14,231.32)
  LAY6 w0.2: v1(271.14,231.32) 270.66,231.32 269.44,232.54 262.5,232.54 261.87,231.9 257.04,231.9 256.34,232.61 250.76,232.61 249.43,233.93 248.79,233.93 v1(248.53,234.19)
VCORE_NTC1P: length 27.1
  TOP w0.2: RT2B1.2 v1(248.52,233.31) ; v1(271.14,230.62) 271.34,230.82 271.71,230.82 272.28,231.39 R2B49.1
  LAY6 w0.2: v1(248.52,233.31) 248.81,233.61 249.3,233.61 250.62,232.28 256.2,232.28 256.91,231.57 262,231.57 262.64,232.21 269.31,232.21 270.9,230.62 v1(271.14,230.62)
VCORE_PH1: length 1.9
  TOP w0.3: 242.71,244.99 242.71,246.87 R3B35.1
VCORE_PH1_SNB: length 1.3
  BOTTOM w0.5: R2M17.2 247.9,239.77 C2M10.1
VCORE_PH1_VDRV: length 3.1
  TOP w0.3: R2B16.1 C2B13.1 247.77,243.58 247.51,243.32 EU2B3.29
VCORE_PH1_VIN: length 3.3
  TOP w0.3: 244.71,244.99 244.71,246.24 C2B8.1 R2B6.2
VCORE_PH2: length 1.9
  TOP w0.3: R3B34.1 229.4,246.84 EU3B2.7
VCORE_PH2_SNB: length 1.2
  BOTTOM w0.5: R3M36.2 226.06,239.52 C3M27.1
VCORE_PH2_VCIN: length 3.6
  TOP w0.3: R3B27.2 231.9,246.89 R3B36.1 231.14,246.12 231.14,245.76 231.4,245.49 EU3B2.3
VCORE_PH2_VDRV: length 3
  TOP w0.3: R3B42.1 C3B33.1 234.44,243.58 234.2,243.34 EU3B2.29
VCORE_PH3: length 1.9
  TOP w0.3: 219.34,244.99 219.34,246.87 R3B33.1
VCORE_PH3_SNB: length 1.1
  BOTTOM w0.5: C3M28.1 224.66,239.27 R3M37.2
VCORE_PH3_VCIN: length 3.4
  TOP w0.3: R3B28.2 C3B22.1 221.86,246.89 221.34,246.37 221.34,244.99
VCORE_PH3_VDRV: length 3.1
  TOP w0.3: R3B40.1 C3B32.1 224.4,243.58 224.14,243.32 EU3B3.29
VCORE_PH4: length 1.9
  TOP w0.3: R4B26.1 206.03,246.84 EU3B1.7
VCORE_PH4_SNB: length 1.2
  BOTTOM w0.5: C4M21.1 203.07,238.89 R4M24.2
VCORE_PH4_VCIN: length 3.5
  TOP w0.3: EU3B1.3 208.03,245.49 207.89,245.63 207.89,246.25 C3B24.1 208.53,246.89 R3B26.2
VCORE_PH4_VDRV: length 3
  TOP w0.3: EU3B1.29 210.83,243.34 211.07,243.58 C3B29.1 R3B41.1
VCORE_PH5: length 2
  TOP w0.3: 265.95,244.99 265.95,246.12 265.81,246.27 R2B11.1
VCORE_PH5_SNB: length 2.2
  TOP w0.5: C2B19.1 259.84,241.68 260.22,241.3 R2B31.2
VCORE_PH5_VCIN: length 3.6
  TOP w0.3: R2B7.2 268.22,247.27 R2B9.1 267.95,247.26 267.95,244.99
VCORE_PH5_VDRV: length 3
  TOP w0.3: R2B19.1 272.16,243.58 C2B16.1 271.01,243.58 270.75,243.32 EU2B4.29
VCORE_PH6: length 1.9
  TOP w0.3: R2B10.1 252.64,246.84 EU2B2.7
VCORE_PH6_SNB: length 1.2
  BOTTOM w0.5: C2M11.1 249.8,238.89 R2M16.2
VCORE_PH6_VCIN: length 3.5
  TOP w0.3: R2B5.2 255.14,246.89 C2B11.1 254.5,246.25 254.5,245.63 254.64,245.49 EU2B2.3
VCORE_PH6_VDRV: length 3
  TOP w0.3: EU2B2.29 257.44,243.34 257.68,243.58 C2B14.1 R2B17.1
VCORE_PH7: length 1.9
  TOP w0.3: R4B25.1 196.36,246.87 196.36,244.99
VCORE_PH7_SNB: length 1.3
  BOTTOM w0.5: R4M25.2 201.54,239.01 C4M22.1
VCORE_PH7_VCIN: length 3.3
  TOP w0.3: 198.36,244.99 198.36,246.24 C4B22.1 R4B21.2
VCORE_PH7_VDRV: length 3.1
  TOP w0.3: EU4B4.29 201.15,243.32 201.42,243.58 C4B30.1 R4B28.1
VCORE_PH8: length 1.9
  TOP w0.3: EU4B3.7 183.05,246.84 R4B24.1
VCORE_PH8_SNB: length 1.6
  BOTTOM w0.5: 180.97,239.39 179.57,239.39 C4M23.1
VCORE_PH8_VCIN: length 3.5
  TOP w0.3: EU4B3.3 185.05,245.49 184.91,245.63 184.91,246.25 C4B24.1 185.54,246.89 R4B20.2
VCORE_PH8_VDRV: length 3
  TOP w0.3: EU4B3.29 187.84,243.34 188.08,243.58 C4B28.1 R4B29.1
VCORE_PSYS: length 6.8
  TOP w0.2: R2C15.2 277.49,223.9 277.13,224.26 277.13,225.7 C2C1.2 277.62,227.4 278.23,228.02 278.94,228.02 279.54,228.61 EU1B1.32
VCORE_PWM1: length 67.8
  TOP w0.2: EU1B1.55 286.16,233.21 v1(287.02,234.06)
  LAY6 w0.2: v1(238.25,246) 237.87,246 236.75,244.88 236.75,240.77 241.3,236.22 244.6,236.22 246.12,237.74 250.95,237.74 252.47,236.22 257.81,236.22 258.19,235.84 259.84,235.84 260.22,236.22 263.77,236.22 264.54,235.46 270.51,235.46 270.89,235.08 272.41,235.08 273.17,235.84 273.17,237.11 273.76,237.69 278.18,237.69 280.86,235.01 280.86,234.5 281.55,233.81 285.36,233.81 285.62,233.55 286.51,233.55 v1(287.02,234.06)
  BOTTOM w0.3: v1(238.25,246) 238.88,246.63 R3M15.2
VCORE_PWM1_R: length 3.4
  BOTTOM w0.2: EU3M1.13 237.6,244.84 237.74,244.98 237.74,246.89 R3M15.1 R3M13.1
VCORE_PWM2: length 93.1
  TOP w0.2: v1(287.02,233.3) 286.53,232.81 EU1B1.54
  LAY6 w0.2: v1(287.02,233.3) 286.63,232.92 285.36,232.92 284.98,233.3 281.43,233.3 280.41,234.31 280.41,234.95 278,237.36 274.06,237.36 273.64,236.94 273.64,235.8 272.46,234.62 270.71,234.62 270.51,234.82 263.9,234.82 263.14,235.58 260.47,235.58 260.09,235.2 257.93,235.2 257.55,235.58 252.09,235.58 250.69,236.98 246.38,236.98 244.98,235.58 237.49,235.58 236.85,234.95 235.58,234.95 234.44,233.81 219.96,233.81 213.36,240.41 213.36,244.85 214.88,246.38 v1(215.26,246.38)
  BOTTOM w0.2: v1(215.26,246.38) 215.51,246.63 R3M14.2
VCORE_PWM2_R: length 2.8
  BOTTOM w0.2: R3M14.1 214.37,247.01 214.37,244.98 214.23,244.84 EU3M2.13
VCORE_PWM3: length 41.3
  TOP w0.2: v1(286.25,234.06) 285.8,233.61 EU1B1.56
  LAY6 w0.2: v1(261.49,247.27) 259.96,245.74 259.96,241.04 264.79,236.22 270.38,236.22 271.14,235.46 272.16,235.46 272.79,236.09 272.79,237.36 273.48,238.05 278.33,238.05 281.3,235.08 281.3,234.69 281.81,234.19 286.13,234.19 v1(286.25,234.06)
  BOTTOM w0.2: R2M3.2 262.12,247.9 v1(261.49,247.27)
VCORE_PWM3_R: length 2.9
  BOTTOM w0.2: R2M3.1 260.98,245.74 260.98,244.98 260.84,244.84 EU2M1.13
VCORE_PWM4: length 115.4
  TOP w0.2: EU1B1.53 285.9,232.41 v1(286.02,232.28)
  LAY6 w0.2: v1(286.02,232.28) 285.58,231.84 283.52,231.84 282.44,232.92 281.17,232.92 280.03,234.06 280.03,234.82 277.87,236.98 275.33,236.98 273.29,234.94 273.29,234.05 272.82,233.59 270.98,233.59 270.38,234.19 263.52,234.19 263.27,234.44 257.42,234.44 257.04,234.82 251.71,234.82 250.31,236.22 246.63,236.22 245.23,234.82 239.14,234.82 238.81,234.49 235.88,234.49 234.56,233.17 219.45,233.17 216.53,236.09 213.86,236.09 212.21,234.44 196.34,234.44 190.37,240.41 190.37,244.73 191.64,246 v1(192.15,246)
  BOTTOM w0.2: 192.53,246.76 192.53,246.38 v1(192.15,246)
VCORE_PWM4_R: length 3.5
  BOTTOM w0.2: EU4M1.13 191.25,244.84 191.38,244.98 191.38,246.12 191.97,246.71 191.97,247.09 R4M11.1
VCORE_PWM_PH1: length 2.1
  TOP w0.2: v1(246.35,246.1) 245.71,245.46 245.71,244.99
  BOTTOM w0.2: R2M8.2 246.35,245.46 v1(246.35,246.1)
VCORE_PWM_PH1_R: length 20
  LAY5 w0.2: v1(247.26,244.09) 246.63,243.46 246.63,241.17 245.87,240.41 240.03,240.41 239.26,241.17 236.22,241.17 233.93,243.46 v1(233.93,243.97)
  BOTTOM w0.2: v1(233.93,243.97) 234.05,243.84 EU3M1.6 ; R2M8.1 246.88,244.47 v1(247.26,244.09)
VCORE_PWM_PH2: length 3.3
  TOP w0.2: v1(233.8,247.01) 232.4,245.61 EU3B2.1
  BOTTOM w0.2: R3M17.2 v1(233.8,247.01)
VCORE_PWM_PH2_R: length 2.4
  BOTTOM w0.2: R3M17.1 234.56,245.49 234.18,245.11 234.18,244.54 234.38,244.34 EU3M1.7
VCORE_PWM_PH3: length 2.1
  TOP w0.2: 222.34,244.99 222.34,245.46 222.75,245.87 v1(222.75,246.1)
  BOTTOM w0.2: R3M23.2 222.75,245.49 v1(222.75,246.1)
VCORE_PWM_PH3_R: length 20
  LAY5 w0.2: v1(210.56,243.97) 210.56,243.58 214.24,239.9 216.02,239.9 216.53,240.41 221.86,240.41 223.26,241.81 223.26,243.46 v1(223.9,244.09)
  BOTTOM w0.2: EU3M2.6 210.68,243.84 v1(210.56,243.97) ; R3M23.1 223.52,244.47 v1(223.9,244.09)
VCORE_PWM_PH4: length 3.5
  TOP w0.2: v1(210.43,247.14) 210.43,247.01 209.03,245.61 EU3B1.1
  BOTTOM w0.2: v1(210.43,247.14) 210.56,247.01 R3M18.2
VCORE_PWM_PH4_R: length 2.4
  BOTTOM w0.2: EU3M2.7 211.02,244.34 210.82,244.54 210.82,245.11 211.2,245.49 R3M18.1
VCORE_PWM_PH5: length 2.2
  TOP w0.2: R2B18.2 269.36,245.62 268.95,245.21 268.95,244.99
VCORE_PWM_PH5_R: length 21
  TOP w0.2: v1(269.62,244.98) 270.51,244.98 R2B18.1
  LAY5 w0.2: v1(269.62,244.98) 269.49,244.85 269.49,240.92 268.98,240.41 263.65,240.41 263.14,239.9 260.73,239.9 257.17,243.46 v1(257.17,243.97)
  BOTTOM w0.2: v1(257.17,243.97) 257.29,243.84 EU2M1.6
VCORE_PWM_PH6: length 3.3
  TOP w0.2: EU2B2.1 255.64,245.61 v1(257.04,247.01)
  BOTTOM w0.2: R2M5.2 v1(257.04,247.01)
VCORE_PWM_PH6_R: length 2.4
  BOTTOM w0.2: R2M5.1 257.81,245.49 257.42,245.11 257.42,244.54 257.62,244.34 EU2M1.7
VCORE_PWM_PH7: length 2.1
  TOP w0.2: v1(199.89,246.12) 199.89,245.87 199.36,245.33 199.36,244.99
  BOTTOM w0.2: v1(199.89,246.12) R4M16.2
VCORE_PWM_PH7_R: length 20.4
  LAY5 w0.2: v1(200.91,244.09) 200.02,243.2 200.02,240.66 199.64,240.28 193.29,240.28 192.91,239.9 191.38,239.9 187.57,243.71 v1(187.57,243.97)
  BOTTOM w0.2: R4M16.1 200.53,244.47 v1(200.91,244.09) ; v1(187.57,243.97) 187.7,243.84 EU4M1.6
VCORE_PWM_PH8: length 3.5
  TOP w0.2: EU4B3.1 186.05,245.61 187.45,247.01 v1(187.45,247.14)
  BOTTOM w0.2: v1(187.45,247.14) 187.57,247.01 R4M13.2
VCORE_PWM_PH8_R: length 2.4
  BOTTOM w0.2: EU4M1.7 188.03,244.34 187.83,244.54 187.83,245.11 188.21,245.49 R4M13.1
VCORE_SENSE_IC_N: length 6.3
  TOP w0.2: EU1B1.16 278.58,236.53 277.24,237.87 R2B34.1 277.74,238.63 277.74,239.65 277.49,239.9 R2B24.1
VCORE_SENSE_IC_P: length 6.3
  TOP w0.2: EU1B1.15 279.14,236.73 278.25,237.62 R2B32.1 278.76,238.76 278.76,240.03 R2B25.2 279.01,240.28 279.01,241.04 R2B20.2
VCORE_SET1: length 6.8
  TOP w0.2: R2B39.1 273.55,235.28 274.26,234.57 R2B42.2 274.95,234.06 274.95,233.42 R2B46.1 275.59,232.92 276.17,232.34 278.18,232.34 278.25,232.41 EU1B1.23
VCORE_SET2: length 3.9
  TOP w0.2: R2B50.1 275.46,232.15 275.71,232.15 275.86,232.01 EU1B1.24
VCORE_SET3: length 4.9
  TOP w0.2: R2B62.2 R2B60.1 276.33,227.96 277.47,229.11 277.47,229.98 277.9,230.41 EU1B1.28
VCORE_SET4: length 5.9
  TOP w0.2: R2C5.1 R2C3.2 276.22,226.44 276.47,226.69 276.47,227.65 277.8,228.97 277.8,229.81 278,230.01 EU1B1.29
VCORE_SET5: length 7.4
  TOP w0.2: EU1B1.31 279.14,228.72 278.76,228.34 278.1,228.34 277.13,227.38 277.13,226.2 276.8,225.88 276.8,223.85 R2C11.1 R2C14.2
VCORE_SM_SCL: length 80.1
  TOP w0.1: v1(279.01,215.52) 278.63,215.52 278.13,216.03 278.13,216.79 R2C24.2 278.13,217.8 278.13,219.07 R2C20.1 278.91,219.86 278.91,223.59 279.42,224.09 279.42,226.59 280.34,227.51 EU1B1.34
  LAY3 w0.1: v1(282.7,195.45) 282.7,196.47 284.6,198.37 287.65,198.37 296.03,189.99 296.03,169.54 J1D9.2
  LAY6 w0.125: v1(282.7,195.45) 282.21,195.45 277.11,200.55 277.11,208.64 279.65,211.17 279.65,214.88 v1(279.01,215.52)
VCORE_SM_SDA: length 77.8
  TOP w0.1: R2C25.2 280.79,217.3 v1(281.05,217.55) 280.54,218.06 280.54,218.44 R2C21.1 279.14,219.84 279.14,223.49 279.65,224 279.65,226.44 280.74,227.53 EU1B1.35
  LAY3 w0.1: v1(283.46,195.45) 283.46,196.72 284.73,197.99 287.52,197.99 295.4,190.12 295.4,171.45 J1D9.1
  LAY6 w0.125: v1(281.05,217.55) 281.05,215.39 280.16,214.5 280.16,211.33 277.36,208.53 277.36,200.66 282,196.02 282.89,196.02 v1(283.46,195.45)
VCORE_TSEN: length 56.5
  TOP w0.2: v1(236.57,233.3) 236.47,233.4 236.47,237.24 238.4,239.17 239.04,239.17 239.88,240.01 240.17,240.01 240.41,239.77 RT3B1.1 ; R2B37.2 274.54,235.3 275.1,234.75 v1(275.1,234.69) 275.53,234.26 275.53,233.73 276.6,232.66 277.98,232.66 278.13,232.81 EU1B1.22
  LAY6 w0.2: v1(275.1,234.69) 274.52,234.69 274.19,234.36 274.19,233.68 273.17,232.66 270.63,232.66 270.12,233.17 262.89,233.17 262.63,233.42 256.79,233.42 256.66,233.55 251.2,233.55 249.8,234.95 247.39,234.95 245.99,233.55 236.83,233.55 v1(236.57,233.3)
VCORE_VCC_IC: length 58.1
  TOP w0.2: EU1B1.33 279.94,228.25 279.71,228.03
  TOP w0.38: 286,237.87 286,240.36 v1(286.13,240.48) 285.54,240.48 284.98,241.04 R1B20.2
  TOP w0.5: v1(277.49,219.45) 276.09,219.45 275.71,219.84 R2C23.2 R2C22.2 ; 279.71,228.03 279.14,227.46 C2B23.1 278.94,227 278.94,225.19 v1(278.32,224.57)
  LAY6 w0.38: 279.01,223.88 280.39,225.25 291,225.25 291.59,224.66 292.73,224.66 293.56,225.49 293.56,227.77 294.64,228.85 294.64,235.65 291.71,238.57 291.71,239.9 290.44,241.17 287.7,241.17 287.02,240.48 v1(286.13,240.48)
  LAY6 w0.5: v1(277.49,219.45) 277.49,220.98 279.01,222.5 279.01,223.88 v1(278.32,224.57)
VCORE_VREF: length 38.6
  TOP w0.2: 271.34,229.94 271.34,229.31 270.89,228.85 ; 271.34,229.94 271.52,230.12 272.16,230.12 R2B53.1 273.3,230 275.59,230 275.97,229.61 R2B55.1 276.28,229.81 276.28,229.93 277.56,231.21 EU1B1.26 ; 271.34,229.94 270.94,229.94 270.51,230.38 270.51,233.42 270.76,233.68 ISO2B3.1 ; ISO2B3.1 271.39,233.68 272.16,232.92 R2B45.1 ; ISO2B3.1 R2B38.1 271.88,234.72 272.38,234.72 R2B40.1 ; 270.89,228.85 271.39,228.34 271.39,227.58 271.78,227.2 R2B61.1 R2C2.1 271.9,226.44 271.39,225.93 271.39,223.14 273.43,221.11 R2C18.1 274.7,220.6 276.09,220.6 R2C19.1 ; 270.89,228.85 270.12,228.09 R2C1.1 270,226.44 ISO2C1.1
VCORE_VRHOT_IC: length 127
  TOP w0.1: 168.4,233.3 169.41,233.3 v1(169.67,233.04) ; EU1B1.17 278.14,234.81 278,234.95 v1(277.62,234.95)
  LAY6 w0.125: v1(277.62,234.95) 277.36,234.95 276.22,233.81 276.22,229.81 272.59,226.18 271.26,226.18 266.69,221.61 257.81,221.61 255.78,219.59 187.44,219.59 185.67,221.36 177.29,221.36 170.81,227.84 170.81,231.9 v1(169.67,233.04)
VCORE_VSWH_PH1: length 5.6
  BOTTOM w0.5: R2M17.1 245.49,235.84 L3B4.1
VCORE_VSWH_PH2: length 5.5
  BOTTOM w0.5: R3M36.1 229.36,236.22 L3B3.1
VCORE_VSWH_PH3: length 5.4
  BOTTOM w0.5: R3M37.1 221.74,236.22 L3B2.1
VCORE_VSWH_PH4: length 5.5
  BOTTOM w0.5: R4M24.1 205.61,235.84 L3B1.1
VCORE_VSWH_PH5: length 5.5
  TOP w1: L2B3.1 266.06,238.5 R2B31.1
VCORE_VSWH_PH6: length 5.4
  BOTTOM w0.5: L2B2.1 252.22,235.84 R2M16.1
VCORE_VSWH_PH7: length 5.3
  BOTTOM w0.5: L4B4.1 199.13,235.84 R4M25.1
VCORE_VSWH_PH8: length 4.6
  BOTTOM w0.5: L4B3.1 183.38,236.6 R4M23.1
VCORE_ZCD#_PH1: length 2
  TOP w0.2: 245.21,244.99 245.21,245.8 245.49,246.07 v1(245.49,246.1)
  BOTTOM w0.2: R2M4.2 245.33,246.73 245.33,246.28 245.49,246.12 v1(245.49,246.1)
VCORE_ZCD#_PH2: length 2
  TOP w0.2: v1(231.9,245.87) EU3B2.2
  BOTTOM w0.2: R3M19.2 232.53,246.63 231.9,246 v1(231.9,245.87)
VCORE_ZCD#_PH3: length 1.8
  TOP w0.2: v1(221.99,246.1) 221.99,246 221.84,245.85 221.84,244.99
  BOTTOM w0.2: R3M16.2 221.97,246.73 221.97,246.12 v1(221.99,246.1)
VCORE_ZCD#_PH4: length 2
  TOP w0.2: v1(208.53,245.87) EU3B1.2
  BOTTOM w0.2: v1(208.53,245.87) 208.53,246 209.16,246.63 R3M20.2
VCORE_ZCD#_PH5: length 1.3
  TOP w0.2: 268.45,244.99 268.45,245.4 268.98,245.93 R2B12.2
VCORE_ZCD#_PH6: length 2
  TOP w0.2: v1(255.14,245.87) EU2B2.2
  BOTTOM w0.2: R2M6.2 255.77,246.63 255.14,246 v1(255.14,245.87)
VCORE_ZCD#_PH7: length 2.1
  TOP w0.2: 198.86,244.99 198.86,245.85 v1(199.13,246.12)
  BOTTOM w0.2: R4M12.2 198.98,246.86 198.98,246.28 v1(199.13,246.12)
VCORE_ZCD#_PH8: length 2
  TOP w0.2: v1(185.55,245.87) EU4B3.2
  BOTTOM w0.2: R4M14.2 186.18,246.63 185.55,246 v1(185.55,245.87)
VCT_PINL1: length 8.1
  TOP w0.2: J4A2.19 177.29,277.58 C4A6.2
VCT_PINL10: length 6.2
  TOP w0.1: J4A2.28 194.17,270.27 197.73,266.7 R4A11.2
VHV_TYPEC_FB_BP: length 3.3
  TOP w0.3: 109.98,261.24 R6A78.1 111.5,261.87 112.1,262.47 EU6A2.7
VN_ELVSS_EDP_AMOLED: length 2.3
  TOP w0.1: R1A4.2 J1A4.1
VOL_DOWN: length 7
  TOP w0.1: R9D37.2 16.89,167.38 15.24,167.38 R9D36.2 R9D35.2 12.57,166.88 11.52,167.92 J9D4.3
VOL_DOWN_EC: length 302.6
  TOP w0.1: U8F6.25 22.02,105.08 v1(21.84,104.9) ; J6J2.216 v1(144.09,10.87) ; R9D36.1 16.38,166.88 16.89,166.37 19.3,166.37 19.68,165.99 21.33,165.99 21.43,165.89 23.84,165.89 24.63,165.11 v1(24.63,164.97)
  LAY3 w0.1: v1(21.84,104.9) 22.57,104.17 22.57,100.96 20.06,98.45 20.06,95.73 16.53,92.19 16.53,86.19 14.73,84.39 14.73,83.56 14.37,83.21 14.37,73.95 12.11,71.69 12.11,71.09 10.06,69.03 10.06,51.08 11.99,49.15 11.99,38.6 20.72,29.87 20.72,20.16 22.12,18.76 24.48,18.76 27.01,16.23 57.75,16.23 60.11,13.86 66.81,13.86 69.48,16.53 71.3,16.53 71.89,15.95 82.36,15.95 82.94,16.53 84.69,16.53 85.89,15.33 106.14,15.33 111.44,10.03 113.15,10.03 113.79,9.4 117.62,9.4 117.92,9.7 124.69,9.7 126.17,11.17 129.01,11.17 130.54,12.7 133.73,12.7 134.87,11.56 142.87,11.56 143.56,10.87 v1(144.09,10.87)
  LAY6 w0.125: v1(24.63,164.97) 24.63,158.47 23.32,157.17 23.32,151.99 24.48,150.83 24.48,132.23 25.91,130.81 25.91,124.41 25.01,123.52 25.01,117.6 22.41,115 22.41,105.47 v1(21.84,104.9)
VOL_DOWN_PCH: length 109.7
  TOP w0.1: R9D37.1 17.27,167.89 14.85,167.89 14.47,168.27 v1(14.47,168.3) ; v1(12.06,74.93) 12.29,74.7 18.13,74.7 R9G32.2
  LAY6 w0.125: v1(14.47,168.3) 14.47,158.37 14.33,158.22 14.33,147.08 14.99,146.42 14.99,140.09 14.35,139.44 13.56,139.44 11.16,137.04 11.16,134.33 9.82,133 9.82,120.64 10.78,119.69 10.78,104 11.24,103.53 11.24,97.33 10.27,96.36 10.27,81.44 11.29,80.42 11.29,75.7 v1(12.06,74.93)
VOL_UP: length 4.6
  TOP w0.1: J9D4.2 11.95,168.92 12.95,169.92 R9D32.2 R9D33.2 R9D34.2
VOL_UP_EC: length 285.5
  TOP w0.1: v1(25.4,168.4) 15.11,168.4 R9D33.1 ; v1(27.43,104.52) 27.62,104.71 U8F6.11 ; J6J2.208 v1(143.85,11.89)
  LAY3 w0.1: v1(27.43,104.52) 27.94,104.52 28.19,104.27 28.19,95.88 28.44,95.63 28.44,90.68 28.06,90.3 28.06,89.23 26.85,88.02 26.85,85.36 28.16,84.06 28.16,80.57 28.34,80.39 28.34,73.81 26.47,71.94 26.47,68.23 21.27,63.03 21.27,58.55 22.13,57.69 22.13,51.65 23.05,50.73 23.05,47.75 29.73,41.08 29.73,38.14 31.83,36.03 34.78,36.03 35.93,34.87 45.33,34.87 46.91,33.29 50.82,33.29 52.32,31.79 55.93,31.79 62.6,25.12 63.71,25.12 64.31,24.52 66.74,24.52 66.91,24.69 75.92,24.69 76.46,25.22 81.04,25.22 82.44,26.62 84.28,26.62 85.65,25.25 89.06,25.25 89.8,24.51 98,24.51 98.12,24.63 102,24.63 104.57,22.06 111.05,22.06 112.35,20.76 113.72,20.76 114.42,20.06 117.22,20.06 118.23,19.05 121.03,19.05 122.04,20.06 124.84,20.06 125.62,19.28 127.35,19.28 128.14,20.06 134.36,20.06 135.38,19.05 136.77,19.05 137.97,17.86 137.97,16.69 137.28,16 137.28,15.24 138.84,13.68 142.52,13.68 143.85,12.36 v1(143.85,11.89)
  LAY6 w0.125: v1(25.4,168.4) 25.63,168.17 25.63,158.15 25.24,157.76 25.24,135.28 26.16,134.36 26.16,131.63 26.66,131.12 26.66,124.1 26.28,123.72 26.28,113.92 26.65,113.55 26.65,112.89 26.79,112.75 26.79,110.21 28.19,108.82 28.19,105.28 v1(27.43,104.52)
VOL_UP_PCH: length 138.4
  TOP w0.089: 102.45,128.62 102.45,130.89 102.94,131.38 102.94,134.96 102.64,135.26 U6E1.AD48
  TOP w0.1: 102.45,128.62 102.45,126.82 102.38,126.75 102.38,121.39 102.03,121.03 v1(101.85,121.03) ; v1(18.03,169.29) 17.9,169.42 15.87,169.42 R9D34.1
  LAY6 w0.125: v1(59.43,156.46) 59.7,156.19 59.7,152.85 63.37,149.18 63.37,146.56 63.84,146.1 63.84,145.07 66.8,142.11 66.8,139.95 68.45,138.3 68.45,137.16 69.72,135.88 70.89,135.88 72.89,133.88 72.89,131.82 76.46,128.25 76.46,127.26 79.61,124.12 79.61,123.58 85.34,117.84 94.95,117.84 98.14,121.03 v1(101.85,121.03)
  BOTTOM w0.1: v1(59.43,156.46) 59.41,156.46 54.84,161.03 47.48,161.03 47.11,160.66 44.45,160.66 44.19,160.4 34.91,160.4 34.3,161 32.74,161 32.43,160.69 27.72,160.69 26.92,159.89 26.41,159.89 25.14,161.16 19.93,161.16 19.68,160.91 18.89,160.91 18.16,161.64 18.16,169.16 v1(18.03,169.29)
VPP_EN: length 171.8
  TOP w0.1: v1(251.33,76.71) 251.71,77.09 252.6,77.09 R2G30.2
  TOP w0.2: R5F20.1 v1(140.58,102.61)
  LAY5 w0.125: v1(251.33,76.71) 250.31,77.72 225.67,77.72 225.04,77.09 218.38,77.09 216.24,79.23 206.86,79.23 203.83,76.2 195.75,76.2 194.19,77.76 181.78,77.76 160.78,56.77 151.89,56.77 v1(150.11,54.99)
  LAY6 w0.125: v1(140.58,102.61) 140.58,97.41 137.41,94.23 137.41,85.07 150.82,71.66 150.82,55.7 v1(150.11,54.99)
VPP_EN_L: length 2.3
  TOP w0.1: U2G2.4 250.66,76.23 250.82,76.07 251.71,76.07 R2G30.1
VPP_PG_PS: length 188.3
  TOP w0.1: U2G2.2 249.86,75.24 R2G38.2 250.06,75.18 250.31,74.93 250.31,73.4 v1(250.95,72.77)
  TOP w0.2: R5F10.2 v1(140.08,108.71) ; v1(142.49,107.82) 142.35,107.68 EU5F1.6
  LAY5 w0.125: v1(150.87,54.99) 151.51,55.62 163.95,55.62 168.32,59.99 168.32,63.95 180.06,75.69 182.11,75.69 183.55,77.12 194.47,77.12 195.65,75.95 203.93,75.95 206.96,78.98 216.13,78.98 218.28,76.83 225.19,76.83 225.83,77.47 249.93,77.47 250.44,76.96 250.44,73.28 v1(250.95,72.77)
  LAY6 w0.125: v1(140.08,108.71) 140.97,107.82 v1(142.49,107.82) 140.97,106.3 140.97,103.88 141.35,103.5 141.35,97.81 137.66,94.13 137.66,85.17 151.07,71.76 151.07,55.19 v1(150.87,54.99)
VPP_VR_EN: length 1.7
  TOP w0.2: R5F20.2 EU5F1.1
VPP_VR_FB: length 2.6
  TOP w0.3: EU5F1.4 142.85,103.53 R5F18.1 143.75,103.5 R5F21.2
VR_ENABLE: length 273
  TOP w0.1: v1(158.87,201.8) 158.11,201.8 R5C53.1 ; R5B27.1 157.19,234.79 156.97,234.57 v1(156.84,234.57) ; R5C53.1 U5C2.3 ; R5C53.1 156.08,199.77 R5C63.2 C5C37.1 R5C62.2 R5C61.2 R5C57.2 ; R8D50.1 31.11,177.29 TP8D1.1 31.36,177.67 v1(31.24,177.8) ; Q8C9.6 v1(37.33,202.69) ; v1(36.32,187.81) 36.32,187.83 36.57,188.09 R8D12.2
  LAY5 w0.125: v1(37.33,248.41) 37.47,248.27 46.7,248.27 47.32,248.89 53.18,248.89 53.53,249.25 68.02,249.25 71.27,245.99 71.65,245.99 74.06,243.59 77.66,243.59 79.34,241.91 83.59,241.91 84.29,241.2 92.23,241.2 92.39,241.04 93.41,241.04 94.21,241.84 106.95,241.84 109.73,239.07 116.79,239.07 118.38,240.66 126.49,240.66 127.69,241.86 131.5,241.86 133.4,243.77 135.36,243.77 140.43,248.84 146.51,248.84 149.1,246.24 149.1,245.76 149.7,245.16 153.61,245.16 154.05,244.73 155.32,244.73 156.46,243.58 156.46,242.95 156.59,242.82 156.59,234.82 v1(156.84,234.57)
  LAY6 w0.125: v1(31.24,177.8) 31.24,179.15 36.57,184.48 36.57,187.58 36.34,187.81 v1(36.32,187.81) 36.32,187.83 36.57,188.09 36.57,192.66 37.72,193.8 37.72,197.59 37.92,197.79 37.92,198.94 37.33,199.53 v1(37.33,202.69) 37.33,205.94 35.56,207.71 35.56,208.81 34.06,210.31 32.78,210.31 32.31,210.79 32.31,211.74 32.65,212.08 32.65,216.59 31.49,217.75 31.49,222.94 30.61,223.83 30.61,227.83 29.59,228.85 29.59,229.24 31.24,230.89 31.24,235.3 32.51,236.57 32.51,237.41 32,237.91 32,241.76 35.82,245.58 35.82,246.29 37.33,247.8 v1(37.33,248.41) ; v1(158.87,201.8) 159.45,202.38 159.45,205.14 158.11,206.48 158.11,207.15 160.15,209.2 160.15,210.44 161.03,211.32 161.03,211.96 162.05,212.98 162.05,214.22 157.51,218.77 157.51,230.32 156.58,231.24 156.58,234.44 156.71,234.57 v1(156.84,234.57)
VR_ENABLE_C10: length 41.7
  TOP w0.1: v1(156.08,234.57) 156.08,234.98 R5B91.1 ; v1(158.2,202.88) 157.76,203.33 R5C46.2 156.93,203.33 156.52,202.92 156.52,202.24 155.76,201.49 U5C2.4
  LAY6 w0.125: v1(158.2,202.88) 157.57,203.51 157.57,207.3 159.67,209.4 159.67,210.64 160.52,211.49 160.52,213.74 160.9,214.12 160.9,214.69 156.97,218.63 156.97,225.8 154.55,228.22 154.55,230.63 156.08,232.15 v1(156.08,234.57)
VR_ENABLE_DIODE: length 1.4
  TOP w0.1: CR8D2.1 R8D50.2
VR_ENABLE_IC_R: length 177.9
  TOP w0.1: v1(156.97,226.95) 156.97,226.82 158.08,225.71 166.64,225.71 167.48,226.55 167.48,229.87 168.02,230.41 v1(168.02,231.65) ; v1(158.87,203.07) 158.87,202.82 158.49,202.44 R5C46.1 157.09,201.67 R5C53.2
  TOP w0.2: EU1B1.21 v1(276.98,233.21) 276.98,233.3 275.64,234.64 275.64,235.79 C2B21.1
  LAY5 w0.125: v1(187.96,218.18) 187.96,218.95 185.29,221.61 184.71,221.61 179.82,226.51 179.82,228.48 179.45,228.85 174.75,228.85 173.6,230 169.67,230 v1(168.02,231.65)
  LAY6 w0.125: v1(276.98,233.21) 276.98,230.21 272.7,225.93 271.36,225.93 266.79,221.36 257.91,221.36 255.89,219.34 189.11,219.34 v1(187.96,218.18) ; v1(158.87,203.07) 159.13,203.33 159.13,205.1 157.86,206.37 157.86,207.26 159.9,209.3 159.9,210.54 160.78,211.42 160.78,212.06 161.8,213.08 161.8,214.12 157.25,218.66 157.25,226.66 v1(156.97,226.95)
VR_ENABLE_PU: length 1.2
  TOP w0.1: R2G23.1 248.08,77.67 U2G2.11
VR_READY: length 170.5
  TOP w0.1: v1(7.23,188.34) 7.36,188.21 9.27,188.21 11.04,189.99 21.46,189.99 22.02,190.55 27.91,190.55 28.19,190.27 28.81,190.27 29.27,190.73 29.27,193.14 31.29,195.16 35.52,195.16 36.19,195.83 v1(36.7,195.83) 36.95,196.09 R8C80.1 ; R8C44.2 v1(29.21,207.39) 29.87,208.05 31.84,208.05 33.03,209.25 34.97,209.25 R8C37.1 R8C42.1 R8C46.1 ; R9F37.1 14.09,97.41 TP9F4.1 11.55,97.41 10.66,96.52 10.66,95.88 9.14,94.36 v1(4.82,94.36)
  LAY6 w0.125: v1(4.82,94.36) 5.08,94.36 5.84,95.12 5.84,99.93 5.97,100.06 5.97,106.42 4.16,108.24 4.16,119.08 4.7,119.61 4.7,141.22 7.23,143.76 7.23,153.67 6.73,154.18 6.73,161.43 7.62,162.32 7.62,187.96 v1(7.23,188.34)
  BOTTOM w0.1: v1(36.7,195.83) 35.56,195.83 32.76,198.63 32.76,202.34 31.24,203.86 R8N2.2 30.86,205.74 v1(29.21,207.39)
VR_READY_C10: length 1.5
  BOTTOM w0.1: R8N2.1 31.24,208 31.32,208.09
VR_READY_EC: length 253.4
  TOP w0.1: U8F6.48 16.9,98.69 16.51,98.3 v1(16.51,97.92) 16.38,97.79 R9F37.2 ; v1(128.65,24.13) 128.65,23.49 R6J5.1 ; J6J2.24 113.16,10.41 112.64,10.41 112.06,9.83 112.06,6.91 110.74,5.59 110.74,4.32 110.49,4.06 v1(107.95,4.06)
  LAY3 w0.1: J8J13.2 26.54,8.09 26.54,6.48 27.9,5.12 58.43,5.12 62.2,1.35 89.18,1.35 91.26,3.43 102.93,3.43 103.31,3.81 107.69,3.81 v1(107.95,4.06)
  LAY6 w0.125: v1(107.95,25.27) 107.95,23.75 105.91,21.72 105.15,21.72 103.37,19.94 103.37,8.64 104.14,7.87 104.14,4.95 105.15,3.94 107.82,3.94 v1(107.95,4.06) ; J8J13.2 20.22,9.11 16.63,12.7 16.63,22.1 14.22,24.51 14.22,27.33 12.95,28.6 12.95,33.3 13.26,33.61 13.26,60.78 14.22,61.74 14.22,65.28 14.96,66.03 14.96,72.66 16.13,73.83 16.13,81.23 16.66,81.76 16.66,84.04 15.87,84.83 15.87,85.22 16.52,85.86 16.52,89.05 16,89.58 16,97.41 v1(16.51,97.92)
  BOTTOM w0.1: v1(107.95,25.27) 108.58,24.64 111.25,24.64 112.52,25.91 115.95,25.91 118.94,22.91 127.43,22.91 v1(128.65,24.13)
VR_READY_IMVP: length 438
  TOP w0.1: R8C41.2 30.22,206.75 R8C44.1 R8C45.1 31.62,206.63 v1(32,207.01) ; 161.16,236.85 161.26,236.76 164.74,236.76 v1(165.1,237.11)
  TOP w0.2: R2C6.1 v1(280.16,224.15)
  LAY5 w0.125: v1(294.82,226.58) 294.85,226.61 294.85,240.12 292.74,242.23 292.74,246.91 291.97,247.68 291.97,250.54 292.98,251.56 292.98,256.39 292.75,256.63 292.75,263.78 289.79,266.74 282.96,266.74 282.15,265.93 280.22,265.93 279.57,265.28 276.98,265.28 276.83,265.43 275.46,265.43 274.57,264.54 273.77,264.54 272.52,265.8 269.86,265.8 268.6,264.54 265.05,264.54 263.78,263.27 262.48,263.27 260.44,261.23 254.17,261.23 252.04,259.1 246.63,259.1 246.23,258.69 236.85,258.69 236.62,258.47 233.72,258.47 231.82,256.56 229.97,256.56 228.97,257.56 226.95,257.56 225.56,256.17 224.9,256.17 223.65,257.42 216.09,257.42 215.44,258.07 208.84,258.07 208.19,257.42 199.89,257.42 197.95,255.48 195.84,255.48 193.55,253.2 193.55,252.86 193.25,252.55 v1(193.01,252.55) 191.44,254.12 182.53,254.12 180.36,251.95 174.32,251.95 173.81,252.46 147.91,252.46 147.29,251.85 137.9,251.85 134.9,248.85 132.08,248.85 130.86,247.63 130.86,246.66 129.83,245.62 126.82,245.62 125.61,244.41 116.7,244.41 116.27,244.83 111.68,244.83 111.47,244.62 109.38,244.62 108.08,245.92 95.32,245.92 94.36,244.96 92.05,244.96 91.09,245.92 87.22,245.92 84.75,248.39 83.09,248.39 82.43,249.05 78.97,249.05 77.96,250.06 72.81,250.06 70.86,252 70.01,252 69.66,252.35 52.24,252.35 51.89,252 50.99,252 50.39,252.6 49.17,252.6 48.32,251.75 41.78,251.75 41.1,251.07 36.19,251.07 v1(35.05,249.93)
  LAY6 w0.125: v1(165.1,237.11) 165.73,237.74 167.74,237.74 167.95,237.95 170.89,237.95 171.57,238.63 174.69,238.63 175.81,239.75 175.81,245.35 172.72,248.43 172.72,249.56 173.03,249.86 175.33,249.86 176.14,249.05 183.93,249.05 185.64,250.77 189.39,250.77 191.35,252.73 192.83,252.73 v1(193.01,252.55) ; v1(32,207.01) 32,207.77 30.17,209.6 30.17,211.66 30.42,211.9 30.42,216.34 29.21,217.55 29.21,218.44 29.99,219.23 29.99,221.59 29.33,222.25 29.33,225.42 28.49,226.27 28.49,230.43 28.56,230.5 28.56,233.87 29.29,234.59 29.29,240.18 30.86,241.76 30.86,243.53 32.38,245.05 32.38,246.25 34.16,248.03 34.16,249.05 v1(35.05,249.93) ; v1(294.82,226.58) 294.82,225.99 292.73,223.9 285.24,223.9 284.32,224.81 280.56,224.81 280.16,224.41 v1(280.16,224.15)
  BOTTOM w0.1: U8N1.3 v1(32,207.01)
VR_READY_PWRGD_PS: length 8.7
  TOP w0.1: J6J2.133 v1(131.39,15.7) ; R6J5.2 v1(128.52,21.72)
  LAY8 w0.1: v1(128.52,21.72) 129.66,20.57 129.66,17.43 v1(131.39,15.7)
VR_SVID_ALERT_N: length 6.9
  TOP w0.1: EU1B1.19 277.41,234.01 276.6,234.82 276.6,237.23 275.46,238.38 R2B27.2
VR_SVID_ALERT_N_R: length 369.7
  TOP w0.1: Q5M4.3 163.04,235.62 R5B85.2 v1(163.44,236.3) ; v1(277.01,244.7) 276.91,244.6 275.71,244.6 274.95,243.84 274.95,241.17 275.46,240.66 R2B27.1 ; R1G6.2 296.79,71.06 297.75,72.01 J1G4.3
  LAY6 w0.125: v1(277.01,244.7) 277.01,244.73 279.29,247.01 283.9,247.01 287.85,243.06 290.99,243.06 296.74,237.31 296.74,219.21 294.86,217.34 294.86,216.33 293.85,215.31 291.71,215.31 288.42,212.02 288.42,199.58 292.21,195.79 292.21,194.23 293.75,192.68 293.75,180.06 295.01,178.81 295.01,174.57 293.24,172.8 293.24,164.8 293.75,164.29 293.75,158.37 293.96,158.16 293.96,138.38 293.11,137.54 293.11,135.63 293.39,135.35 293.39,130.58 293.12,130.31 293.12,124.89 300.77,117.23 300.77,81.83 297.71,78.76 297.71,73 J1G4.3
  LAY8 w0.1: v1(163.44,236.3) 162.99,235.84 162.43,235.84 161.94,236.32 158.83,236.32 156.55,238.6 156.55,241.34 157.06,241.84 158.76,241.84 159.41,242.5 159.41,246.45 163.88,250.92 175.44,250.92 177.22,252.69 180.39,252.69 181.92,254.22 188.9,254.22 189.64,254.96 189.64,255.72 190.55,256.63 193.74,256.63 194.12,256.25 196.78,256.25 197.92,257.39 207.57,257.39 210.11,259.93 213.55,259.93 215.96,257.52 223.45,257.52 225.35,259.43 227.9,259.43 228.82,258.51 228.82,256.23 230.44,254.6 239.71,254.6 240.73,253.58 273.5,253.58 274.79,252.29 274.79,246.92 v1(277.01,244.7)
