# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCCSA_SET1: length 6.2
  TOP w0.2: R5B81.2 R5B84.1 151.9,234.82 152.66,235.58 152.66,236.93 153.08,237.35 153.08,238 153.91,238.83 EU5B2.28
VCCSA_SET2: length 11.4
  TOP w0.2: v1(152.14,236.77) 151.93,236.77 151.51,236.35 R5B79.1 R5B78.2 151.51,237.11 151.85,237.45 R5B77.1 152.48,237.45 152.78,237.74 152.78,238.12 153.28,238.63 153.28,239.01 153.5,239.23 EU5B2.27
  LAY5 w0.2: v1(152.14,236.77) 151.97,236.77 149.96,238.78 148.74,238.78 v1(148.44,238.49)
  BOTTOM w0.2: v1(148.44,238.49) 148.85,238.49 149.19,238.15 Q5M2.2
VCCSA_SET3: length 4.6
  TOP w0.2: R5B75.2 150.49,239.2 151.19,239.9 R5B74.1 151.38,240.21 151.58,240.41 152.66,240.41 153.44,239.63 EU5B2.26
VCCSA_SNB: length 1.8
  BOTTOM w0.38: C5M2.1 R5M2.2
VCCSA_SVID_ALERT_N: length 9.3
  TOP w0.1: R5B85.1 163.4,234.69 162.21,234.69 Q5M4.2 161.64,234.69 160.52,234.69 159.76,235.46 159.76,235.71 158.08,237.39 156.69,237.39 156.22,237.85 EU5B2.5
VCCSA_SVID_CLK: length 4.7
  TOP w0.1: R5B83.1 159.7,236.09 158.17,237.62 156.84,237.62 156.62,237.83 EU5B2.6
VCCSA_SVID_DATA: length 10.6
  TOP w0.1: EU5B2.4 155.82,237.87 156.59,237.11 158.04,237.11 159.51,235.64 159.51,235.33 160.53,234.3 163.81,234.3 164.21,234.69 R5B87.1
VCCSA_TG: length 2.9
  TOP w0.5: R5B90.1 162.05,239.77 163.57,241.3 EU5B1.3
VCCSA_TGR: length 7.8
  TOP w0.2: EU5B2.10 v1(159,239.63)
  TOP w0.5: v1(163.06,239.27) 163.7,239.9 EU5B1.4
  LAY6 w0.5: v1(159,239.63) 159.36,239.27 v1(163.06,239.27)
  BOTTOM w0.5: v1(159,239.63) 159.87,238.76 C5M3.2
VCCSA_TSEN: length 16.1
  TOP w0.2: v1(156.94,243.33) 157.2,243.58 R5B67.2 157.6,243.2 157.09,242.7 156.97,242.7 156.62,242.35 EU5B2.16 ; v1(163.44,238.26) 163.58,238.26 164.09,238.77 C5B44.2
  LAY5 w0.2: v1(156.94,243.33) 157.12,243.51 163.18,243.51 163.98,242.71 163.98,238.66 163.58,238.26 v1(163.44,238.26)
VCCSA_TSEN_SET: length 16
  TOP w0.2: v1(164.46,238.22) 164.49,238.25 164.59,238.25 164.97,238.63 C5B44.1 ; R5B57.2 R5B62.1 157.6,245.24 R5B67.1 157.32,244.47 v1(156.94,244.09)
  LAY5 w0.2: v1(164.46,238.22) 164.46,238.25 164.31,238.4 164.31,242.85 163.32,243.84 157.2,243.84 v1(156.94,244.09)
VCCSA_UG: length 3
  TOP w0.2: EU5B2.9 158.49,239.23 158.71,239.01
  TOP w0.508: 158.71,239.01 158.77,238.95 159.44,238.95 160.02,239.52 R5B90.2
VCCSA_VIN: length 1.3
  TOP w0.38: R4B30.1 165.1,248.92 R5B54.1
VCCSA_VIN_IC: length 6.4
  TOP w0.2: 158.36,241.55 158.36,241.04 158.15,240.83 EU5B2.13
  TOP w0.508: R5B55.1 C5B40.1 159.63,244.09 159.13,243.58 159.13,242.82 158.36,242.06 158.36,241.55
VCCSA_VOUT: length 1.1
  TOP w0.508: R4B41.1 178.18,246
VCCSA_VREF: length 14
  TOP w0.2: R5B76.1 151.92,239.14 v1(152.04,239.01) ; EU5B2.17 156.22,243.01 155.99,243.24 v1(155.93,243.24) 155.86,243.31 155.75,243.31 155.32,243.74 R5B66.1 R5B61.1 154.55,244.73 R5B65.2
  LAY6 w0.2: v1(155.93,243.24) 155.93,242.89 v1(152.04,239.01)
  BOTTOM w0.2: v1(152.04,239.01) 152.04,238.53 R5M8.1 R5M11.1 R5M12.1
VCCSA_VRHOT: length 5
  TOP w0.1: 155.42,238.18 155.42,237.89 156.59,236.73 158.11,236.73 158.72,236.12 R5B82.1
VCCSA_VSEN: length 11.7
  TOP w0.2: v1(149.58,243.26) 149.91,243.26 C5B38.1 150.24,243.97 150.11,244.09 R5B59.1 ; EU5B2.25 153.5,240.03 152.62,240.92 C5B42.1 151.26,240.92 151.13,241.05 150.37,241.05 v1(149.98,240.66) 149.6,240.66 149.47,240.79 R5B71.1 ; C5B36.1 R5B59.1 ; R5B59.1 R5B58.2
  LAY6 w0.2: v1(149.58,243.26) 149.98,242.85 v1(149.98,240.66)
VCCSA_VSW:
  vias: v1(170.56,241.81) v1(171.32,241.81)
VCCSFR_OC_FB: length 4
  TOP w0.25: EU5C2.4 161.92,208.02 R5C34.2 161.29,207.52 R5C29.1
VCCSFR_OC_PVIN: length 1.9
  TOP w0.38: 164.21,215.26 164.08,215.39 R5C14.2 163.37,214.45 163.44,214.37
  vias: v1(163.32,210.95)
VCCSFR_OC_SR_CAP: length 1.6
  TOP w0.2: C4C8.1 177.52,210.3 U4C1.7
VCCST_PWRGD: length 393.8
  TOP w0.1: v1(134.59,218.06) 121.07,218.06 117.64,214.63 101.48,214.63 94.25,207.39 v1(90.42,207.39) ; R8C47.2 44.64,205.8 Q8C5.3 48,206.75 48.87,207.62 51.41,207.62 52.23,206.8 60.52,206.8 61.34,205.99 64.51,205.99 65.61,204.9 65.61,202.53 65.97,202.16 71.77,202.16 73.53,200.4 75.81,200.4 77.97,198.25 82.67,198.25 84.7,196.21 84.7,194.56 87.75,191.51 v1(90.04,191.51) ; v1(171.32,231.65) 171.45,231.52 171.45,231.25 172.98,229.72 172.98,226.89 174.24,225.63 174.24,219.07 R4C10.1 175.76,217.3 R4C11.2 ; R1C46.1 298.65,209.93 v1(298.57,210.01)
  LAY5 w0.125: v1(300.35,239.65) 301.26,238.74 301.26,223.78 300.91,223.43 300.91,219 298.06,216.15 298.06,210.51 v1(298.57,210.01)
  LAY6 w0.125: v1(300.35,239.65) 300.35,239.77 298.15,241.98 298.15,246.4 297.71,246.84 293.16,246.84 290.95,249.05 285.1,249.05 283.32,250.82 283.32,252.47 281.68,254.12 273.62,254.12 273.42,254.32 234.22,254.32 231.49,251.59 224.15,251.59 223.77,251.97 217.18,251.97 216.15,250.93 208.55,250.93 207.51,251.97 204.33,251.97 203.39,251.03 199.45,251.03 198.79,250.37 191.8,250.37 189.33,247.9 185.92,247.9 185.02,247 180.16,247 178.92,245.77 178.92,233.66 178.43,233.17 173.86,233.17 172.33,231.65 v1(171.32,231.65)
  BOTTOM w0.1: v1(171.32,231.65) 171.06,231.65 170.43,232.28 170.43,232.94 166.65,236.72 166.11,236.72 165.09,237.74 163.32,237.74 162.87,237.3 158.28,237.3 156.5,239.08 156.5,239.86 154.94,241.43 154.07,241.43 153.02,242.48 147.41,242.48 147.06,242.83 145.41,242.83 144.39,243.85 140.59,243.85 139.58,242.83 138.42,242.83 136.12,240.54 136.12,235.63 134.89,234.4 134.4,234.4 134.11,234.11 134.11,224.37 134.59,223.88 v1(134.59,218.06) ; v1(90.04,191.51) 90.17,191.64 90.17,195.71 91.42,196.96 91.42,198.51 90.29,199.64 90.29,207.26 v1(90.42,207.39)
VCCST_PWRGD_CPU: length 50.8
  TOP w0.089: 214.12,203.08 214.12,200.61 214.89,199.83 214.89,199.48 214.79,199.38 214.79,198.42 J3D1.B13
  TOP w0.1: 214.12,203.08 214.12,203.86 207.67,210.31 195.04,210.31 193.55,211.79 182.98,211.79 178.75,216.03 176.53,216.03 176.14,215.64 C4C5.1 175.76,216.41 R4C10.2
VCCST_SFR_EN: length 248.8
  TOP w0.1: v1(182.75,199.13) 182.75,200.15 182.49,200.4 182.49,201.04 182.37,201.17 182.37,202.06 182.11,202.31 U4C2.9 ; 66.42,77.47 66.42,76.71 67.94,75.18 71.07,75.18 71.45,74.8 71.45,73.07 71.55,72.97 71.55,66.55 71.62,66.47 71.62,65.78 72.19,65.21 72.19,61.91 72.64,61.47 74.54,61.47 v1(76.07,62.99)
  LAY5 w0.125: v1(151.76,83.31) 149.85,83.31 148.69,82.15 138.28,82.15 137.66,81.53 134.74,81.53 133.28,82.99 123.06,82.99 122.87,82.8 101.7,82.8 96.05,77.15 94.29,77.15 93.47,76.33 93.47,74.82 83.62,64.97 78.04,64.97 v1(76.07,62.99)
  LAY6 w0.125: v1(182.75,199.13) 180.46,196.85 180.46,195.2 179.95,194.69 178.68,194.69 178.45,194.46 178.45,193.27 177.49,192.31 177.49,183.34 173.86,179.7 173.1,179.7 172.59,179.2 172.59,172.46 167.89,167.77 167.89,163.21 163.25,158.57 163.25,157.54 161.54,155.83 161.54,153.8 161.12,153.38 159.83,153.38 158.98,152.53 158.98,152.1 149.33,142.45 149.33,136.36 150.19,135.5 150.19,133.86 150.93,133.13 150.93,131.97 149.2,130.24 149.2,98.83 149.73,98.3 149.73,85.34 v1(151.76,83.31)
VCCST_SFR_EN_R: length 1.1
  TOP w0.17: R7G22.1 67.31,78.12 67.14,78.29 U7G5.4
VCCSTG_EN: length 363.7
  TOP w0.1: v1(189.86,191.26) 189.64,191.48 189.64,200.63 187.96,202.31 U4C3.9 ; v1(150.74,191.46) 150.82,191.39 R5D3.2 151.89,184.12 155.62,180.39 156.17,180.39 156.97,179.58 168.64,179.58 170.81,177.42 v1(173.54,177.42) ; R8D74.2 v1(46.48,172.08)
  LAY5 w0.125: v1(150.74,191.46) 151.51,190.7 151.51,180.06 150.49,179.05 150.49,166.17 144.52,160.19 141.65,160.19 137.84,164 137.84,192.78 137.23,193.4 137.23,205.02 137.56,205.36 137.56,210.15 129.19,218.52 121.03,218.52 116.2,213.7 99.63,213.7 98.3,215.03 98.3,219.12 97.2,220.22 88.37,220.22 82.67,225.92 82.67,229.49 81.02,231.14 72.84,231.14 68.02,235.96 67.23,235.96 64.81,238.38 64.23,238.38 62.96,239.65 61.57,239.65 61.08,240.13 61.08,241.28 60.55,241.8 59.79,241.8 58.7,242.89 57.56,242.89 55.6,244.85 54.48,244.85 52.26,242.63 50.73,242.63 v1(50.16,242.06)
  LAY6 w0.125: v1(189.86,191.26) 189.64,191.04 189.64,185.51 189.64,185.51 189.64,185.33 188.72,184.4 185.87,184.4 183.08,181.61 181.48,181.61 179.45,179.58 179.45,178.31 178.12,176.98 173.98,176.98 v1(173.54,177.42) ; v1(46.48,172.08) 47.24,172.85 47.24,184.07 45.59,185.72 45.59,186.18 45.46,186.31 44.7,186.31 44.33,186.68 44.33,192.4 43.43,193.29 43.43,196.98 43.56,197.11 43.56,201.26 43.31,201.51 43.31,204.21 42.92,204.6 42.92,205.61 43.42,206.12 43.42,209.12 42.61,209.93 39.54,209.93 35.94,213.53 35.94,235.77 36.64,236.46 36.64,238.16 37.36,238.88 38.5,238.88 39.39,239.77 42.69,239.77 43.58,240.66 48.76,240.66 v1(50.16,242.06)
VCCSTG_EN_R: length 306.1
  TOP w0.1: v1(151.15,193.57) 151.15,193.55 151.66,193.04 U5D1.1 ; R8D96.1 48.79,174.85 48.79,173.04 47.83,172.08 v1(47.37,172.08) R8D74.1 48.26,171.32 48.64,170.94 48.64,170.18 48,169.54 48,167.38 47.68,167.06 U8D12.4
  LAY5 w0.125: v1(151.15,193.57) 151.15,193.52 151.76,192.91 151.76,179.96 150.74,178.94 150.74,166.07 144.62,159.94 141.55,159.94 137.59,163.9 137.59,172.03 137.28,172.35 137.28,179.58 136.27,180.59 136.27,186.84 137.16,187.73 137.16,192.66 136.98,192.84 136.98,205.11 135.63,206.46 135.63,211.73 129.09,218.27 121.13,218.27 116.3,213.45 99.52,213.45 98.05,214.92 98.05,219.01 97.09,219.97 88.26,219.97 81.65,226.58 81.65,229.97 81.13,230.5 78.12,230.5 77.61,229.99 73.63,229.99 67.92,235.71 65.23,235.71 63.24,237.69 63.24,239.01 62.86,239.39 61.46,239.39 60.83,240.03 60.83,241.17 60.45,241.55 59.69,241.55 58.59,242.64 57.45,242.64 55.49,244.6 54.73,244.6 52.44,242.31 51.43,242.31 v1(51.05,241.93)
  LAY6 w0.125: v1(51.05,241.93) 49.53,240.41 43.68,240.41 42.79,239.52 39.49,239.52 38.6,238.63 37.46,238.63 36.89,238.06 36.89,236.36 36.2,235.67 36.2,213.63 39.64,210.18 42.72,210.18 43.93,208.97 43.93,205.05 43.56,204.68 43.56,201.62 43.81,201.37 43.81,198.78 44.58,198.01 44.58,188.61 45.21,187.98 45.21,187.32 45.97,186.56 45.97,185.7 47.49,184.17 47.49,172.21 v1(47.37,172.08)
VDDQ_BLEED: length 1.6
  TOP w0.1: R2G17.2 250.44,81.53 Q2G1.1
VDDQ_BLEED_L: length 1.5
  TOP w0.1: R2G17.1 250.26,79.57 U2G2.8
VDDQ_CTRL: length 2.8
  TOP w0.305: U2G3.8 263.52,72.77 262.89,73.4 R2G37.1
VDDQ_EN: length 18.9
  TOP w0.1: R2G16.2 249.3,81.28 v1(249.17,81.41) ; R2G29.1 263.77,76.33 263.9,76.2 v1(263.9,76.1)
  BOTTOM w0.1: v1(263.9,76.1) 262.91,77.09 260.35,77.09 259.94,76.68 256.44,76.68 252.85,80.26 250.31,80.26 v1(249.17,81.41)
VDDQ_EN_L: length 1.7
  TOP w0.1: U2G2.9 249.86,79.19 R2G16.1
VDDQ_LGATE: length 1.8
  TOP w0.203: 265.43,81.82 EU2G1.15
  TOP w0.508: 265.43,81.82 265.71,81.82 R2G11.1
VDDQ_LGATE_R: length 12.9
  TOP w0.508: U2G1.8 v1(268.47,93.34) ; R2G11.2 v1(268.73,82.42)
  BOTTOM w0.508: v1(268.47,93.34) 268.73,93.09 v1(268.73,82.42)
VDDQ_PWRGD: length 8.6
  TOP w0.1: R8C64.2 44.9,201.04 45.27,201.41 Q8C11.2 ; R8C64.2 45.08,200.53 45.08,200.4 45.33,200.15 45.97,200.15 47.37,198.75 R8C73.1 48.26,198.25 v1(48.38,198.37) R8C72.1 ; R8C64.2 R8C56.1
VDDQ_PWRGD_ISOLATE: length 322.4
  TOP w0.1: v1(153.79,197.1) 153.92,197.23 R5C62.1 ; R8C61.2 49.42,200.56 48.89,200.02 v1(48.76,200.02) 48,200.02 47.75,200.28 47.11,200.28 46.63,200.76 Q8C11.3 ; R5E7.1 153.79,155.07 153.72,155.07 153.37,154.72 152.81,154.72 151.89,153.8 151.89,153.41 152.14,153.16 152.9,153.16 153.15,152.91 154.94,152.91 R5E11.1 156.21,153.16 156.21,152.27 154.78,150.85 150.46,150.85 150.21,151.1 150.21,152.66 v1(149.5,153.37)
  LAY5 w0.125: v1(153.79,197.1) 153.79,196.34 152.78,195.32 152.78,193.29 153.05,193.01 153.05,178.79 151,176.73 151,165.96 144.72,159.69 141.45,159.69 137.33,163.8 137.33,171.93 137.03,172.24 137.03,179.48 135.88,180.62 135.88,186.81 136.9,187.83 136.9,192.38 136.43,192.85 136.43,205.3 135.38,206.35 135.38,211.62 128.98,218.02 121.23,218.02 116.41,213.19 99.42,213.19 97.63,214.98 97.63,219.07 96.99,219.72 88.16,219.72 81.4,226.47 81.4,229.87 81.02,230.25 78.23,230.25 77.72,229.74 73.53,229.74 67.81,235.46 65.12,235.46 62.84,237.74 59.66,237.74 59.05,238.35 59.05,241.81 58.47,242.39 56.81,242.39 v1(55.11,244.09)
  LAY6 w0.125: v1(149.5,153.37) 149.47,153.39 149.47,157.17 149.27,157.37 149.27,161.77 151.47,163.97 151.47,166.73 151.76,167.02 151.76,177.29 152.65,178.18 152.65,179.45 151.76,180.34 151.76,186.73 152.9,187.88 152.9,193.14 152.62,193.42 152.62,196.18 153.54,197.1 v1(153.79,197.1)
  BOTTOM w0.1: v1(55.11,244.09) 54.8,243.78 54.8,233.41 55.22,232.99 55.22,207.95 49.55,202.28 49.55,200.66 48.92,200.02 v1(48.76,200.02)
VDDQ_UGATE: length 5.8
  TOP w0.203: EU2G1.17 263.66,82.95 v1(264.16,83.44)
  TOP w0.508: v1(267.2,84.07) 267.46,83.82 R2G7.1
  BOTTOM w0.508: v1(264.16,83.44) 266.57,83.44 v1(267.2,84.07)
VDDQ_UGATE_R: length 1.6
  TOP w0.508: U2G1.1 R2G7.2
VDDQ_VR_CS: length 1.6
  TOP w0.203: EU2G1.13 266.19,81.02 R2G15.2
VDDQ_VR_EN_S3: length 1.8
  TOP w0.1: R2G28.2 262.87,77.74 EU2G1.7
VDDQ_VR_EN_S5: length 2.1
  TOP w0.1: EU2G1.8 263.27,78.23 R2G29.2
VDDQ_VR_FB: length 4.9
  TOP w0.203: EU2G1.6 262.47,78.32 R2G26.1 262.38,77.21 262.38,75.82 R2G37.2
VDDQ_VR_FB_R: length 3.3
  TOP w0.3: R2G25.2 C2G23.2 R2G26.2 R2G33.1
VDDQ_VR_TON: length 3.7
  TOP w0.203: 264.09,78.68 263.66,79.1 EU2G1.9
  TOP w0.5: R2G27.1 265.17,77.6 264.09,78.68
VDDQ_VR_VDD: length 3.5
  TOP w0.203: EU2G1.12 265.32,80.63 265.49,80.45
  TOP w0.38: 265.49,80.45 265.68,80.26 C2G21.1 R2G18.2 R2G21.2
VDDQ_VR_VDDQ_PIN: length 2.2
  TOP w0.203: EU2G1.5 261.2,80.23 C2G22.1 R2G20.2
VSS_EDP_AMOLED: length 41.6
  TOP w0.1: R1A4.1 v1(298.45,269.87) R1A5.1 ; J1B2.28 299.42,240.11 299.72,240.41 v1(299.72,241.17) 299.72,241.81 299.41,242.11 J1B2.32
  BOTTOM w0.1: v1(299.72,241.17) 300.73,242.19 300.73,249.93 296.41,254.25 295.91,254.25 293.24,256.92 293.24,261.87 298.19,266.83 298.19,269.62 v1(298.45,269.87)
VSS_SA_PCIE_IO_SENSE: length 111
  TOP w0.2: R5B60.2 154.45,245.24 v1(154.58,245.36) ; v1(160.52,206.75) 160.52,206.5 161.03,205.99 R5C40.2
  TOP w0.254: J3D1.D6 v1(207.61,196.78)
  LAY5 w0.2: v1(207.61,196.78) 208.15,197.33 208.15,198.84 202.57,204.41 194.93,204.41 192.32,201.8 183.94,201.8 181.53,204.21 181.53,206.49 178.65,209.37 165.05,209.37 163.57,207.9 161.67,207.9 v1(160.52,206.75)
  LAY6 w0.2: v1(160.52,206.75) 161.6,207.83 161.6,208.85 162.18,209.43 162.99,209.43 163.95,210.39 163.95,215.61 161.25,218.31 160.4,218.31 159.23,219.48 159.23,227.34 160.31,228.42 160.31,230.59 161.49,231.77 161.49,235.5 161.03,235.96 158.36,235.96 156.43,237.89 156.43,243.74 154.81,245.36 v1(154.58,245.36)
VSSGT_SENSE: length 125
  TOP w0.089: J3D1.AB38 v3(239.98,179.3)
  TOP w0.1: v1(281.61,220.98) 281.48,220.85 R1C13.2 280.92,219.96 TP2C1.1
  LAY2 w0.1: v1(268.73,164.03) 268.51,164.03 267.19,165.35 267.19,168.85 265.38,170.66 262.9,170.66 254.21,179.36 242.92,179.36 242.25,180.03 241.46,180.03 241.16,179.73 240.59,179.73 240.15,179.3 v3(239.98,179.3)
  LAY6 w0.115: v1(281.61,220.98) 281.61,220.8 281.73,220.67 282.69,220.67 283.44,219.93 283.44,213.52 278.23,208.31 278.23,201.06 282.42,196.87 283.38,196.87 284.73,195.52 284.73,194.69 290.7,188.72 290.7,174.62 287.75,171.67 287.75,168.63 282.75,163.62 270.71,163.62 270.01,164.32 269.02,164.32 v1(268.73,164.03)
VSSMPHY_SENSE: length 106.3
  TOP w0.089: 111.77,130.57 111.77,130.59 111.26,131.1 110.3,131.1 109.5,131.89 109.5,134.41 109.62,134.53 109.62,135.23 109.54,135.31 109.54,135.78 109.65,135.89 109.65,136.26 109.31,136.59
  TOP w0.1: v1(121.2,93.56) 120.86,93.22 120.39,93.22 114.37,99.24 114.37,105.61 115.26,106.5 115.26,109.58 114.8,110.03 114.8,111.03 112.95,112.88 112.95,129.39 111.77,130.57 ; 171.57,95.88 171.57,95.12 170.94,95.12 v1(170.81,95.25)
  LAY5 w0.115: v1(170.81,95.25) 170.54,94.98 170.51,94.98 168.09,97.41 148.08,97.41 147.32,96.65 142.36,96.65 140.2,98.8 133.47,98.8 128.52,93.85 124.33,93.85 123.76,93.28 121.49,93.28 v1(121.2,93.56)
2X4_GND: length 4.1
  TOP w0.38: J1A1.4 299.35,278.89 R1A1.1
2X4_POWER_DETECT: length 523.5
  TOP w0.089: U6E1.T47 106.74,135.73 106.95,135.52 106.95,135.23 106.95,130.81 109.47,128.29 109.47,128.04
  TOP w0.1: 109.47,128.04 109.47,110.81 108.58,109.92 v1(108.58,107.31) ; v1(302.76,271.26) 302.26,271.77 302.26,275.72 R1A2.2 R1A1.2
  LAY5 w0.125: v1(302.76,271.26) 302.64,271.39 294.45,271.39 293.94,270.88 290.4,270.88 289.89,271.39 282.23,271.39 281.55,272.07 278.42,272.07 275.97,274.52 274.01,274.52 273.76,274.27 268.32,274.27 267.87,274.72 266.29,274.72 264.18,276.83 257.55,276.83 257.17,277.21 257.17,277.72 256.39,278.51 253.38,278.51 252.62,277.74 250.21,277.74 249.7,277.24 239.85,277.24 239.6,277.49 237.61,277.49 236.47,278.63 229.99,278.63 229.1,277.75 225.93,277.75 224.42,276.24 222.49,276.24 219.24,272.99 210.52,272.99 205.36,278.15 205.36,284.94 203.15,287.14 199.21,287.14 197.81,288.54 177.72,288.54 176.35,287.17 176.35,285.34 177.92,283.77 177.92,281.02 176.3,279.4 172.32,279.4 171.05,278.13 168.57,278.13 166.94,279.77 163.26,279.77 162.42,278.94 162.42,277.28 161.49,276.35 147.49,276.35 143.97,279.88 143.97,283.69 142.71,284.94 136.81,284.94 135.63,283.76 135.63,280.33 133.34,278.05 133.34,275.38 132.96,275 132.96,272.88 132.05,271.98 131.08,271.98 129.91,270.8 129.91,268.18 128.93,267.2 124.38,267.2 123.57,268.02 122.68,268.02 122.37,267.72 117.37,267.72 116.9,267.25 115.33,267.25 114.91,266.83 110.61,266.83 107.31,263.52 105.79,263.52 105.41,263.9 105.41,265.17 104.29,266.29 102.71,266.29 101.85,265.43 v1(101.85,265.17) ; v1(108.58,107.31) 109.09,107.31 109.1,107.3 110.62,107.3 112.01,108.69 112.01,109.6 112.9,110.49 112.9,114.22 119.2,120.53 121.32,120.53 126.25,125.46 126.25,128.03 127.12,128.9 128.39,128.9 129.28,129.79 129.28,130.81 129.79,131.32 131.37,131.32 138.55,138.5 138.55,152.31 131.18,159.68 131.18,164.47 131.98,165.26 131.98,170.43 128.39,174.02 128.39,175.66 129.35,176.62 129.35,179.12 129.05,179.42 129.05,184.68 129.68,185.31 129.68,188.37 130.18,188.87 130.18,190.64 131.13,191.59 131.13,192.48 131.66,193.02 131.66,196.03 129.66,198.03 129.66,208.65 129.54,208.77 129.54,210.69 128.2,212.03 127.18,212.03 126.61,212.6 126.61,213.1 125.26,214.46 123.15,214.46 121.67,212.98 119.99,212.98 118.26,211.25 107.37,211.25 103.78,207.66 102.08,207.66 98.65,211.08 97.01,211.08 v1(94.23,213.87)
  LAY6 w0.125: v1(101.85,265.17) 101.85,262.89 101.09,262.13 101.09,258.57 102.19,257.46 103.96,257.46 104.3,257.13 104.3,255.31 102.52,253.53 102.52,248.45 101.72,247.65 100.43,247.65 96.34,243.56 96.34,242.26 92.45,238.38 92.45,222.5 93.21,221.74 93.21,214.88 v1(94.23,213.87)
3.3A_KBC_SENSE_SMC: length 2.6
  TOP w0.3: R8F15.1 26.03,120.52 25.88,120.37 EU8F1.4
  TOP w0.5: R8F14.2 R8F15.1
3G16_JTAG2_CLK: length 4.2
  TOP w0.1: R5B19.1 147.19,243.52 146.19,242.53 143.91,242.53 J5B2.A5
3G16_RSVD_B12: length 12.6
  TOP w0.1: R5C4.2 137.03,222.88 138.04,223.9 138.04,232.41 J5B2.B12
3P3APG_PIN2: length 3.8
  TOP w0.1: Q8D13.1 C8D31.1 R8D85.1 R8D88.2
3P3APG_PIN5: length 5.4
  TOP w0.1: R8D90.2 Q8D14.1 36.32,162.94 37.59,164.21 Q8D13.3
12_FAN_FETDRV: length 5.2
  TOP w0.3: v1(290.83,138.81) 290.94,138.93 EU1E2.7
  TOP w0.38: v1(290.02,142.07) 290.65,142.07 EU1E1.4
  BOTTOM w0.38: v1(290.02,142.07) 290.02,139.49 290.7,138.81 v1(290.83,138.81)
12_PEG_FETDRV: length 4.5
  TOP w0.35: EU6B2.4 117.09,248.54 117.98,249.43 117.98,250.82 117.59,251.21 EU6B1.7
12_SLOT2_FETDRV: length 2.8
  TOP w0.28: EU8B1.7 52.95,257.17 52.02,256.24 EU8B3.4
12_SLOT3_FETDRV: length 7.4
  TOP w0.28: v1(36.06,254.69) 35.77,254.39 EU8B4.7 ; v1(41.65,254.33) 42.37,254.33 EU8B2.4
  LAY5 w0.28: v1(41.65,254.33) 41.6,254.39 36.36,254.39 v1(36.06,254.69)
+BV_VBAT_VREG_R_CR: length 286.9
  TOP w0.5: v1(15.24,160.91) 15.11,160.78 13.08,160.78 11.93,159.64 R9E1.1
  TOP w0.508: v1(21.71,216.53) 20.06,218.18 20.06,219.96 24.25,224.15 CR8C1.2
  LAY5 w0.5: v1(13.2,9.78) 13.46,9.52 21.71,9.52 22.96,10.77 61.86,10.77 J8J13.40
  LAY6 w0.5: v1(13.2,9.78) 13.2,14.35 10.76,16.79 10.76,48.64 9.41,49.99 9.41,55.42 9.77,55.77 9.77,62.53 10.58,63.34 10.58,69.51 11.48,70.41 11.48,73.33 12.72,74.57 12.72,75.28 11.73,76.28 11.73,80.6 10.71,81.62 10.71,96.18 11.68,97.15 11.68,103.72 11.22,104.18 11.22,119.96 10.26,120.92 10.26,132.81 11.6,134.15 11.6,136.7 12.85,137.95 14.19,137.95 15.43,139.19 15.43,146.6 14.77,147.27 14.77,158.04 15.24,158.51 v1(15.24,160.91) 15.24,168.53 14.41,169.36 14.41,177.23 13.41,178.23 13.41,186.75 14.98,188.33 14.98,192 18.79,195.81 18.79,201.92 21.59,204.71 21.59,205.87 21.25,206.2 21.25,216.08 v1(21.71,216.53)
+BV_VREG_MAIN_R34BV: length 6.1
  TOP w0.38: R9J14.1 22.86,21.33 22.86,18.67 J9J4.2
+BV_VREG_VBAT_J: length 3.3
  TOP w0.5: J9E1.2 9.39,158.62 R9E1.2
+BV_VREG_VBAT_R: length 77.6
  TOP w0.508: BH9C1.2 22.6,214.11 16.38,207.88 13.77,207.88 13.15,207.26 9.72,207.26 6.29,203.83 v1(5.84,203.83)
  LAY5 w0.5: J9E1.1 5.58,159.89 5.58,172.57 6.47,173.46 6.47,186.05 5.08,187.45 5.08,191.77 5.84,192.53 v1(5.84,203.83)
  BOTTOM w0.5: BH9C1.2 BH9C1.1
+DRMOS_5V: length 143.4
  TOP w0.38: R4B21.1 201.04,248.03 201.8,247.27 R4B28.2 ; R4B29.2 188.46,247.14 187.45,248.16 R4B20.1 186.94,249.3 v1(187.07,249.43) ; v1(233.29,249.43) R3B27.1 233.8,247.65 234.18,247.65 234.82,247.01 R3B42.2 ; R3B40.2 224.79,247.14 223.9,248.03 R3B28.1 v1(223.39,249.17) ; v1(272.56,246.51) 272.41,246.35 272.41,245.24 ; R1D5.1 287.4,181.99 286.25,180.85 v1(286.25,180.59) R1D6.2 ; v1(246.76,249.17) R2B6.1 247.26,248.03 248.15,247.14 R2B16.2 ; R3B41.2 211.45,247.14 210.43,248.16 R3B26.1 209.93,248.41 v1(209.04,249.3) ; R2B17.2 258.06,247.01 256.92,248.16 R2B5.1 256.54,249.3 v1(256.66,249.43)
  TOP w0.5: R2B7.1 270.38,248.54 v1(270,248.92) ; R1D8.1 287.17,168.05 286.38,167.26 R1D9.2 285.39,167.99 285.36,168.02 v1(285.36,168.27) ; v1(200.4,248.92) R4B21.1
  LAY5 w0.5: v1(285.36,168.27) 285.36,168.4 286.46,169.5 286.46,175.41 285.09,176.79 285.09,179.42 v1(286.25,180.59) ; v1(200.4,248.92) 199.13,248.92 198.75,249.3 187.19,249.3 v1(187.07,249.43)
  LAY5 w0.508: v1(286.25,180.59) 287.52,181.86 287.52,193.42 283.96,196.99 283.96,198 283.33,198.63 281.3,198.63 279.4,200.53 275.33,200.53 274.57,201.29 274.57,203.07 275.59,204.09 275.59,209.8 274.82,210.56 274.82,218.69 274.06,219.45 274.06,233.04 272.79,234.31 272.79,246.28 v1(272.56,246.51)
  vias: v1(229.23,252.86) v1(229.99,252.86) v1(255.9,249.43)
+HDMIC_ALS_SCL_R: length 4.1
  TOP w0.1: R2A22.1 274.06,270.64 CR2A3.1
+HDMIC_ALS_SDA_R: length 4.3
  TOP w0.1: CR2A3.2 276.52,271.97 276.52,271.32 276.09,270.89 274.57,270.89 R2A23.1
+PW_VCC0V9_LAN: length 14.3
  TOP w0.2: EU7A3.26 v1(98.78,261.89) ; v1(93.8,264.44) 93.48,264.12 EU7A3.38 ; v1(95.09,255.95) 95.09,256.01 95.08,256.01 EU7A3.9
  TOP w0.203: EU7A3.56 v1(90.32,257.49) ; v1(90.32,262.37) 90.39,262.29 EU7A3.44 ; EU7A3.50 v1(90.32,259.89)
  BOTTOM w0.38: v1(95.09,255.95) 94.99,256.06 C7M5.1 ; C7M1.1 90.88,259.33 v1(90.32,259.89) 90.77,260.35 C7L8.1 ; C7M8.1 91.05,256.54 90.32,257.28 v1(90.32,257.49) 91.11,257.49 C7M3.1 ; C6L4.1 98.12,261.24 v1(98.78,261.89) 98.27,261.89 C6L3.1 ; v1(93.8,264.44) 93.59,264.22 93.59,263.66 C7L3.1 ; v1(90.32,262.37) 90.56,262.13 C7L6.1
  vias: v1(91.31,251.66) v1(92.05,251.67)
+PW_VCC0V9_LC: length 1.4
  TOP w0.2: U5A2.J8 v2(164.09,268.7)
  BOTTOM w0.2: C5L20.1 163.57,267.97 163.57,268.18 v2(164.09,268.7)
+PW_VCC0V9_LVR: length 0.9
  TOP w0.203: U5A2.H8 164.42,269.03 v2(164.74,269.35) ; U5A2.H6 163.77,269.03 v2(164.09,269.35)
+PW_VCC0V9_PCIE: length 2.8
  TOP w0.203: U5A2.M16 v2(168.64,266.75) ; v2(169.29,266.75) 168.97,267.08 U5A2.M18 ; U5A2.J18 169.29,268.7 v2(169.32,268.7) ; U5A2.L18 168.97,267.73 v2(169.29,268.05) ; v2(169.94,268.05) 169.62,267.73 U5A2.L19 ; U5A2.M19 v2(169.94,266.75)
+PW_VCC3V3_ANA: length 2.1
  TOP w0.1: U5A2.E16 168.64,270 v2(168.61,270)
  BOTTOM w0.089: v2(168.61,270) 168.4,270.22 168.4,270.89
  BOTTOM w0.1: C5L5.1 168.01,271.4 168.4,271.02 168.4,270.89
+PW_VCC3V3_ANA_PCIE: length 4.1
  TOP w0.1: v2(168.64,268.05) 168.32,267.73 U5A2.L16
  BOTTOM w0.089: 168.65,271.14 168.65,270.51 168.96,270.19 168.96,268.38 v2(168.64,268.05)
  BOTTOM w0.1: 168.65,271.14 168.65,271.4 C5L4.1
+PW_VCC3V3_ANA_USB2: length 2.2
  TOP w0.1: v2(169.32,269.35) 169.29,269.35 168.97,269.03 U5A2.H18
  BOTTOM w0.089: v2(169.32,269.35) 169.64,269.68 170.11,269.68 170.17,269.75
  BOTTOM w0.1: 170.17,269.75 170.55,270.13 170.68,270.13 C4L3.1
+PW_VCC3V3_LC: length 12.1
  TOP w0.203: U5A2.V6 v2(164.09,264.8)
  BOTTOM w0.25: 171.45,261.49 171.06,261.49 170.68,261.87 169.92,261.87 169.67,262.13 R5L18.2 ; 165.98,262.13 165.98,262.89
  BOTTOM w0.305: v2(164.09,264.8) 164.71,264.18 C5L36.1
  BOTTOM w0.38: C5L36.1 164.71,262.51 165.22,262 165.86,262 165.98,262.13 165.98,261.87 166.36,261.49 168.27,261.49 168.68,261.9 169.18,261.9 R5L18.2
+U11EV_PIN7: length 4.5
  TOP w0.38: U8J1.7 C7J1.1 63.75,33.07
+U12EV_PIN4: length 7.6
  TOP w0.38: C8J1.1 v1(55.24,28.19) U8J1.4
  LAY6 w0.508: v1(55.24,33.78) v1(55.24,28.19)
+V_3P3_PORT80: length 19.1
  TOP w0.38: v1(51.43,265.81) 51.35,265.73 42.74,265.73 40.23,268.25 v1(39.62,268.25)
  BOTTOM w0.38: R8L6.1 R8L7.1 ; R8L6.1 R8L4.1 R8L2.1 ; R8L6.1 v1(51.43,265.81) ; v1(39.62,268.25) 39.72,268.35 U8L1.16
+V_3V3_USBC_FLASH: length 60
  TOP w0.3: v1(112.82,259.59) 112.77,259.64 C6A49.1
  TOP w0.5: R5B13.1 138.3,257.02 v1(138.27,257.05) ; v1(133.24,259.33) 133.24,255.17 132.35,254.28 U5B1.8 ; v1(140.2,257.05) 140.08,256.92 R5B15.1 142.49,256.28 CR5B1.1 143,255.65 140.84,253.49 129.66,253.49 C6B2.1 ; R5B14.1 v1(139.19,257.05)
  TOP w0.508: C6B2.1 C6B1.1 ; C6B1.1 R6B8.1 ; C6B1.1 130.32,254.51 130.55,254.28 U5B1.8
  LAY6 w0.5: v1(138.27,257.05) v1(139.19,257.05) v1(140.2,257.05)
  BOTTOM w0.5: v1(133.24,259.33) 129.83,259.33 128.69,258.19 126.69,258.19 126.06,258.82 124.07,258.82 J6B1.18 119.38,258.7 113.71,258.7 v1(112.82,259.59) 112.82,258.01 114.04,256.79 J6B1.6
+V_5.0_7_PC: length 2.8
  TOP w0.38: J5J2.14 v1(126.23,7.49)
  BOTTOM w0.38: R6W4.2 126.74,6.97 126.23,7.49 v1(126.23,7.49)
+V_CODEC_CPVEE: length 2.5
  TOP w0.2: EU6A1.20 127.5,279.24 127.79,279.53 128.65,279.53 C6A15.2
+V_CODEC_CPVPP: length 2.9
  TOP w0.2: EU6A1.25 126.15,281.85 126.23,281.94 126.74,281.94 127.76,282.95 C6A6.2
+V_CODEC_LDO1: length 3.2
  TOP w0.2: C6A13.1 118.99,281.05 R6A30.1 119.12,280.04 EU6A1.39
+V_CODEC_LDO2: length 2.2
  TOP w0.2: C6A17.1 128.25,278.36 127.58,278.36 127.5,278.44 EU6A1.18
+V_CODEC_LDO3: length 3.5
  TOP w0.2: 129.03,275.33 128.27,276.1 128.27,276.73 127.36,277.64 EU6A1.16
+V_CODEC_LDO4: length 2.1
  TOP w0.2: C6A16.1 119.43,278.84 EU6A1.42
+V_CODEC_STB: length 9.8
  TOP w0.5: R6A18.2 v1(116.38,281.63) ; R6A11.1 v1(122.17,285.11)
  LAY6 w0.5: v1(116.38,281.63) 116.58,281.43 117.98,281.43 118.87,282.32 118.87,283.59 119.63,284.35 121.41,284.35 v1(122.17,285.11)
+V_CODEC_VREF: length 4.1
  TOP w0.2: EU6A1.38 120.46,280.44 120.14,280.76 120.14,281.43 119.38,282.19 C6A11.2 C6A8.2
+V_CPU_VREF_CA_DIMM0_CHA: length 93.9
  TOP w0.089: J3D1.AC40 v3(241.81,178.38)
  TOP w0.215: v1(293.62,118.49) 293.24,118.87 R1F6.1 C1F1.1
  LAY2 w0.215: v1(281.3,139.6) 281.04,139.6 276.26,144.37 276.26,148.23 263.98,160.51 263.98,168.07 253.58,178.47 241.9,178.47 v3(241.81,178.38)
  BOTTOM w0.215: v1(293.62,118.49) 291.46,118.49 290.06,119.89 290.06,133.45 288.13,135.39 287.36,135.39 283.78,138.97 282.61,138.97 281.97,139.6 v1(281.3,139.6)
+V_CPU_VREF_CA_DIMM0_CHA_R: length 3
  TOP w0.38: R1F4.1 R1F5.1 ; R1F5.1 291.97,118.87 ; R1F5.1 291.97,120.9
+V_CPU_VREF_CA_DIMM0_CHB: length 117.6
  TOP w0.089: v3(240.9,178.41) 240.9,178.43 J3D1.AC39
  TOP w0.38: v1(294.89,106.17) 294.89,106.55 293.75,107.69 292.35,107.69 291.97,108.08 C1F7.1 291.71,108.84 R1F26.1
  LAY6 w0.15: 242.35,178.84 241.3,178.84 v3(240.9,178.41)
  LAY6 w0.216: v1(282.77,139.6) 282.41,139.6 281.86,140.16 280.59,140.16 278.13,142.62 278.13,145.05 276.64,146.54 276.64,148.64 273.45,151.83 273.45,155.3 269.11,159.64 269.11,160.72 266.25,163.57 265.17,163.57 264.35,164.4 264.35,168.72 259.53,173.54 259.53,176.32 256.69,179.15 255.82,179.15 255.18,179.79 255.18,180.46 254.77,180.87 245.17,180.87 243.14,178.84 242.35,178.84
  BOTTOM w0.3: v1(282.77,139.6) 283.95,139.6 287.49,136.07 288.34,136.07 290.7,133.71 290.7,124.59 296.67,118.62 296.67,115.57 294.64,113.54 294.64,112.39 295.1,111.93 295.1,106.38 v1(294.89,106.17)
+V_CPU_VREF_CA_DIMM0_CHB_R: length 2.9
  TOP w0.38: R1F26.2 R1F31.1 291.71,107.06 R1F32.1 291.97,105.92
+V_CPU_VREF_CA_DIMM1_CHA: length 106.3
  TOP w0.089: J3D1.AC38 v3(239.98,178.41)
  TOP w0.215: v1(292.35,115.82) 291.97,115.44 R1F12.1 291.33,115.06 290.95,115.44 C1F4.1
  LAY6 w0.15: 240.45,179.55 240.45,178.88 v3(239.98,178.41)
  LAY6 w0.215: v1(281.3,140.71) 280.67,140.71 278.51,142.87 278.51,146.65 277.39,147.77 277.39,149.26 273.83,152.82 273.83,156.44 265.55,164.72 265.55,165.44 265.26,165.73 265.26,168.24 265.89,168.87 265.89,170.24 265.32,170.81 263.02,170.81 260.02,173.8 260.02,177.66 255.71,181.97 244.73,181.97 242.63,179.87 240.76,179.87 240.45,179.55
  BOTTOM w0.215: v1(281.3,140.71) 280.81,140.23 280.81,139.4 281.65,138.57 283.38,138.57 287.56,134.39 288.44,134.39 289.56,133.27 289.56,118.62 v1(292.35,115.82)
+V_CPU_VREF_CA_DIMM1_CHA_R: length 1
  TOP w0.38: R1F17.1 R1F12.2
+V_CPU_VREF_CA_DIMM1_CHB: length 119.1
  TOP w0.089: J3D1.AB40 v3(241.81,179.3)
  TOP w0.215: C1F12.1 R1F52.1 293.75,97.41 v1(294.38,98.04)
  LAY2 w0.215: v1(280.67,141.86) 279.27,141.86 276.6,144.53 276.6,148.38 264.33,160.65 264.33,168.26 253.76,178.83 242.28,178.83 v3(241.81,179.3)
  BOTTOM w0.215: v1(294.38,98.04) 296.41,100.07 296.41,111.5 295.27,112.65 295.27,113.28 297.05,115.06 297.05,118.78 291.08,124.74 291.08,134.97 284.53,141.53 280.99,141.53 v1(280.67,141.86)
+V_CPU_VREF_CA_DIMM1_CHB_R: length 0.9
  TOP w0.38: R1F52.2 R1F51.1
+V_CPU_VREF_DIMM1_CHA: length 2.8
  TOP w0.38: R1F16.1 291.97,114.04 R1F21.1 291.97,112.27
+V_CPU_VREF_DIMM1_CHB: length 3.2
  TOP w0.38: 291.97,99.19 R1F43.1 ; R1F43.1 291.97,101.34 ; R1F43.1 R1F42.1
+V_LDO_1V8_BP_PD: length 4.7
  TOP w0.1: C5A27.1 149.22,267.94 148.46,267.18 145.81,267.18 EU5A1.35
+V_LDO_3V3_USBC: length 346.5
  TOP w0.28: EU5A1.9 137.5,266.73 R5A31.1 ; CR5B1.2 147.06,255.78 150.36,259.08 150.36,261.87 150.87,262.38 R5A46.1 ; R5A46.1 151,263.4 R5A47.1 ; R5A46.1 R5A38.1 R5A33.1 ; R5A36.1 v1(134.87,265.68)
  TOP w0.35: U6A4.5 110.49,268.6 C6A34.1 R6A57.1 109.6,270.25 109.22,270.63 108.73,270.63 108.38,270.28 108.38,269.03 107.95,268.6 106.93,268.6 106.04,267.71 v1(106.04,266.37)
  TOP w0.38: v1(145.16,257.15) 145.41,257.4 R5B6.1 R5B7.1 ; R5A59.1 R5A60.1 142.24,259.79
  TOP w0.5: 142.24,258.7 142.24,259.79 ; 142.24,258.7 141.22,258.7 139.82,260.09 139.82,262.13 v1(139.63,262.32) ; 142.24,258.7 142.24,257.68 143.28,256.64 143.68,256.64 144.55,255.78 CR5B1.2 146.3,255.8 146.3,256 v1(145.16,257.15)
  TOP w0.508: v1(42.67,92.33) 42.79,92.2 R8G11.1
  LAY5 w0.5: v1(86.99,264.79) 86.54,265.25 81.42,265.25 79.47,267.19 68.69,267.19 68.14,266.64 66.11,266.64 64.55,268.19 60.96,268.19 59.64,266.88 49.96,266.88 49.14,266.06 46.73,266.06 45.72,265.05 v1(45.08,265.05)
  LAY6 w0.5: v1(86.99,264.79) 86.99,265.17 88.79,266.97 92.69,266.97 93.62,266.04 94.38,266.04 94.91,266.57 105.84,266.57 v1(106.04,266.37) 106.17,266.5 107.01,266.5 107.56,265.94 107.56,265.84 111.06,262.35 111.06,261.56 112.25,260.36 121.9,260.36 124.26,262.72 130.39,262.72 131.69,264.03 133.09,264.03 134.74,265.68 v1(134.87,265.68)
  LAY6 w0.508: v1(42.67,92.33) 42.41,92.33 41.91,92.84 41.91,97.92 42.22,98.24 42.22,101.3 43.68,102.77 43.68,106.17 42.41,107.44 42.41,121.28 43.53,122.4 43.53,126.59 44.55,127.61 44.55,130.33 43.75,131.13 43.75,135.99 42.42,137.31 42.42,138.94 43.3,139.83 43.3,144.63 43.15,144.78 43.15,148.57 42.46,149.26 42.46,152.48 41.97,152.97 41.97,159.45 43.15,160.63 43.15,161.77 44.17,162.79 44.17,168.42 43.37,169.22 43.37,177.23 42.03,178.56 42.03,181.86 40.57,183.32 40.57,186.63 40.89,186.95 40.89,188.35 41.46,188.92 41.46,198.36 40.89,198.93 40.89,207.76 40.25,208.41 38.72,208.41 34.6,212.52 34.6,220.03 34.22,220.4 34.22,227.14 35,227.91 35,231.82 33.78,233.04 33.78,235.08 35.69,236.99 35.69,240 36.46,240.77 36.46,242.08 37.08,242.7 38.22,242.7 39.11,243.58 42.54,243.58 43.56,244.6 45.08,244.6 46.48,246 46.48,248.28 47.56,249.36 47.56,251.52 46.5,252.58 46.5,254.4 46.92,254.82 46.92,255.97 45.21,257.68 45.21,264.92 v1(45.08,265.05)
  BOTTOM w0.5: v1(139.63,262.32) 139.63,262.37 138.35,263.65 137.01,263.65 134.98,265.68 v1(134.87,265.68)
+V_PPHV_TYPEC: length 2.8
  TOP w0.3: R6A83.2 130.34,260.35 130.85,260.85
+V_PPHV_TYPEC_BP_R: length 21.2
  TOP w0.38: R6A82.1 110.87,260.22 110.87,259.2 111.25,258.82 126.61,258.82 v1(126.87,259.08) ; C6A46.1 126.49,261.11 R6A83.1 ; C6A43.1 122.3,259.97
+V_PWR_MON1: length 4.1
  TOP w0.089: U3H1.B2 218.06,54.1 217.67,54.1 217.63,54.06 217.25,54.06
  TOP w0.38: C3H4.1 215.01,54.99 215.9,54.1 R3H25.2 217.17,53.97 217.25,54.06
+V_PWR_MON2: length 4.3
  TOP w0.089: U1E2.B2 282.83,155.07 282.19,155.07
  TOP w0.1: 281.96,154.99 282.04,155.07 282.19,155.07
  TOP w0.38: 281.96,154.99 281.66,154.68 280.92,154.68 R2E5.2 280.67,155.07 279.78,155.95 C2E1.1
+V_PWR_MON3: length 4.2
  TOP w0.089: 282.7,145.41 283.34,145.41 U1E3.B2
  TOP w0.1: 282.32,145.29 282.44,145.41 282.7,145.41
  TOP w0.38: C1E8.1 280.28,146.3 281.17,145.41 R1E34.2 281.3,145.16 282.19,145.16 282.32,145.29
+V_PWR_MON4: length 4.3
  TOP w0.088: 290.07,161.29 U1E1.B2
  TOP w0.089: 290.07,161.29 289.43,161.29
  TOP w0.1: 289.43,161.29 289.3,161.29 289.21,161.2
  TOP w0.38: C1D13.1 287.02,162.18 287.9,161.29 R1E3.2 288.16,160.91 288.92,160.91 289.21,161.2
+V_PWR_MON5: length 3.8
  TOP w0.089: 187.83,54.1 188.58,54.1 U4H1.B2
  TOP w0.38: R4H24.2 C4H7.1 186.67,54.1 187.83,54.1
+V_PWR_MON6: length 4.4
  TOP w0.089: U3H2.B2 228.73,54.6 228.73,54.95 228.72,54.96 228.72,55.12
  TOP w0.1: 228.72,55.12 228.72,55.37
  TOP w0.38: 228.72,55.37 228.72,56.39 C3H1.1 R3H10.2
+V_PWR_MON7: length 4.1
  TOP w0.089: 201.42,53.21 202.06,53.21 U4H2.B2
  TOP w0.1: 201.42,53.21 201.16,53.21 201.06,53.11
  TOP w0.38: 201.06,53.11 201.04,53.08 R4H32.2 199.89,53.21 199,54.1 C4H9.1
+V_VDDQ_VR_OUT: length 15.8
  TOP w0.3: R2G31.1 256.92,76.45 256.28,77.09 256.28,79.5 254.38,81.41 254.38,88.39
  TOP w0.305: 254.12,88.64 254.38,88.39
  TOP w0.508: R2G2.1 251.58,89.79
+VHDMI_1P2S_VR_IN: length 1.3
  TOP w0.38: 273.81,259.46 273.81,259.15 R2B3.2
+VPP: length 300.3
  TOP w0.38: C5F2.1 v1(155.49,116.58) C5F1.1 ; 146.05,104.01 146.17,104.14 R5F13.2 ; R7C4.1 96.77,225.8 97.53,225.04 97.53,219.58 96.77,218.82 v1(96.77,218.79) ; R5F6.1 v1(155.54,115.44) ; 149.09,123.06 147.95,124.2 147.95,128.9 143.63,133.22 141.09,133.22 v1(140.71,133.6)
  TOP w0.508: R2G38.1 v1(249.8,73.53)
  LAY5 w0.38: v1(96.77,218.79) 95.6,218.79 94.38,217.58 94.38,215.87 97.7,212.55 116.88,212.55 121.71,217.39 128.72,217.39 134.74,211.37 134.74,206.08 135.57,205.25 135.57,192.47 136.14,191.9 136.14,187.96 135.03,186.85 135.03,178.4 135.5,177.93 135.5,175.96 135.15,175.61 135.15,172.23 135.99,171.4 135.99,163.37 141.8,157.56 141.8,134.81 140.71,133.73 v1(140.71,133.6) ; v1(249.8,73.53) 249.8,76.45 249.17,77.09 226.06,77.09 225.42,76.45 218.12,76.45 215.97,78.6 207.12,78.6 204.09,75.57 195.49,75.57 194.31,76.74 183.71,76.74 182.27,75.31 180.36,75.31 175.38,70.33 v1(175.38,69.98)
  LAY6 w0.38: J1F3.286 157.84,98.66 158.83,97.66 171.32,97.66 172.97,96.01 176.91,96.01 v1(177.54,96.65)
  BOTTOM w0.38: v1(177.54,96.65) 177.54,96.52 179.32,94.74 181.35,94.74 183.38,92.71 183.38,81.66 181.86,80.14 181.86,79.07 177.61,74.83 177.61,72.2 v1(175.38,69.98)
  vias: v1(155.68,132.51) v1(155.68,131.57)
+VPP_VR_OUT: length 8.2
  TOP w0.3: R5F22.1 v1(147.44,102.61) ; R5F13.1 C5F8.1
  BOTTOM w0.3: v1(147.44,102.61) 147.44,107.16 v1(146.68,107.92)
+VPP_VR_SW_SNUB: length 1.9
  TOP w0.5: C5F7.1 144.78,112.39 144.14,111.76
+VPP_VR_VIN: length 1.6
  TOP w0.38: C5F10.1 R5F12.2
+VR_CAP: length 3.3
  TOP w0.2: 24.59,107.61 24.82,107.38 U8F6.18
  TOP w0.5: C9F3.1 23.74,108.46 24.59,107.61
+VREF_ADC: length 27.8
  TOP w0.5: FB6J1.2 117.05,25.87 134.1,25.87 135.89,24.08
  TOP w0.508: J6J2.161 J6J2.153 136.39,20.95 136.39,23.57 135.89,24.08
+VREF_CPU: length 186.5
  TOP w0.203: U8F6.95 31.22,89.81 31.3,89.72
  TOP w0.38: 31.3,89.72 32.25,88.77 C8G7.1 ; J6J2.217 v1(145.87,21.21) ; J6J2.225 v1(147.66,20.78)
  TOP w0.5: C8G7.1 33.14,88.01 R8G25.2 v1(33.27,89.03)
  LAY3 w0.508: v1(33.27,89.03) 33.51,88.79 33.51,72.26 32.05,70.81 32.05,70.05 31.26,69.26 31.26,67.16 29.74,65.64 29.74,62.7 27.55,60.51 27.55,55.58 28.21,54.91 28.21,50.25 29.83,48.63 33.4,48.63 36.06,45.97 36.06,42.92 40.1,38.88 42.64,38.88 43.43,39.67 45.21,39.67 45.48,39.94 46.54,39.94 46.7,40.11 51.71,40.11 54.7,37.12 61.15,37.12 64.66,33.6 67.24,33.6 67.48,33.36 101.1,33.36 102.79,31.67 110.92,31.67 112.06,32.82 113.1,32.82 113.66,32.26 113.66,30.88 115.82,28.73 141.32,28.73 145.87,24.17 v1(145.87,21.21) 147.23,21.21 v1(147.66,20.78)
+VREF_VTT_VR: length 2.2
  TOP w0.203: C2G20.1 259.6,80.63 EU2G1.4
+VREG_PS2: length 19.9
  TOP w0.38: R7J2.1 v1(68.45,28.62) ; v1(69.85,28.62) 69.72,28.75 R7J3.1 ; v1(72.44,28.62) 72.26,28.8 R7J5.1
  TOP w0.508: R7J5.1 R7J4.1
  LAY6 w0.5: 78.61,11.05 J7J4.2 78.79,13.16
  LAY6 w0.508: 76.2,20.83 75.94,21.08 75.94,25.12 v1(72.44,28.62)
  BOTTOM w0.508: v1(72.44,28.62) v1(69.85,28.62) v1(68.45,28.62)
  vias: v1(77.97,21.08) v1(78.99,21.08)
+VRTC: length 400.9
  TOP w0.38: v1(130.12,20.78) J6J2.121
  TOP w0.5: CR8C1.3 28.76,225.11 C8C4.1 29.71,225.3 33.27,221.74 33.65,221.74 34.54,220.85 v1(34.92,220.85) ; R7F23.1 81.66,118.87 v1(81.91,119.12) ; R8F49.1 43.3,101.47 v1(43.81,100.96) ; R7F5.1 80.69,126.74 82.88,128.93 84.65,128.93 v1(84.7,128.98)
  TOP w0.508: J6J2.113 129.61,20.27 v1(130.12,20.78)
  LAY3 w0.508: v1(43.81,100.96) 41.68,98.83 41.68,97.82 40.89,97.03 40.89,91.82 40,90.93 40,87.63 39.49,87.12 39.49,79.25 40,78.74 40,72.52 39.11,71.63 39.11,66.29 41.69,63.72 43.23,63.72 44.73,62.22 44.73,59.53 46.35,57.91 46.35,55.16 47.32,54.19 47.32,50.46 51.43,46.35 53.72,46.35 57.67,42.4 70.75,42.4 72.61,40.54 78.23,40.54 78.48,40.28 84.6,40.28 85.56,41.24 89.24,41.24 89.83,41.83 105.31,41.83 106.45,40.69 121.61,40.69 124.58,37.72 v1(125.34,37.72)
  LAY5 w0.5: v1(75.43,93.6) 75.66,93.37 79.35,93.37 81.96,95.98 81.96,97.89 81.72,98.13 81.72,101.07 82.22,101.57 82.22,111.31 80.77,112.76 80.77,117.98 v1(81.91,119.12) 82.37,119.58 82.37,125.17 84.7,127.51 v1(84.7,128.98)
  LAY6 w0.508: v1(43.81,100.96) 43.81,101.11 44.95,102.24 44.95,111.26 44.17,112.04 44.17,126.33 45.18,127.35 45.18,130.59 44.47,131.3 44.47,145.95 45.23,146.71 45.23,148.71 44.02,149.93 44.02,151.82 42.6,153.23 42.6,158.81 44.8,161.01 44.8,168.69 44,169.49 44,177.49 43.12,178.37 43.12,181.92 41.27,183.77 41.27,184.91 42.29,185.93 42.29,186.69 41.52,187.45 41.52,188.09 42.1,188.66 42.1,198.62 41.52,199.19 41.52,208.02 40.51,209.04 38.98,209.04 35.24,212.79 35.24,220.53 v1(34.92,220.85)
  LAY8 w0.508: v1(125.34,37.72) 125.6,37.72 126.3,37.02 126.3,36.47 126.84,35.92 129.34,35.92 132.53,32.72 132.53,30.94 131.9,30.3 131.9,26.18 130.61,24.89 130.61,22.93 131.03,22.5 131.03,21.31 130.51,20.78 v1(130.12,20.78)
  BOTTOM w0.508: v1(84.7,128.98) 84.7,129.28 85.21,129.79 86.1,129.79 87.12,130.81 R7R62.1 R7R60.1 ; v1(43.81,100.96) 44.57,101.73 46.1,101.73 50.5,97.33 61.13,97.33 62.73,98.93 72.18,98.93 73.2,97.92 73.2,95.83 v1(75.43,93.6)
+VRTC_V3P3DSW_RDIV: length 6.7
  TOP w0.38: C8C9.1 R8C13.1 25.78,220.34
  TOP w0.5: C8C9.1 26.28,223.14 26.28,225.68 25.9,226.06 CR8C1.1
+VTT: length 9.7
  TOP w0.305: R2G14.2 255.52,81.79 255.01,82.29 255.01,84.94 255.21,85.14 ; v1(218.69,95.88) C3G4.1 218.69,96.77
  TOP w0.38: 256.15,86.1 R2G8.2 255.21,85.14 255.14,85.22
  vias: v1(217.04,95.88) v1(217.83,132.71) v1(217.93,96.77) v1(217.93,95.88) v1(255.14,86.61) v1(256.03,86.61) v1(256.92,86.61)
+VTT_LDO_VIN: length 2
  TOP w0.203: EU2G1.19 262.87,84.34 C2G13.1
+VTT_OUT: length 1.9
  TOP w0.2: 262.27,83.24 262.47,83.04 EU2G1.20 262.08,82.49 262.06,82.46
  TOP w0.508: R2G8.1 256.15,83.06
+VTYPEC_VR_IN_BP: length 15.5
  TOP w0.38: R6A73.1 123.31,266.44 v1(122.42,265.56) ; R6A77.2 110.49,262.51
  BOTTOM w0.38: v1(110.49,265.68) 111.12,266.32 115.95,266.32 116.84,265.43 122.3,265.43 v1(122.42,265.56)
AIC_TBT_CIO_PWR_EN: length 4.6
  TOP w0.1: J6J1.4 118.33,31.75 118.74,31.75 119.25,32.26 R6H44.1
AIC_USB_FORCE_PWR: length 289.6
  LAY5 w0.125: v1(127.25,214.63) 128.09,214.63 131.95,210.77 131.95,203.45 132.71,202.69 132.71,196.76 132.96,196.51 132.96,192.53 132.39,191.96 132.39,191.07 131.44,190.12 131.44,189.1 131.95,188.59 131.95,180.6 131.69,180.34 131.69,178.56 132.32,177.93 132.32,176.66 133.28,175.71 133.28,171.93 134.45,170.76 134.45,168.67 133.64,167.85 133.64,163.54 140.26,156.91 140.26,137.75 134.35,131.83 134.35,124.07 129.02,118.74 126.73,118.74 124.72,120.76 123.91,120.76 122.03,118.87 119.91,118.87 114.56,113.52 114.56,109.8 114.24,109.47 114.24,107.87 115.07,107.04 115.07,106.41 114.14,105.48 114.14,89.69 v1(115.44,88.39)
  LAY6 w0.125: v1(127.25,214.63) 127,214.88 127,216.73 125.79,217.94 125.79,225.01 123.95,226.84 123.95,234.84 122.81,235.99 122.81,237.91 123.33,238.43 123.33,238.99 130.99,246.66 130.99,248.25 137.89,255.14 140.98,255.14 142.16,256.31 142.16,256.99 143.87,258.7 145.51,258.7 146.15,259.34 148.85,259.34 150.11,260.61 153.29,260.61 153.92,261.24 v1(153.92,261.62) ; v1(115.44,88.39) 115.44,87.91 120.3,83.05 120.3,79.71 122.65,77.36 122.65,72.29 119.75,69.39 119.75,62.18 125.22,56.71 125.22,54.88 125.73,54.38 125.73,52.83 124.63,51.74 124.63,35.52 J6J1.8
  BOTTOM w0.1: v1(153.92,261.62) 154.43,261.11 R5L25.1
ALL_SYS_PWRGD: length 249.3
  TOP w0.1: v1(13.08,203.96) 16.1,203.96 16.51,203.55 20.42,203.55 21.84,204.98 21.84,206.9 22.2,207.26 27.3,207.26 28.32,208.28 31.75,208.28 32.94,209.47 36.3,209.47 36.83,208.95 R8C37.2 37.97,208.28 39.24,209.55 40.25,209.55 41.09,208.71 43.89,208.71 R8C39.2 R8C40.1 ; v1(71.12,66.04) 71.12,65.78 71.62,65.28 71.62,64.73 R7H8.1
  LAY5 w0.125: v1(13.08,203.96) 12.82,203.71 12.82,188.72 12.29,188.19 12.29,182.62 11.93,182.27 11.93,163.83 12.95,162.81 12.95,153.92 13.73,153.14 13.73,150.1 19.3,144.53 19.3,135.26 19.93,134.62 19.93,131.75 21.89,129.8 21.89,122.47 20.7,121.28 20.7,114.3 19.79,113.4 19.79,112 20.83,110.96 20.83,109.47 19.81,108.45 19.81,102.74 20.06,102.49 20.57,102.49 21.54,101.52 21.54,94.9 20.75,94.11 20.75,91.31 20.11,90.67 20.11,84.75 21.21,83.66 21.21,81.26 19.94,79.99 19.94,70.89 20.45,70.38 20.45,62.5 22.75,60.2 25.41,60.2 28.46,57.15 41.76,57.15 47.88,63.27 48.53,63.27 49.27,64.01 49.83,64.01 50.33,63.51 51.85,63.51 52.54,62.82 59.14,62.82 61.73,65.41 67.3,65.41 67.94,64.77 68.45,64.77 69.08,65.4 70.48,65.4 v1(71.12,66.04)
AMP_PD_N_HDR: length 20.3
  TOP w0.1: 35.94,257.24 35.94,256.28 35.43,255.78 32.76,255.78 32.13,256.41 Q8B1.3 31.68,257.68 29.08,257.68 28.95,257.81 CR8A1.2 25.67,260.45 R8A31.2 R8A32.2 22.86,259.97 J9A5.10
AN_RCAL: length 6.9
  TOP w0.1: R7A6.2 88.36,265.4 88.36,264.06 88.95,263.47 90.08,263.47 90.26,263.65 91.31,263.65 91.58,263.38 EU7A3.42
AN_RESREF: length 3.9
  TOP w0.1: EU7A3.20 98.42,259.49 98.71,259.21 100.07,259.21 100.33,259.46 100.71,259.46 R6B1.2
ATX_DETECT_N: length 212.9
  TOP w0.1: J6J2.56 119.2,8.84 v1(118.99,8.63) ; R9F25.1 16.07,105.08 v1(16.07,104.77) 16.07,104.5 17.09,103.49 U8F6.36
  LAY3 w0.1: v1(118.99,8.63) 118.87,8.51 111.98,8.51 108.17,12.32 106.93,12.32 106.55,12.7 106.55,12.94 106.16,13.33 105.62,13.33 104.64,12.36 101.62,12.36 99.42,10.16 81.66,10.16 80.89,10.92 69.85,10.92 68.79,11.98 41.95,11.98 41.57,12.36 24.08,12.36 22.47,13.97 22.07,13.97 18.56,17.47 14.96,17.47 13,19.43 13,24.69 12.52,25.17 12.52,36.09 10.59,38.02 10.59,48.56 8.61,50.54 8.61,70.2 9.52,71.12 9.52,73.28 10.32,74.07 10.32,76.93 9.39,77.85 9.39,80.39 10.21,81.2 10.21,91.13 12.62,93.55 13.64,93.55 16.1,96.01 16.89,96.01 17.14,96.26 17.14,103.71 v1(16.07,104.77)
AU1_VR_READY: length 3.7
  TOP w0.2: R2C6.2 280.16,226.44 281.14,227.42 EU1B1.36
AU_D0LL: length 2
  TOP w0.2: R1B44.1 287.26,229.61 EU1B1.46
AU_DBLR: length 2.3
  TOP w0.2: EU1B1.51 286.09,231.61 286.89,232.41 R1B39.2
AU_DRVEN_L: length 2.1
  TOP w0.2: EU1B1.47 286.65,230.01 287.02,230.38 R1B43.2
AUDIO_AGND: length 22.8
  TOP w0.2: EU6A1.37 v1(121.07,281.56) ; v1(127.88,278.89) 127.83,278.84 EU6A1.19
  TOP w0.38: C5A8.2 v1(156.08,280.54) ; C6A16.2 117.34,279.53 v1(117.34,280.16) R6A30.2 ; C6A13.2 117.34,281.56 v1(117.34,282.19) C6A11.1 ; R6A38.2 v1(117.09,274.57) ; R6A49.2 v1(117.09,273.05) ; C6A2.1 v1(120.01,287.53) ; C5A1.2 v1(162.17,288.54) ; C5A11.2 v1(149.35,280.03) ; C6A3.2 v1(118.11,284.22) ; v1(130.68,279.91) C6A15.1 129.92,279.4 130.17,279.14 C6A17.2 C6A20.2 129.92,277.37 C6A25.2 130.55,276.6 v1(130.68,276.73) ; C6A6.1 v1(128.52,284.35) ; C6A18.2 v1(117.34,278.13) 117.34,277.49 C6A21.2 ; C6A8.1 v1(117.34,283.08)
  BOTTOM w0.38: v1(121.07,281.56) 121.15,281.48 ISO6L1.1 ; v1(120.14,277.87) 120.39,277.62 ISO6L2.1
  vias: v1(117.22,289.69) v1(121.79,289.69) v1(125.73,289.69) v1(128.65,289.69) v1(155.7,285.11) v1(155.82,287.78)
BACKFEED_CUT_DSW_N: length 5.1
  TOP w0.1: Q8C3.3 29.14,214.82 29.33,214.63 30.6,214.63 31.11,214.12 R8C25.2 31.62,213.23 31.93,212.92 31.93,212.6
BACKFEED_CUT_DSW_N_S0IDLE: length 522.3
  TOP w0.1: R7B5.1 v1(60.96,256.41) ; R4H11.1 175,57.28 174.49,56.77 173.1,56.77 172.59,56.26 v1(172.59,55.37) ; 31.93,211.92 31.28,211.92 30.86,212.34 30.86,213.87 30.48,214.25 28.82,214.25 v1(28.7,214.37) ; R4G9.1 v1(189.73,92.2) ; R8D20.1 43.3,188.47 42.79,187.96 42.79,187.52 42.38,187.1 41.62,187.1 41.27,187.45 39.75,187.45 39.62,187.32 30.58,187.32 30.09,187.8 v1(29.71,187.8) 29.23,187.8 28.85,188.19 26.32,188.19 25.94,187.8 22.7,187.8 21.88,188.62 15.72,188.62 15.11,189.23 12.19,189.23 v1(11.93,188.97)
  LAY5 w0.125: 173.83,86.87 165.78,86.87 161.47,82.56 159.89,82.56 157.42,80.08 150.03,80.08 149.51,79.56 139.41,79.56 139.04,79.2 138.27,79.2 135.4,76.33 115.31,76.33 113.79,77.85 113.79,78.87 112.26,80.4 106.18,80.4 103.12,77.34 99.34,77.34 85.74,63.74 85.74,63.29 83.79,61.35 78.49,61.35 76.87,59.73 75.38,59.73 75.04,59.39 75.04,57.9 73.4,56.26 66.64,56.26 65.14,54.76 54.6,54.76 54.11,54.26 50.93,54.26 49.23,52.55 48.16,52.55 46.78,51.18 43.64,51.18 41.65,49.18 35.46,49.18 34.92,48.65 27.22,48.65 22.59,53.27 22.59,58.22 18.67,62.14 18.67,67.21 18.01,67.87 18.01,69.88 17.64,70.25 17.64,80.93 18.14,81.43 18.14,85.63 17.3,86.47 17.3,88.72 18.54,89.96 18.54,102.47 18.06,102.94 18.06,105.78 18.67,106.38 18.67,108.58 18.13,109.12 18.13,120.15 19.76,121.77 19.76,130.42 17.65,132.53 17.65,144.01 12.97,148.69 12.97,152.7 11.68,154 11.68,176.02 10.27,177.43 10.27,187.31 v1(11.93,188.97) ; 173.83,86.87 178.41,91.44 181.33,91.44 182.85,92.96 188.97,92.96 v1(189.73,92.2) ; 173.83,86.87 v1(173.86,86.87) ; v1(35.56,259.71) 35.56,259.59 38.11,257.03 52.91,257.03 53.53,256.41 v1(60.96,256.41)
  LAY6 w0.125: v1(35.56,259.71) 32.58,256.74 32.58,255.32 31.75,254.48 31.75,251.45 31.25,250.95 31.25,249.99 30.11,248.85 30.11,245.76 29.1,244.75 29.1,242.63 26.08,239.61 26.08,237.28 25.52,236.72 25.52,234.87 24.62,233.97 24.62,229.71 26.96,227.37 26.96,222.92 27.56,222.32 27.56,216 28.7,214.86 v1(28.7,214.37) 28.67,214.35 28.67,206.91 29.59,205.99 29.59,204.09 30.86,202.82 30.86,194.56 29.71,193.42 v1(29.71,187.8)
  BOTTOM w0.1: v1(172.59,55.37) 172.59,57.15 173.06,57.62 173.06,59.53 172.72,59.88 172.72,70.86 175,73.15 175,80.3 175.6,80.9 175.6,85.12 v1(173.86,86.87)
BACKFEED_CUT_N: length 470
  TOP w0.1: v1(9.9,205.23) 10.87,206.2 13.59,206.2 14.21,206.82 17.59,206.82 18.16,207.39 20.22,207.39 23.52,210.69 R8C34.2 R8C33.1 26.03,212.34 29.01,212.34 29.14,212.22 Q8C4.3 ; U8D11.3 35.75,170.37 35.94,170.18 35.94,167.77 35.59,167.42 29.72,167.42 29.18,167.95 28.09,167.95 26.12,169.93 20.35,169.93 19.72,169.29 18.79,169.29 16.63,171.45 11.15,171.45 v1(9.9,172.69) ; v1(173.48,57.28) 173.73,57.53 173.73,58.67 R4H3.1 ; v1(151.63,9.02) 151.63,8.51 150.56,7.45 148.75,7.45 148.33,7.87 145.79,7.87 R5J13.2
  LAY5 w0.125: v1(9.9,205.23) 8.89,204.21 8.89,173.71 v1(9.9,172.69) 10.03,172.57 10.03,152.43 9.77,152.17 9.77,139.42 11.4,137.79 11.4,133.39 10.76,132.74 10.76,121.19 13.56,118.39 13.56,107.69 14.47,106.78 14.47,104.37 15.11,103.73 15.11,102.36 15.9,101.57 15.9,100.86 15.23,100.2 15.23,91.84 14.47,91.07 14.47,85.9 15.36,85.01 15.36,82.29 14.59,81.53 14.59,71.03 14.97,70.65 14.97,61.24 13.33,59.6 13.33,46.46 14.83,44.95 19.3,44.95 19.93,45.59 21.97,45.59 24.51,43.05 28.4,43.05 29.71,41.74 35.88,41.74 36.97,40.65 40.52,40.65 41.02,41.15 45.16,41.15 45.46,41.45 46.33,41.45 47.15,40.63 53.53,40.63 54.35,41.45 60.39,41.45 61.23,42.29 71.19,42.29 72.04,41.44 75.04,41.44 75.89,42.29 76.57,42.29 76.95,41.91 83.22,41.91 83.91,42.6 88.29,42.6 93.31,47.62 95.25,47.62 95.92,48.29 103.66,48.29 104.68,47.26 112.94,47.26 113.79,48.11 113.79,48.62 114.79,49.61 118.68,49.61 121.56,46.74 123.45,46.74 124.17,46.01 128.27,46.01 128.82,45.46 140.54,45.46 142.03,46.95 145.71,46.95 149.06,50.3 163.65,50.3 168.73,55.37 171.06,55.37 172.97,57.28 v1(173.48,57.28)
  LAY6 w0.125: v1(173.48,57.28) 173.48,57.02 168.78,52.32 160.93,52.32 159.38,50.78 159.38,20.55 153.98,15.15 153.98,12.19 151.63,9.84 v1(151.63,9.02)
BACKFEED_CUT_N_EC: length 3.5
  TOP w0.1: J6J2.223 145.28,12.06 145.28,10.29 145.03,10.03 R5J13.1
BACKFEED_CUT_N_S0IDLE: length 494.6
  TOP w0.1: R5C45.2 v1(151.38,201.67) ; v1(174.24,57.28) 174.24,58.04 R4H6.2 ; R4G6.1 v1(189.73,93.22) ; v1(36.32,171.7) 36.1,171.49 U8D11.4 ; R8D19.1 v1(42.29,187.7)
  LAY5 w0.125: v1(48.38,53.08) 49.4,53.08 50.83,54.51 54,54.51 54.5,55.01 65.03,55.01 66.54,56.51 73.3,56.51 74.79,58.01 74.79,59.5 75.28,59.98 76.77,59.98 78.38,61.6 83.69,61.6 85.48,63.39 85.48,63.84 99.24,77.59 103.01,77.59 106.07,80.65 112.36,80.65 114.04,78.97 114.04,77.95 115.16,76.83 v1(135.22,76.83) 135.25,76.83 137.87,79.45 138.94,79.45 139.3,79.81 149.41,79.81 149.92,80.33 157.31,80.33 159.79,82.81 161.36,82.81 165.68,87.12 172.97,87.12 v1(174.62,88.77) 175.38,88.77 178.3,91.69 181.22,91.69 182.75,93.22 v1(189.73,93.22)
  LAY6 w0.125: v1(151.38,201.67) 151.38,199.13 150.13,197.89 150.13,191.36 150.62,190.88 150.74,190.88 151,190.63 151,188.34 150.24,187.58 150.24,167.64 148.97,166.37 148.97,164.97 147.98,163.98 147.98,156.88 148.21,156.65 148.21,154.19 147.98,153.96 147.98,150.67 142.11,144.8 142.11,139.56 140.63,138.09 140.63,136 135.51,130.87 135.51,124.22 131.4,120.12 131.4,118.57 126.82,113.99 126.82,98.67 130.63,94.86 130.63,84.03 135.25,79.41 135.25,76.86 v1(135.22,76.83) ; v1(42.29,187.7) 42.29,187.48 43.07,186.7 43.07,184.59 43.56,184.09 43.56,180.03 44.45,179.14 44.45,173.28 v1(44.72,173) 44.57,172.85 44.57,169.54 45.24,168.87 45.24,160.83 43.05,158.63 43.05,153.42 44.47,152 44.47,150.11 45.75,148.83 45.75,146.41 44.91,145.58 44.91,131.48 45.63,130.77 45.63,127.16 44.61,126.15 44.61,112.22 45.39,111.44 45.39,102.06 44.57,101.25 44.57,100.96 43.49,99.88 43.49,92.26 43.11,91.88 43.11,82.08 43.94,81.25 43.94,76.5 45.46,74.98 45.46,71 48.1,68.35 48.1,67.21 47.65,66.75 47.65,65.76 47.12,65.23 47.12,62.91 47.87,62.15 47.87,59.82 48.38,59.31 v1(48.38,53.08)
  BOTTOM w0.1: v1(44.72,173) 44.16,173 43.43,173.73 39.01,173.73 37.97,172.69 37.97,172.21 37.46,171.7 v1(36.32,171.7) ; v1(174.62,88.77) 175.83,87.56 175.83,82.45 176.53,81.75 176.53,79.25 175.27,77.99 175.27,73.04 172.97,70.74 172.97,59.94 174.24,58.67 v1(174.24,57.28)
