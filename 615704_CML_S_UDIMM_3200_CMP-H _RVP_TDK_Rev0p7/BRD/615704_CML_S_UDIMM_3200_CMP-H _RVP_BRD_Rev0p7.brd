# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Library data of the parts (continued)
R7E25 R7E32 R7R9 R7R23 R7R38 R7R40 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; room: LPSS
R7E28 R7E48 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 36
R7E40 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 92
R7E61 R9G40 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: ICH
R7F2 = RES: alternate symbols: (); part number: RES_0402-A93549-036,EMPTY,20K,5%,1/16W,LPDB,GENERIC; room: EC
R7F6 R7R3 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 157
R7F8 R7R2 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 157
R7F11 = RES: alternate symbols: (); part number: RES_0603-A93551-141,CHIP,10M,5%,1/10W,LPDB,GENERIC; room: ICH
R7F13 = RES: alternate symbols: (); part number: RES_0402-A93549-027,EMPTY,100K,5%,1/16W,LPDB,GENERIC; room: 157
R7F17 R7F18 = RES: alternate symbols: (); part number: RES_0402-A93549-005,EMPTY,33,5%,1/16W,LPDB,GENERIC; room: 94
R7F20 = RES: alternate symbols: (); part number: RES_0402-A93549-005,EMPTY,33,5%,1/16W,LPDB,GENERIC
R7F21 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; room: 94
R7F23 R7R62 = RES: alternate symbols: (); part number: RES_0402-A93548-133,CHIP,30.1K,1%,1/16W,LPDB,GENERIC; room: ICH
R7F25 R7T8 R7T9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 41
R7F30 = RES: alternate symbols: (); part number: RES_0402-A93548-511,CHIP,470,1%,1/16W,LPDB,GENERIC; room: ICH
R7F31 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 44
R7F37 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 38
R7F38 R7F39 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: 44
R7F40 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 41
R7F43 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: ICH
R7G3 R8G37 = RES: alternate symbols: (); part number: RES_1206-A93552-001,EMPTY,0,5%,1/4W,LPDB,GENERIC
R7G8 R7G11 R7G16 R7G19 R7G20 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; room: LAN; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R7G9 R7G13 R7G17 R7G21 R7G24 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: 120
R7G10 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: LPSS; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R7G12 R7G33 R7H16 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: 120
R7G14 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 118
R7G23 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 119
R7G34 R7H14 R7H17 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 120
R7G35 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 120
R7H2 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: 120
R7H19 = RES: alternate symbols: (); part number: RES_0402-A93549-036,EMPTY,20K,5%,1/16W,LPDB,GENERIC; room: 120
R7H20 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 120
R7H21 R7H22 R7H30 R7H41 R7H46 R8G60 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: LPSS
R7H27 R7H34 R7H38 R7H44 R8D49 R8D63 R9H6 R9H8 R9H11 R9H14 R9J15 = RES: alternate symbols: (); part number: RES_0402-A93548-126,CHIP,49.9K,1%,1/16W,LPDB,GENERIC
R7H67 R8F55 R8H32 = RES: alternate symbols: (); part number: RES_0402-A93549-012,CHIP,330,5%,1/16W,LPDB,GENERIC; room: EV
R7H69 R8H57-R8H61 R8H63 = RES: alternate symbols: (); part number: RES_0402-A93549-011,CHIP,220,5%,1/16W,LPDB,GENERIC; room: EV
R7H72 R8H71 = RES: alternate symbols: (); part number: RES_1206-A93552-001,CHIP,0,5%,1/4W,LPDB,GENERIC; room: 203
R7J1 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC; room: 195
R7J2-R7J5 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC; room: SIO_PS2KEYMOUSE
R7J6-R7J9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: SIO_PS2KEYMOUSE
R7J10 R8J3 R8J4 R8J6 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 204
R7J11 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC; room: 204
R7J12 R7J14 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 204
R7J13 R7J15 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 204
R7L1 R8E45 R9E29-R9E31 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 128
R7P10 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-E58715-001,CHIP,0.005,1%,1/8W,LPDB,GENERIC; room: 157
R7R4 R7R6 = RES: alternate symbols: (); part number: RES_0402-A93548-060,CHIP,200,1%,1/16W,LPDB,GENERIC; room: 43
R7R14 = RES: alternate symbols: (); part number: RES_0402-A93548-220,CHIP,150K,1%,1/16W,LPDB,GENERIC; room: 113
R7R15 R7R22 = RES: alternate symbols: (); part number: RES_0402-A93549-005,EMPTY,33,5%,1/16W,LPDB,GENERIC; room: LPSS
R7R20 R7R24 R7R35 = RES: alternate symbols: (); part number: RES_0402-A93548-126,CHIP,49.9K,1%,1/16W,LPDB,GENERIC; room: 113
R7R60 = RES: alternate symbols: (); part number: RES_0402-A93549-028,CHIP,1M,5%,1/16W,LPDB,GENERIC; room: ICH
R7T6 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 131
R7T27 = RES: alternate symbols: (); part number: RES_0402-A93549-011,CHIP,220,5%,1/16W,LPDB,GENERIC; room: 34
R7U2 R7U6-R7U8 R7U11 R7U14 R7U18 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: ICH; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R7U10 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: ICH; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R7U30 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 118
R7U31 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 118
R7U32 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 118
R7U33-R7U35 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: LAN
R8A1 R8A17 = RES: alternate symbols: (); part number: RES_0402-A93549-096,CHIP,820,5%,1/16W,LPDB,GENERIC
R8A2 R8A6 R8A16 R8A20 R8E13 R8E16 = RES: alternate symbols: (); part number: RES_0402-G64084-076,CHIP,1.2K,1%,1/16W,LPDB,GENERIC
R8A3 R8A7 R8A15 R8A19 = RES: alternate symbols: (); part number: RES_0402-G64084-084,CHIP,2.7K,1%,1/16W,LPDB,GENERIC
R8A22 R8A23 = RES: alternate symbols: (); part number: RES_0402-A93548-014,CHIP,1.5K,1%,1/16W,LPDB,GENERIC
R8A24 R8A26 R8B8 R8B23 R9A21 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 109
R8A25 R8B9 R9B2 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 109
R8A27 R9A24 R9B1 R9B5 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 109
R8A28 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 141
R8A29 R8A30 R9B4 R9B8 R9B10 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 109
R8A32 R8B1 R8B2 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 110
R8B3 R8B17 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 104
R8B4 R8B16 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 104
R8B6 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; room: 109
R8B11 R8B13 = RES: alternate symbols: (); part number: RES_0402-A93549-003,EMPTY,22,5%,1/16W,LPDB,GENERIC; room: 104
R8B35 R8B37 R8C3 R8C6 R8C14 R8C17 R8C21 R8C23 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 100
R8B36 R8B38 R8C4 R8C7 R8C15 R8C22 R8C24 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 101
R8C5 R8D26 R8D35 R8D37 R8D61 R8D76 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 177
R8C8 R8C11 R9C18 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 102
R8C13 = RES: alternate symbols: (); part number: RES_0402-A93548-224,EMPTY,45.3K,1%,1/16W,LPDB,GENERIC; room: 160
R8C16 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 160
R8C19 R8C20 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 102
R8C25 R8C34 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: 181
R8C28 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 100
R8C29 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 101
R8C32 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: LAN
R8C35 R8D3 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 181
R8C36 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 181
R8C37 R8C44 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 180
R8C38 = RES: alternate symbols: (); part number: RES_0402-A93548-639,CHIP,22K,1%,1/16W,LPDB,GENERIC; room: 180
R8C39-R8C41 R8C46 R8C56 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 180
R8C42 R8C61 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 180
R8C45 R8C55 R9E26 R9F27 R9F30 = RES: alternate symbols: (); part number: RES_0402-A93549-036,CHIP,20K,5%,1/16W,LPDB,GENERIC; room: CORE_PCSPKR
R8C47 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,EMPTY,100,1%,1/16W,LPDB,GENERIC; room: 180
R8C50 R8C57 R8C67 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 180
R8C52 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: 181
R8C53 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: AUDIO
R8C54 R8C76 = RES: alternate symbols: (); part number: RES_0402-A93548-128,EMPTY,100K,1%,1/16W,LPDB,GENERIC; room: 181
R8C59 R8C63 R8C65 R8C79 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 183
R8C62 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 183
R8C64 = RES: alternate symbols: (); part number: RES_0402-A93548-476,CHIP,47K,1%,1/16W,LPDB,GENERIC; room: 180
R8C66 R8C68 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 183
R8C75 R8C82 R8D2 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: 183
R8C78 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 176
R8D1 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 183
R8D4 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 181
R8D5 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 182
R8D6 = RES: alternate symbols: (); part number: RES_0402-A93549-019,CHIP,3.3K,5%,1/16W,LPDB,GENERIC; room: 182
R8D7 = RES: alternate symbols: (); part number: RES_0402-A93549-027,EMPTY,100K,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_100000OHM_2_1; room: 176
R8D8 = RES: alternate symbols: (); part number: RES_0402-A93548-048,CHIP,249,1%,1/16W,LPDB,GENERIC; room: 177
R8D9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 176
R8D10 = RES: alternate symbols: (); part number: RES_0402-A93548-186,EMPTY,200K,1%,1/16W,LPDB,GENERIC; room: 179
R8D13 = RES: alternate symbols: (); part number: RES_0402-A93548-044,CHIP,3.32K,1%,1/16W,LPDB,GENERIC; room: 179
R8D15 = RES: alternate symbols: (); part number: RES_0402-A93548-121,CHIP,3.92K,1%,1/16W,LPDB,GENERIC; room: 181
R8D17 = RES: alternate symbols: (); part number: RES_0402-A93548-518,CHIP,8.2K,1%,1/16W,LPDB,GENERIC; room: 179
R8D19 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: VREG
R8D20 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: 182
R8D21 R8D31 R8D42 R8D43 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 177
R8D23 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: 177
R8D24 R8D27 = RES: alternate symbols: (); part number: RES_0402-A93549-028,EMPTY,1M,5%,1/16W,LPDB,GENERIC; room: 177
R8D25 = RES: alternate symbols: (); part number: RES_0402-A93548-163,CHIP,2.43K,1%,1/16W,LPDB,GENERIC; room: 177
R8D28-R8D30 R8D34 R8D66 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 177
R8D32 = RES: alternate symbols: (); part number: RES_0402-A93548-476,CHIP,47K,1%,1/16W,LPDB,GENERIC; room: 177
R8D33 = RES: alternate symbols: (); part number: RES_0402-A93548-639,CHIP,22K,1%,1/16W,LPDB,GENERIC; room: 177
R8D36 R8D45 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: 177
R8D38 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 177
R8D39 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: 177
R8D46 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 177
R8D60 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: VREG
R8D88 = RES: alternate symbols: (); part number: RES_0402-G21796-063,CHIP,31.6K,1%,1/16W,LPDB,GENERIC; room: 178
R8D89 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 178
R8E2 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-G21796-041,CHIP,22.1K,1%,1/16W,LPDB,GENERIC; room: 178
R8E3 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 178
R8E6 R8E22 R8E41 R8E63 R8F10 R8F46 R8G15 = RES: alternate symbols: (); part number: RES_0402-G64084-116,CHIP,51K,1%,1/16W,LPDB,GENERIC
R8E7 R8E42 R8F11 R8G18 = RES: alternate symbols: (); part number: RES_0402-A93548-507,CHIP,232K,1%,1/16W,LPDB,GENERIC
R8E18 R8E21 R8E25 R8E32 R9E3 R9E4 R9E7 R9E9 R9E13 R9E15 R9E18 R9E20 R9E22 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 123
R8E19 R8E20 R8E24 R8E36 R9E2 R9E5 R9E8 R9E10 R9E12 R9E16 R9E17 R9E21 R9E23 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 123
R8E23 R8F41 = RES: alternate symbols: (); part number: RES_0402-A93548-334,CHIP,102K,1%,1/16W,LPDB,GENERIC
R8E56 = RES: alternate symbols: (); part number: RES_0402-A93549-008,CHIP,75,5%,1/16W,LPDB,GENERIC; room: 125
R8E64 = RES: alternate symbols: (); part number: RES_0402-G64084-112,CHIP,39K,1%,1/16W,LPDB,GENERIC
R8F6 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 33
R8F21 R8F30 R8F51 R9F9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 127
R8F23 R9F12 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 126
R8F25 R9G15 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 127
R8F26 R9F35 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 124
R8F28 R9E6 R9E28 R9F25 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 125
R8F31 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 125
R8F36 R8F52 R9F15 R9F32 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 124
R8F40 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 125
R8F42 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 126
R8F43 R8F45 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 126
R8F44 = RES: alternate symbols: (); part number: RES_0402-A93548-132,CHIP,15K,1%,1/16W,LPDB,GENERIC
R8F50 R8G17 R9F34 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 126
R8F53 R8G25 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 126
R8G5 = RES: alternate symbols: (); part number: RES_0402-A93548-212,CHIP,22.6K,1%,1/16W,LPDB,GENERIC; room: 124
R8G6 = RES: alternate symbols: (); part number: RES_0402-A93548-212,CHIP,22.6K,1%,1/16W,LPDB,GENERIC
R8G7 RT8G1 = THERM_NTC: alternate symbols: (); part number: THERM_NTC_0402-C98257-004,IC,47KOHM,1%,NULL,LPDB,GENERIC
R8G10 R8G14 R8G22 R8G23 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: 127
R8G20 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: OTG_CONNECTOR
R8G24 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; room: 124
R8G26 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 126
R8G46 R8G47 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC; room: PCH
R8G52 = RES: alternate symbols: (); part number: RES_0402-A93548-518,CHIP,8.2K,1%,1/16W,LPDB,GENERIC; room: SB_TERMINATION
R8G61 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 121
R8G79 R8H7 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 93
R8G81 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 98
R8G82 R8H14 R8H15 R8H17 R8H18 R8H20 R8H21 R8H23 R8H24 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 93
R8G86 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 93
R8G87 = RES: alternate symbols: (); part number: RES_0603-A93550-039,EMPTY,249,1%,1/10W,LPDB,GENERIC
R8H6 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC; room: 93
R8H8 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 94
R8H33 R8H41 R9H7 R9H10 = RES: alternate symbols: (); part number: RES_0402-A93548-518,CHIP,8.2K,1%,1/16W,LPDB,GENERIC; room: ICH
R8H36 R8H48 = RES: alternate symbols: (); part number: RES_0402-A93549-012,CHIP,330,5%,1/16W,LPDB,GENERIC; room: ICH
R8H37 = RES: alternate symbols: (); part number: RES_0402-A93548-045,CHIP,49.9,1%,1/16W,LPDB,GENERIC; room: ICH
R8H39 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 95
R8H62 = RES: alternate symbols: (); part number: RES_0402-A93548-005,CHIP,150,1%,1/16W,LPDB,GENERIC; room: 202
R8H65 R8H66 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 96
R8H67 R8H68 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 91
R8H69 R8H70 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 96
R8H72 R8H74 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: SIO_STDFNTPNL
R8H75 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 46
R8J1 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 203
R8J2 R8J5 R8J7 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 204
R8J8 R8J10 R8J15 R8J17 = RES: alternate symbols: (); part number: RES_0402-A93548-094,CHIP,499,1%,1/16W,LPDB,GENERIC; room: ICH
R8J9 = RES: alternate symbols: (); part number: RES_0402-A93549-016,CHIP,1K,5%,1/16W,LPDB,GENERIC; room: 201
R8J11 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 196
R8J19 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 196
R8J20 R8J24 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 201
R8J22 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: 45
R8J23 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 201
R8L1 = RES: alternate symbols: (); part number: RES_0603-D71825-003,CHIP,0.01,0.5%,1/10W,LPDB,GENERIC; room: 122
R8L2 R8L4 R8L6 R8L7 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 122
R8L3 = RES: alternate symbols: (); part number: RES_0603-D71825-003,EMPTY,0.01,0.5%,1/10W,LPDB,GENERIC; room: 122
R8L5 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC; room: 128
R8R3 R8R6 R8R7 R8R10 = RES: alternate symbols: (); part number: RES_0402-A93548-126,CHIP,49.9K,1%,1/16W,LPDB,GENERIC; room: 129
R9A13 = RES: alternate symbols: (); part number: RES_0402-A93549-005,EMPTY,33,5%,1/16W,LPDB,GENERIC; room: 103
R9B16 R9B18 R9B22 R9B28 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 110
R9B17 R9B19 R9B23 R9B27 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 110
R9C1 = RES: alternate symbols: (); part number: RES_0402-A93549-011,CHIP,220,5%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R9C3 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R9C4 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: SENSE_SST
R9C8 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R9C9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R9C10 R9C11 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R9C12 R9C14 R9C15 R9C17 R9C22 = RES: alternate symbols: (); part number: RES_0402-A93548-126,EMPTY,49.9K,1%,1/16W,LPDB,GENERIC; room: 99
R9C13 = RES: alternate symbols: (); part number: RES_0402-A93548-126,CHIP,49.9K,1%,1/16W,LPDB,GENERIC; room: 99
R9C16 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 99
R9C19 R9C20 R9D2 R9D3 = RES: alternate symbols: (); part number: RES_0402-A93549-003,CHIP,22,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: 99
R9C21 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: 99
R9D1 = RES: alternate symbols: (); part number: RES_0402-A93549-003,CHIP,22,5%,1/16W,LPDB,GENERIC; room: 99
R9D4 R9D7 R9D19 R9D23 R9D25 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 140
R9D5 R9D6 R9D20 R9D28 R9D30 = RES: alternate symbols: (); part number: RES_0402-A93548-031,EMPTY,10,1%,1/16W,LPDB,GENERIC; room: 140
R9D9 R9D13 = RES: alternate symbols: (); part number: RES_0402-A93549-027,EMPTY,100K,5%,1/16W,LPDB,GENERIC; room: 140
R9D10 R9D14 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 140
R9D11 R9D15 R9D26 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 140
R9D21 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 140
R9D22 = RES: alternate symbols: (); part number: RES_0402-A93548-126,EMPTY,49.9K,1%,1/16W,LPDB,GENERIC; room: 140
R9D27 R9D29 = RES: alternate symbols: (); part number: RES_0402-A93548-126,EMPTY,49.9K,1%,1/16W,LPDB,GENERIC
R9D32 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 108
R9D33 R9D36 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 108
R9D35 = RES: alternate symbols: (); part number: RES_0402-A93548-186,CHIP,200K,1%,1/16W,LPDB,GENERIC; room: 108
R9E1 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: VREG_VBAT
R9E11 = RES: alternate symbols: (); part number: RES_0402-A93548-049,CHIP,301,1%,1/16W,LPDB,GENERIC; room: 102
R9E14 R9E24 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 125
R9E19 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 124
R9E25 = RES: alternate symbols: (); part number: RES_0603-D71825-003,CHIP,0.01,0.5%,1/10W,LPDB,GENERIC; room: 128
R9F8 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 124
R9F17 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 128
R9F19 R9F20 R9U1 R9U14 R9U16 R9U18 R9U20 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R9F23 R9F24 R9F28 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 130
R9F36 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: EC
R9G11 = RES: alternate symbols: (); part number: RES_0402-A93548-518,CHIP,8.2K,1%,1/16W,LPDB,GENERIC; room: 127
R9G26-R9G28 = RES: alternate symbols: (); part number: RES_0402-A93549-012,CHIP,330,5%,1/16W,LPDB,GENERIC; room: EC
R9G30 = RES: alternate symbols: (); part number: RES_0805-A93555-018,EMPTY,51,5%,1/8W,LPDB,GENERIC; room: 36
R9G33 = RES: alternate symbols: (); part number: RES_0402-A93549-011,CHIP,220,5%,1/16W,LPDB,GENERIC; room: VREG_PWR_CONN
R9G34 = RES: alternate symbols: (); part number: RES_0402-A93549-085,EMPTY,5.1K,5%,1/16W,LPDB,GENERIC; room: ICH
R9G35 R9G38 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 137
R9G36 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 137
R9G39 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 137
R9H1 R9H4 = RES: alternate symbols: (); part number: RES_0402-A93548-511,CHIP,470,1%,1/16W,LPDB,GENERIC; room: 138
R9H2 = RES: alternate symbols: (); part number: RES_0402-A93549-012,CHIP,330,5%,1/16W,LPDB,GENERIC; room: SIO_STDFNTPNL
R9H3 = RES: alternate symbols: (); part number: RES_0402-A93549-012,EMPTY,330,5%,1/16W,LPDB,GENERIC; room: SIO_STDFNTPNL
R9H5 R9H12 = RES: alternate symbols: (); part number: RES_0402-A93548-518,EMPTY,8.2K,1%,1/16W,LPDB,GENERIC; room: ICH
R9H9 R9J17 = RES: alternate symbols: (); part number: RES_0402-A93548-220,CHIP,150K,1%,1/16W,LPDB,GENERIC
R9H13 R9H15 R9H18 R9H19 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 131
R9H20 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: SIO_STDFNTPNL
R9J3 R9J5 R9J8 R9J11 = RES: alternate symbols: (); part number: RES_0402-A93548-126,CHIP,49.9K,1%,1/16W,LPDB,GENERIC; room: 114
R9J12 R9J13 R9J19 = RES: alternate symbols: (); part number: RES_0402-A93548-126,CHIP,49.9K,1%,1/16W,LPDB,GENERIC; room: 112
R9J14 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-G21796-387,CHIP,619,1%,1/16W,LPDB,GENERIC; room: 160
R9U2-R9U5 R9U8 R9U10 R9U11 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: 128
R9U6 R9U9 R9U12 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: 128
R9U7 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 128
RM8E1 = STANDOFF: alternate symbols: (M_2_MTG_7000P4320MA); part number: STANDOFF_TH-H18839-001,STANDOFF,STANDOFF,LPDB,GENERIC; room: 93
RM8F1 = STANDOFF: alternate symbols: (M_2_MTG_7000P4320MA); part number: STANDOFF_TH-H18839-001,EMPTY,STANDOFF,LPDB,GENERIC; room: 93
RT2A2 = FUSE: alternate symbols: (); part number: FUSE_SM-C94014-001,FUSE,1.1A,6V,LPDB,GENERIC; room: DP_HDMI_COMBO_CONNECTOR
RT5B1 = THERMISTOR: alternate symbols: (); part number: THERMISTOR_0402-D88615-001,CHIP,4.7K,1%,66MW,LPDB,GENERIC
RT7C1 = FUSE: alternate symbols: (); part number: FUSE_SM-C92281-001,IC,1.5A,6V,LPDB,GENERIC; room: USB_OUT
RT7J1 = FUSE: alternate symbols: (); part number: FUSE_SM-C92281-001,IC,1.5A,6V,LPDB,GENERIC; room: 195
SW5H1 = SW4_SPSTPB: alternate symbols: (); part number: SW4_SPSTPB_SM-672681-002,SWITCH,SW4_SPSTPB,LPDB,GENERIC; room: VREG_FP_RESET
SW5H2 = SW4_SPSTPB: alternate symbols: (); part number: SW4_SPSTPB_SM-672681-002,SWITCH,SW4_SPSTPB,LPDB,GENERIC; room: VREG_SWITCH_ON
SW7C1 SW8A1-SW8A4 = SW4_SPST: alternate symbols: (); part number: SW4_SPST_DIP8-G18324-001,IC,DHN_04F_T_V,LPDB,GENERIC
SW8F1 = SW_4P_TACT: alternate symbols: (); part number: SW_4P_TACT_SM-H17540-001,IC,EVPAA302K,LPDB,GENERIC
TP1A1 TP1J1 TP1L1 TP1W1 TP3B4 TP3M1 TP4J1 TP4W1 TP5E1 TP5H1 TP5T1 TP8A1 TP8L1 TP9A1 TP9J1 TP9J2 TP9L1 TP9W1 TP9W2 TP4811 = FIDUCIAL: alternate symbols: (); part number: FIDUCIAL_NA-NA,EMPTY,,,TK0,GENERIC
TP1C1 TP1D1 TP1D2 TP2B1-TP2B5 TP2C1 TP3B1-TP3B3 TP4B1 TP4B2 TP5J1-TP5J8 TP6J1-TP6J3 TP8D1 TP8D2 TP8J1 TP9F1-TP9F4 TP9G1 = TP: alternate symbols: (); part number: TP_SM-NA_TPS16,EMPTY,TPS16,LPDB,GENERIC
TP3L1-TP3L5 = TP: alternate symbols: (); part number: TP_SM-NA_TPC25,EMPTY,TP_C25,LPDB,GENERIC; room: LSPCON_CHIP
TP4L1 TP4L2 TP5L1 TP5L2 = TP: alternate symbols: (); part number: TP_SM-NA_TPC25,EMPTY,TP_C25,LPDB,GENERIC
TP6D1 TP6D2 TP6T1 TP7G1 TP8G1 = TP: alternate symbols: (); part number: TP_SM-NA_TPC29P14,EMPTY,TP_C25,LPDB,GENERIC
TP6T2 = TP: alternate symbols: (); part number: TP_SM-NA_TPC29P14,EMPTY,TP_C25,LPDB,GENERIC; room: 43
TP6T3 = TP: alternate symbols: (); part number: TP_SM-NA_TPC29P14,EMPTY,TP_C25,LPDB,GENERIC; room: 33
TP7E1 = TP: alternate symbols: (); part number: TP_SM-NA_TPC29P14,EMPTY,TP_C25,LPDB,GENERIC; room: 42
TP7F1 TP7R1 TP7R2 TP8J2 = TP: alternate symbols: (); part number: TP_SM-NA_TPS16,EMPTY,TPS16,LPDB,GENERIC; room: 159
U1B1 = LM2665: alternate symbols: (); part number: LM2665_SM-H67481-001,IC,LM2665,LPDB,GENERIC
U1B2 = TTL07: alternate symbols: (); part number: TTL07_SM-G58837-001,IC,74AUP1G07GW,LPDB,GENERIC; room: 169
U1E1-U1E3 U3H2 U4H1 U4H2 = PAC1934T: alternate symbols: (); part number: PAC1934T_BGA-J55617-001,IC,PAC1934T-I/J6CX,LPDB,GENERIC
U2A1-U2A4 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM3-J16541-001,CHOKE,90OHM,NA,100MA,LPDB,GENERIC; room: 58
U2B1 = W25Q80DVSNIG: alternate symbols: (); part number: W25Q80DVSNIG_SOIC-H55682-001,IC,W25Q80DVSNIG,LPDB,GENERIC; room: LSPCON_CHIP
U2G1 = MOSFET_N_DUAL_2G3D3S: alternate symbols: (); part number: MOSFET_N_DUAL_2G3D3S_SM-H32492-001,IC,MOSFET_N_DUAL_2G3D3S,LPDB,GENERIC
U2G2 = SLG7NT4375: alternate symbols: (); part number: SLG7NT4375_LCC-H42738-001,IC,SLG7NT4375VTR,LPDB,GENERIC
U2G3 = UP1804AMA8: alternate symbols: (); part number: UP1804AMA8_SOT-G81335-001,IC,UP1804AMA8,LPDB,GENERIC
U3A4 U7B2 U7B3 U8G1 = TTL1G08: alternate symbols: (); part number: TTL1G08_SM-C78568-001,IC,74AHC1G08,LPDB,GENERIC
U3A5 = MCDP2800_BC: alternate symbols: (); part number: MCDP2800_BC_BGA-H73149-002,IC,MCDP2800-BC,LPDB,GENERIC
U3A6 U3A7 = PUSB3FR4Z: alternate symbols: (); part number: PUSB3FR4Z_DFN-H89865-001,IC,PUSB3FR4Z,LPDB,GENERIC; room: 81
U3H1 = PAC1934T: alternate symbols: (); part number: PAC1934T_BGA-J55617-001,IC,PAC1934T-I/J6CX,LPDB,GENERIC; room: 217
U4A1 = PUSB3FR4Z: alternate symbols: (); part number: PUSB3FR4Z_DFN-H89865-001,IC,PUSB3FR4Z,LPDB,GENERIC; room: 78
U4A2 U6D1 U6D7 = PUSB3FR4Z: alternate symbols: (); part number: PUSB3FR4Z_DFN-H89865-001,IC,PUSB3FR4Z,LPDB,GENERIC
U4C1 = SLG5NT1533V: alternate symbols: (); part number: SLG5NT1533V_STDFN-H27492-001,IC,SLG5NT1533V,LPDB,GENERIC
U4C2 U4C3 = SLG5NT1477V: alternate symbols: (); part number: SLG5NT1477V_SM-G95811-001,IC,SLG5NT1477VTR,LPDB,GENERIC
U5A2 = TITAN_RIDGE_DD_VIEW3_2: alternate symbols: (); part number: TITAN_RIDGE_DD_VIEW3_2_BGA-J86430-003,IC,TITAN_RIDGE_DD_VIEW3,1.1,TK0,IP; room: NONE
U5B1 = W25Q80DVSNIG: alternate symbols: (); part number: W25Q80DVSNIG_SOIC-H55682-001,IC,W25Q80DVSNIG,LPDB,GENERIC; room: 192
U5C1 = TTL1G08: alternate symbols: (); part number: TTL1G08_SM-C78568-001,IC,74AHC1G08,LPDB,GENERIC; room: 51
U5C2 U8C1 U8C3 U8D8-U8D11 U8N1 = SN74AUP1G97: alternate symbols: (); part number: SN74AUP1G97_SON-G84640-001,TTL,SN74AUP1G97,LPDB,GENERIC; room: DIGITAL_SPEAKER_HEADERS
U5D1 U7G5 U8D5 = TTL1G32GF: alternate symbols: (); part number: TTL1G32GF_XSON6-G59945-001,IC,74AUP1G32GF,LPDB,GENERIC
U5E1 = TTL1G08_SM-E67345-001,GATE,TTL1G08,LPDB,GENERIC
U5G2 = TTL1G08: alternate symbols: (); part number: TTL1G08_SM-C78568-001,EMPTY,74AHC1G08,LPDB,GENERIC
U6A4 = LM397: alternate symbols: (); part number: LM397_SM-E25618-001,IC,LM397,LPDB,GENERIC
U6B1 = W25Q16: alternate symbols: (); part number: W25Q16_SOIC-J45555-001,IC,W25Q16JVSSIQ,LPDB,GENERIC
U6B2 = W25Q64FV: alternate symbols: (); part number: W25Q64FV_SOIC-D72836-001,EMPTY,W25Q64FV,LPDB,GENERIC
U6C1 = PUSB3FR4Z: alternate symbols: (); part number: PUSB3FR4Z_DFN-H89865-001,IC,PUSB3FR4Z,LPDB,GENERIC; room: 87
U6D2 = PUSB3FR4Z: alternate symbols: (); part number: PUSB3FR4Z_DFN-H89865-001,IC,PUSB3FR4Z,LPDB,GENERIC; room: 85
U6D3 = PUSB3FR4Z: alternate symbols: (); part number: PUSB3FR4Z_DFN-H89865-001,IC,PUSB3FR4Z,LPDB,GENERIC; room: 83
U6D4 U6D5 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM3-J16541-001,CHOKE,90OHM,NA,100MA,LPDB,GENERIC; room: 83
U6E1 = CML_PCH_H_IP_EXT: alternate symbols: (); part number: CML_PCH_H_IP_EXT_BGA-TBD_45673,PCH,CML_PCH_H_IP_EXT,1.0,LPDB,GENERIC
U6J1 = SLG5NT1458V: alternate symbols: (); part number: SLG5NT1458V_LCC-H10115-001,IC,SLG5NT1458V,LPDB,GENERIC
U7C1 = TXS0102: alternate symbols: (); part number: TXS0102_SSOP-J79183-001,IC,TXS0102DCTRE4,LPDB,GENERIC
U7D1 U7H2 U8G2 = NVT2002: alternate symbols: (); part number: NVT2002_TSSOP-G34306-001,IC,NVT2002,LPDB,GENERIC
U7F1 U9A1 = TTL1T45: alternate symbols: (); part number: TTL1T45_SOT-G44167-001,IC,TTL1T45,LPDB,GENERIC
U7G1 U7G2 U7U1 U7U2 = TTL3125: alternate symbols: (); part number: TTL3125_SM-C88127-001,IC,74CBT3125,LPDB,GENERIC; signal model: TTL3125_SM-C88127-001_IC_74CBT3125_LPDB_GENERIC; room: 118
U7G4 = W25Q256: alternate symbols: (); part number: W25Q256_SO16-H25002-001,EMPTY,W25Q256FVFIQ,LPDB,GENERIC; room: 119
U7H1 = TTL07: alternate symbols: (); part number: TTL07_SM-G58837-001,IC,74AUP1G07GW,LPDB,GENERIC; room: 141
U7H3 = AT24C64: alternate symbols: (); part number: AT24C64_SOIC-C47049-001,EMPTY,AT24C64,LPDB,GENERIC
U7H4 = SN74CBTD3384: alternate symbols: (); part number: SN74CBTD3384_TSSOP-C88163-001,IC,SN74CBTD3384,LPDB,GENERIC; room: 195
U8C2 = TTL1G14: alternate symbols: (); part number: TTL1G14_SOT23-C88267-001,IC,TTL1G14,LPDB,GENERIC; room: 180
U8C4 = TTL1G14: alternate symbols: (); part number: TTL1G14_SOT23-C88267-001,IC,TTL1G14,LPDB,GENERIC; room: 183
U8C5 = FPF1320: alternate symbols: (); part number: FPF1320_SM-G61687-001,IC,FPF1320,LPDB,GENERIC
U8C6 = SLG5NT1458V: alternate symbols: (); part number: SLG5NT1458V_LCC-H10115-001,IC,SLG5NT1458V,LPDB,GENERIC; room: 176
U8D1 = TTL1G14: alternate symbols: (); part number: TTL1G14_SOT23-C88267-001,IC,TTL1G14,LPDB,GENERIC; room: 177
U8D6 = TTL1G74: alternate symbols: (); part number: TTL1G74_VSSOP-E90546-001,IC,TTL1G74,LPDB,GENERIC; room: 178
U8D7 = TTL07: alternate symbols: (); part number: TTL07_SM-G58837-001,IC,74AUP1G07GW,LPDB,GENERIC
U8D12 = TTL1G08: alternate symbols: (); part number: TTL1G08_SOT23-H97028-001,IC,SN74LV1T08DBVR,LPDB,GENERIC
U8D13 U8D14 = TTL1G08: alternate symbols: (); part number: TTL1G08_SM-C78568-001,IC,74AHC1G08,LPDB,GENERIC; room: 178
U8E1 U8E2 U8E4 U8E5 U8F4 = TLV62585: alternate symbols: (); part number: TLV62585_SOT563-K33819-001,IC,TLV62585PDRL,LPDB,GENERIC
U8E3 = PCA9555PW: alternate symbols: (); part number: PCA9555PW_TSSOP-C90179-001,IC,PCA9555PW,LPDB,GENERIC; room: 123
U8F1 U8F2 U9C2 = TTL1G08: alternate symbols: (); part number: TTL1G08_SM-C78568-001,IC,74AHC1G08,LPDB,GENERIC; room: 102
U8F3 = TTL07: alternate symbols: (); part number: TTL07_SM-G58837-001,IC,74AUP1G07GW,LPDB,GENERIC; room: 125
U8F5 = TTL1G08: alternate symbols: (); part number: TTL1G08_SM-C78568-001,IC,74AHC1G08,LPDB,GENERIC; room: 33
U8F6 = MEC142X: alternate symbols: (); part number: MEC142X_QFP-H73759-003,IC,MEC1428-NU-D,LPDB,GENERIC; room: 127
U8H1-U8H4 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM3-J16541-001,EMPTY,90OHM,NA,100MA,LPDB,GENERIC
U8H5 = SLG7NT42752_2: alternate symbols: (); part number: SLG7NT42752_2_LCC-K43100-001,IC,SLG7NT42752VTR,TK0,GENERIC; room: NONE
U8H6 U8J1 = AD820: alternate symbols: (); part number: AD820_SOIC-D66090-001,IC,AD820ARZ,LPDB,GENERIC
U8J2 = AT24C02C: alternate symbols: (); part number: AT24C02C_SOIC-H34397-001,IC,AT24C02D-SSHM-T,LPDB,GENERIC; room: 204
U8L1 = MAX6958: alternate symbols: (); part number: MAX6958_SM-E87021-001,IC,MAX6958,LPDB,GENERIC; room: 122
U8L2 = AT24C16C: alternate symbols: (); part number: AT24C16C_SOIC-C77055-001,IC,AT24C16C,LPDB,GENERIC; room: 128
U9C1 = MAX3232: alternate symbols: (); part number: MAX3232_TSSOP-C76254-001,IC,MAX3232CUE+T,LPDB,GENERIC; room: 129
XJ3D2 = CML_S_SOCKET_KOZ_2: alternate symbols: (); part number: CML_S_SOCKET_KOZ_2_TH-NA_61424,KOZ,CML S SOCKET,LPDB,IP; room: NONE
XY7F1 = CON_1X2: alternate symbols: (); part number: CON_1X2_TH-D78481-001,CONN,CON_1X2,LPDB,GENERIC
Y3A1 = XTAL_4P_2: part number: XTAL_4P_2_SMB-D71700-120,XTAL,27MHZ,0.002%,TK0,GENERIC; room: NONE
Y4A1 = XTAL_4P: alternate symbols: (); part number: XTAL_4P_SM-D71700-060,XTAL,25MHZ,0.001%,LPDB,GENERIC
Y4A2 = XTAL_4P_C: alternate symbols: (); part number: XTAL_4P_C_SM-D71700-057,XTAL,25MHZ,0.003%,LPDB,GENERIC; room: 92
Y6A1 = OSC_4P_D_2: alternate symbols: (); part number: OSC_4P_D_2_SM-D34520-034,OSC,32.768KHZ,25PPM,TK0,GENERIC,; room: NONE
Y6D1 = XTAL_4P: alternate symbols: (); part number: XTAL_4P_SM-E35468-024,XTAL,24MHZ,0.002%,LPDB,GENERIC; room: 42
Y7A1 = XTAL_4P_C: alternate symbols: (); part number: XTAL_4P_C_SM-D71700-057,XTAL,25MHZ,0.003%,LPDB,GENERIC
Y7F1 = XTAL: alternate symbols: (); part number: XTAL_THMT-A91451-001,XTAL,32.7680KHZ,20PPM,LPDB,GENERIC; room: 42
Y8F1 = XTAL: alternate symbols: (); part number: XTAL_SM-C13544-024,XTAL,32.768KHZ,20PPM,LPDB,GENERIC; room: 126

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
AUDIO_TJR_8P_2M_MA
  round 0.25 hole 1.1 unplated: (-3.5,1.1) (3,1.1)
  oval 1.875x1.075 hole 1.5x0.7: 1(0,0) 6(0,9.4)
  oval 1.075x1.875 hole 0.7x1.5: 2(3.6,5) 3(-1.6,8.1) 4(-3.1,6.1) 5(-4.5,8.1) 7(4.35,2.9) 8(-4.75,3.6)
B2B_SJR_1X5_2M_MA
  rect 0.3x1.3 smd: 1(0,0.028) 2(1,0.028) 3(2,0.028) 4(3,0.028) 5(4,0.028)
  rect 1.8x2.2 smd: 6(-2.4,-3.227) 7(6.4,-3.227)
B2B_SJV_2X30_2M_IA
  round 0.254 hole 1.016 unplated: (5.537,2.815) (5.537,-17.315)
  rect 2.286x0.279 smd: 1(0,0) 2(5.74,0) 3(0,-0.5) 4(5.74,-0.5) 5(0,-1) 6(5.74,-1) 7(0,-1.5) 8(5.74,-1.5) 9(0,-2) 10(5.74,-2) 11(0,-2.5) 12(5.74,-2.5) 13(0,-3) 14(5.74,-3) 15(0,-3.5) 16(5.74,-3.5) 17(0,-4) 18(5.74,-4) 19(0,-4.5) 20(5.74,-4.5) 21(0,-5) 22(5.74,-5) 23(0,-5.5) 24(5.74,-5.5) 25(0,-6) 26(5.74,-6) 27(0,-6.5) 28(5.74,-6.5) 29(0,-7) 30(5.74,-7) 31(0,-7.5) 32(5.74,-7.5) 33(0,-8) 34(5.74,-8) 35(0,-8.5) 36(5.74,-8.5) 37(0,-9) 38(5.74,-9) 39(0,-9.5) 40(5.74,-9.5) 41(0,-10) 42(5.74,-10) 43(0,-10.5) 44(5.74,-10.5) 45(0,-11) 46(5.74,-11) 47(0,-11.5) 48(5.74,-11.5) 49(0,-12) 50(5.74,-12) 51(0,-12.5) 52(5.74,-12.5) 53(0,-13) 54(5.74,-13) 55(0,-13.5) 56(5.74,-13.5) 57(0,-14) 58(5.74,-14) 59(0,-14.5) 60(5.74,-14.5)
  rect 0.432x2.54 smd: 61(2.87,0.815) 64(2.87,-15.315)
  rect 0.432x4.699 smd: 62(2.87,-4.075) 63(2.87,-10.425)
BGA4_1_50MD
  round 0.25 smd: 1(-0.25,0.25) 2(0.25,0.25) 3(0.25,-0.25) 4(-0.25,-0.25)
BGA6_1_50MC
  round 0.25 smd: A1(-0.25,0.5) A2(0.25,0.5) B1(-0.25,0) B2(0.25,0) C1(-0.25,-0.5) C2(0.25,-0.5)
BGA16_1_50MF
  round 0.25 smd: A1(-0.75,0.75) A2(-0.25,0.75) A3(0.25,0.75) A4(0.75,0.75) B1(-0.75,0.25) B2(-0.25,0.25) B3(0.25,0.25) B4(0.75,0.25) C1(-0.75,-0.25) C2(-0.25,-0.25) C3(0.25,-0.25) C4(0.75,-0.25) D1(-0.75,-0.75) D2(-0.25,-0.75) D3(0.25,-0.75) D4(0.75,-0.75)
BGA64_1_80MA
  round 0.325 smd: A1(-2.8,2.8) A2(-2,2.8) A3(-1.2,2.8) A4(-0.4,2.8) A5(0.4,2.8) A6(1.2,2.8) A7(2,2.8) A8(2.8,2.8) B1(-2.8,2) B2(-2,2) B3(-1.2,2) B4(-0.4,2) B5(0.4,2) B6(1.2,2) B7(2,2) B8(2.8,2) C1(-2.8,1.2) C2(-2,1.2) C3(-1.2,1.2) C4(-0.4,1.2) C5(0.4,1.2) C6(1.2,1.2) C7(2,1.2) C8(2.8,1.2) D1(-2.8,0.4) D2(-2,0.4) D3(-1.2,0.4) D4(-0.4,0.4) D5(0.4,0.4) D6(1.2,0.4) D7(2,0.4) D8(2.8,0.4) E1(-2.8,-0.4) E2(-2,-0.4) E3(-1.2,-0.4) E4(-0.4,-0.4) E5(0.4,-0.4) E6(1.2,-0.4) E7(2,-0.4) E8(2.8,-0.4) F1(-2.8,-1.2) F2(-2,-1.2) F3(-1.2,-1.2) F4(-0.4,-1.2) F5(0.4,-1.2) F6(1.2,-1.2) F7(2,-1.2) F8(2.8,-1.2) G1(-2.8,-2) G2(-2,-2) G3(-1.2,-2) G4(-0.4,-2) G5(0.4,-2) G6(1.2,-2) G7(2,-2) G8(2.8,-2) H1(-2.8,-2.8) H2(-2,-2.8) H3(-1.2,-2.8) H4(-0.4,-2.8) H5(0.4,-2.8) H6(1.2,-2.8) H7(2,-2.8) H8(2.8,-2.8)
BGA874_CNP_H_5_MA
  round 0.305 smd: A2(-11.46,11.314) A3(-10.959,11.314) A4(-10.459,11.314) A46(10.459,11.314) A47(10.959,11.314) A48(11.46,11.314) AA19(-3.099,1.549) AA20(-2.324,1.549) AA22(-1.549,1.549) AA23(-0.775,1.549) AA25(0,1.549) AA27(0.775,1.549) AA28(1.549,1.549) AA30(2.324,1.549) AA31(3.099,1.549) AB19(-3.099,0.775) AB20(-2.324,0.775) AB22(-1.549,0.775) AB23(-0.775,0.775) AB25(0,0.775) AB27(0.775,0.775) AB28(1.549,0.775) AB30(2.324,0.775) AB31(3.099,0.775) AC6(-9.374,0.579) AC7(-8.612,0.579) AC9(-7.85,0.579) AC11(-7.088,0.579) AC12(-6.326,0.579) AC14(-5.564,0.579) AC15(-4.802,0.579) AC17(-4.04,0.579) AC33(4.04,0.579) AC35(4.802,0.579) AC36(5.564,0.579) AC38(6.326,0.579) AC39(7.088,0.579) AC41(7.85,0.579) AC43(8.612,0.579) AC44(9.374,0.579) AD19(-3.099,0) AD20(-2.324,0) AD22(-1.549,0) AD23(-0.775,0) AD25(0,0) AD27(0.775,0) AD28(1.549,0) AD30(2.324,0) AD31(3.099,0) AE6(-9.374,-0.579) AE7(-8.612,-0.579) AE9(-7.85,-0.579) AE11(-7.088,-0.579) AE12(-6.326,-0.579) AE14(-5.564,-0.579) AE15(-4.802,-0.579) AE17(-4.04,-0.579) AE33(4.04,-0.579) AE35(4.802,-0.579) AE36(5.564,-0.579) AE38(6.326,-0.579) AE39(7.088,-0.579) AE41(7.85,-0.579) AE43(8.612,-0.579) AE44(9.374,-0.579) AF19(-3.099,-0.775) AF20(-2.324,-0.775) AF22(-1.549,-0.775) AF23(-0.775,-0.775) AF25(0,-0.775) AF27(0.775,-0.775) AF28(1.549,-0.775) AF30(2.324,-0.775) AF31(3.099,-0.775) AG19(-3.099,-1.549) AG20(-2.324,-1.549) AG22(-1.549,-1.549) AG23(-0.775,-1.549) AG25(0,-1.549) AG27(0.775,-1.549) AG28(1.549,-1.549) AG30(2.324,-1.549) AG31(3.099,-1.549) AH9(-7.919,-2.205) AH10(-7.18,-2.014) AH12(-6.402,-2.014) AH14(-5.564,-2.014) AH15(-4.789,-2.014) AH17(-4.027,-2.014) AH33(4.027,-2.014) AH35(4.789,-2.014) AH36(5.564,-2.014) AH38(6.402,-2.014) AH40(7.18,-2.014) AH41(7.919,-2.205) AJ6(-9.397,-2.586) AJ7(-8.658,-2.395) AJ19(-3.099,-2.324) AJ20(-2.324,-2.324) AJ22(-1.549,-2.324) AJ23(-0.775,-2.324) AJ25(0,-2.324) AJ27(0.775,-2.324) AJ28(1.549,-2.324) AJ30(2.324,-2.324) AJ31(3.099,-2.324) AJ43(8.658,-2.395) AJ44(9.397,-2.586) AK19(-3.099,-3.099) AK20(-2.324,-3.099) AK22(-1.549,-3.099) AK23(-0.775,-3.099) AK25(0,-3.099) AK27(0.775,-3.099) AK28(1.549,-3.099) AK30(2.324,-3.099) AK31(3.099,-3.099) AL9(-7.914,-3.495) AL10(-7.181,-3.259) AL12(-6.419,-3.259) AL13(-5.657,-3.259) AL15(-4.895,-3.259) AL17(-4.133,-3.259) AL21(-2.014,-3.578) AL24(-0.579,-3.591) AL26(0.579,-3.591) AL29(2.014,-3.578) AL33(4.133,-3.259) AL35(4.895,-3.259) AL37(5.657,-3.259) AL38(6.419,-3.259) AL40(7.181,-3.259) AL41(7.914,-3.495) AM7(-8.635,-3.843) AM18(-3.259,-3.683) AM32(3.259,-3.683) AM43(8.635,-3.843) AN6(-9.295,-4.224) AN10(-7.181,-4.656) AN12(-6.444,-4.351) AN13(-5.682,-4.351) AN15(-4.92,-4.351) AN16(-4.351,-4.394) AN18(-3.259,-4.394) AN21(-2.014,-4.289) AN24(-0.579,-4.302) AN26(0.579,-4.302) AN29(2.014,-4.289) AN32(3.259,-4.394) AN34(4.351,-4.394) AN35(4.92,-4.351) AN37(5.682,-4.351) AN38(6.444,-4.351) AN40(7.181,-4.656) AN44(9.295,-4.224) AP9(-7.914,-4.968) AP21(-2.014,-5.064) AP24(-0.579,-5.064) AP26(0.579,-5.064) AP29(2.014,-5.064) AP41(7.914,-4.968) AR8(-8.508,-5.469) AR12(-6.444,-5.443) AR13(-5.682,-5.443) AR15(-4.92,-5.443) AR16(-4.351,-5.182) AR18(-3.259,-5.157) AR32(3.259,-5.157) AR34(4.351,-5.182) AR35(4.92,-5.443) AR37(5.682,-5.443) AR38(6.444,-5.443) AR42(8.508,-5.469) AT6(-9.295,-5.659) AT10(-7.181,-5.773) AT16(-4.351,-5.944) AT18(-3.259,-5.918) AT21(-2.014,-5.902) AT24(-0.579,-5.826) AT26(0.579,-5.826) AT29(2.014,-5.902) AT32(3.259,-5.918) AT34(4.351,-5.944) AT40(7.181,-5.773) AT44(9.295,-5.659) AU9(-7.914,-6.416) AU24(-0.579,-6.588) AU26(0.579,-6.588) AU41(7.914,-6.416) AV6(-9.295,-7.094) AV7(-8.597,-6.764) AV11(-7.079,-6.975) AV13(-5.748,-6.757) AV16(-4.656,-6.719) AV18(-3.259,-6.681) AV21(-2.014,-6.679) AV29(2.014,-6.679) AV32(3.259,-6.681) AV34(4.656,-6.719) AV37(5.748,-6.757) AV39(7.079,-6.975) AV43(8.597,-6.764) AV44(9.295,-7.094) AW9(-7.824,-7.577) AW10(-7.262,-7.509) AW13(-6.01,-7.49) AW15(-4.892,-7.452) AW18(-3.495,-7.413) AW21(-2.205,-7.419) AW24(-0.579,-7.35) AW26(0.579,-7.35) AW29(2.205,-7.419) AW32(3.495,-7.413) AW35(4.892,-7.452) AW37(6.01,-7.49) AW40(7.262,-7.509) AW41(7.824,-7.577) AY8(-8.533,-7.898) AY42(8.533,-7.898) B1(-11.814,10.96) B2(-11.33,10.83) B3(-10.709,10.878) B47(10.709,10.878) B48(11.33,10.83) B49(11.814,10.96) BA6(-9.13,-8.203) BA12(-6.485,-8.135) BA14(-5.24,-8.135) BA17(-3.843,-8.135) BA20(-2.395,-8.158) BA24(-0.579,-8.112) BA26(0.579,-8.112) BA30(2.395,-8.158) BA33(3.843,-8.135) BA36(5.24,-8.135) BA38(6.485,-8.135) BA44(9.13,-8.203) BB6(-9.088,-8.706) BB7(-8.589,-9) BB9(-8.024,-8.774) BB11(-6.866,-8.795) BB14(-5.621,-8.795) BB16(-4.224,-8.795) BB20(-2.586,-8.897) BB24(-0.579,-8.874) BB26(0.579,-8.874) BB30(2.586,-8.897) BB34(4.224,-8.795) BB36(5.621,-8.795) BB39(6.866,-8.795) BB41(8.024,-8.774) BB43(8.589,-9) BB44(9.088,-8.706) BC5(-9.634,-9.254) BC45(9.634,-9.254) BD1(-11.814,-9.959) BD4(-10.474,-9.983) BD46(10.474,-9.983) BD49(11.814,-9.959) BE1(-11.814,-10.459) BE2(-11.373,-10.196) BE3(-10.86,-10.311) BE4(-10.391,-10.487) BE5(-9.965,-10.212) BE45(9.965,-10.212) BE46(10.391,-10.487) BE47(10.86,-10.311) BE48(11.373,-10.196) BE49(11.814,-10.459) BF1(-11.814,-10.96) BF2(-11.33,-10.83) BF3(-10.709,-10.878) BF47(10.709,-10.878) BF48(11.33,-10.83) BF49(11.814,-10.96) BG2(-11.46,-11.314) BG3(-10.959,-11.314) BG4(-10.459,-11.314) BG46(10.459,-11.314) BG47(10.959,-11.314) BG48(11.46,-11.314) C1(-11.814,10.459) C2(-11.373,10.196) C3(-10.86,10.311) C4(-10.391,10.487) C5(-9.965,10.212) C45(9.965,10.212) C46(10.391,10.487) C47(10.86,10.311) C48(11.373,10.196) C49(11.814,10.459) D1(-11.814,9.959) D4(-10.474,9.983) D46(10.474,9.983) D49(11.814,9.959) E5(-9.634,9.254) E45(9.634,9.254) F6(-9.088,8.706) F7(-8.589,9) F9(-8.024,8.774) F11(-6.866,8.795) F14(-5.621,8.795) F16(-4.224,8.795) F20(-2.586,8.897) F24(-0.579,8.874) F26(0.579,8.874) F30(2.586,8.897) F34(4.224,8.795) F36(5.621,8.795) F39(6.866,8.795) F41(8.024,8.774) F43(8.589,9) F44(9.088,8.706) G6(-9.13,8.203) G12(-6.485,8.135) G14(-5.24,8.135) G17(-3.843,8.135) G20(-2.395,8.158) G24(-0.579,8.112) G26(0.579,8.112) G30(2.395,8.158) G33(3.843,8.135) G36(5.24,8.135) G38(6.485,8.135) G44(9.13,8.203) H8(-8.533,7.898) H42(8.533,7.898) J9(-7.824,7.577) J10(-7.262,7.509) J13(-6.01,7.49) J15(-4.892,7.452) J18(-3.495,7.413) J21(-2.205,7.419) J24(-0.579,7.35) J26(0.579,7.35) J29(2.205,7.419) J32(3.495,7.413) J35(4.892,7.452) J37(6.01,7.49) J40(7.262,7.509) J41(7.824,7.577) K6(-9.295,7.094) K7(-8.597,6.764) K11(-7.079,6.975) K13(-5.748,6.757) K16(-4.656,6.719) K18(-3.259,6.681) K21(-2.014,6.679) K29(2.014,6.679) K32(3.259,6.681) K34(4.656,6.719) K37(5.748,6.757) K39(7.079,6.975) K43(8.597,6.764) K44(9.295,7.094) L9(-7.914,6.416) L24(-0.579,6.588) L26(0.579,6.588) L41(7.914,6.416) M6(-9.295,5.659) M10(-7.181,5.773) M16(-4.351,5.944) M18(-3.259,5.918) M21(-2.014,5.902) M24(-0.579,5.826) M26(0.579,5.826) M29(2.014,5.902) M32(3.259,5.918) M34(4.351,5.944) M40(7.181,5.773) M44(9.295,5.659) N8(-8.508,5.469) N12(-6.444,5.443) N13(-5.682,5.443) N15(-4.92,5.443) N16(-4.351,5.182) N18(-3.259,5.157) N32(3.259,5.157) N34(4.351,5.182) N35(4.92,5.443) N37(5.682,5.443) N38(6.444,5.443) N42(8.508,5.469) P9(-7.914,4.968) P21(-2.014,5.064) P24(-0.579,5.064) P26(0.579,5.064) P29(2.014,5.064) P41(7.914,4.968) R6(-9.295,4.224) R10(-7.181,4.656) R12(-6.444,4.351) R13(-5.682,4.351) R15(-4.92,4.351) R16(-4.351,4.394) R18(-3.259,4.394) R21(-2.014,4.289) R24(-0.579,4.302) R26(0.579,4.302) R29(2.014,4.289) R32(3.259,4.394) R34(4.351,4.394) R35(4.92,4.351) R37(5.682,4.351) R38(6.444,4.351) R40(7.181,4.656) R44(9.295,4.224) T7(-8.635,3.843) T17(-3.811,3.683) T18(-3.259,3.683) T32(3.259,3.683) T43(8.635,3.843) U9(-7.914,3.495) U10(-7.181,3.259) U12(-6.419,3.259) U13(-5.657,3.259) U15(-4.895,3.259) U17(-4.133,3.259) U21(-2.014,3.578) U24(-0.579,3.591) U26(0.579,3.591) U29(2.014,3.578) U33(4.133,3.259) U35(4.895,3.259) U37(5.657,3.259) U38(6.419,3.259) U40(7.181,3.259) U41(7.914,3.495) V19(-3.099,3.099) V20(-2.324,3.099) V22(-1.549,3.099) V23(-0.775,3.099) V25(0,3.099) V27(0.775,3.099) V28(1.549,3.099) V30(2.324,3.099) V31(3.099,3.099) W6(-9.397,2.586) W7(-8.658,2.395) W19(-3.099,2.324) W20(-2.324,2.324) W22(-1.549,2.324) W23(-0.775,2.324) W25(0,2.324) W27(0.775,2.324) W28(1.549,2.324) W30(2.324,2.324) W31(3.099,2.324) W43(8.658,2.395) W44(9.397,2.586) Y9(-7.919,2.205) Y10(-7.18,2.014) Y12(-6.402,2.014) Y14(-5.564,2.014) Y15(-4.789,2.014) Y17(-4.027,2.014) Y33(4.027,2.014) Y35(4.789,2.014) Y36(5.564,2.014) Y38(6.402,2.014) Y40(7.18,2.014) Y41(7.919,2.205)
  round 0.279 smd: A5(-9.958,11.314) A45(9.958,11.314) BC1(-11.814,-9.458) BC49(11.814,-9.458) BG5(-9.958,-11.314) BG45(9.958,-11.314) E1(-11.814,9.458) E49(11.814,9.458)
  oval 0.203x0.254 smd: A6(-9.399,11.314) A8(-8.294,11.314) A42(8.294,11.314) A44(9.399,11.314) BD8(-8.411,-9.813) BD12(-6.214,-9.813) BD17(-4.017,-9.813) BD21(-1.82,-9.813) BD29(1.82,-9.813) BD33(4.017,-9.813) BD38(6.214,-9.813) BD42(8.411,-9.813) BE9(-7.784,-10.186) BE10(-7.283,-10.059) BE14(-5.587,-10.186) BE15(-5.086,-10.059) BE18(-3.39,-10.186) BE19(-2.889,-10.059) BE23(-1.193,-10.186) BE24(-0.692,-10.059) BE26(0.692,-10.059) BE27(1.193,-10.186) BE31(2.889,-10.059) BE32(3.39,-10.186) BE35(5.086,-10.059) BE36(5.587,-10.186) BE40(7.283,-10.059) BE41(7.784,-10.186) BG6(-9.399,-11.314) BG8(-8.294,-11.314) BG42(8.294,-11.314) BG44(9.399,-11.314) C9(-7.784,10.186) C10(-7.283,10.059) C14(-5.587,10.186) C15(-5.086,10.059) C18(-3.39,10.186) C19(-2.889,10.059) C23(-1.193,10.186) C24(-0.692,10.059) C26(0.692,10.059) C27(1.193,10.186) C31(2.889,10.059) C32(3.39,10.186) C35(5.086,10.059) C36(5.587,10.186) C40(7.283,10.059) C41(7.784,10.186) D8(-8.411,9.813) D12(-6.214,9.813) D17(-4.017,9.813) D21(-1.82,9.813) D29(1.82,9.813) D33(4.017,9.813) D38(6.214,9.813) D42(8.411,9.813)
  oval 0.152x0.254 smd: A13(-6.072,11.314) A17(-3.875,11.314) A22(-1.678,11.314) A25(0,11.314) A28(1.678,11.314) A33(3.875,11.314) A37(6.072,11.314) B10(-7.123,10.603) B12(-6.265,10.816) B14(-5.587,10.687) B15(-4.926,10.603) B17(-4.068,10.816) B18(-3.39,10.687) B19(-2.729,10.603) B21(-1.871,10.816) B23(-1.193,10.687) B24(-0.532,10.603) B25(0,10.806) B26(0.532,10.603) B27(1.193,10.687) B29(1.871,10.816) B31(2.729,10.603) B32(3.39,10.687) B33(4.068,10.816) B35(4.926,10.603) B36(5.587,10.687) B38(6.265,10.816) B40(7.123,10.603) BE11(-6.761,-10.118) BE12(-6.295,-10.313) BE16(-4.563,-10.118) BE17(-4.098,-10.313) BE20(-2.366,-10.118) BE21(-1.901,-10.313) BE25(0,-10.298) BE29(1.901,-10.313) BE30(2.366,-10.118) BE33(4.098,-10.313) BE34(4.563,-10.118) BE38(6.295,-10.313) BE39(6.761,-10.118) BF10(-7.123,-10.603) BF12(-6.265,-10.816) BF14(-5.587,-10.687) BF15(-4.926,-10.603) BF17(-4.068,-10.816) BF18(-3.39,-10.687) BF19(-2.729,-10.603) BF21(-1.871,-10.816) BF23(-1.193,-10.687) BF24(-0.532,-10.603) BF25(0,-10.806) BF26(0.532,-10.603) BF27(1.193,-10.687) BF29(1.871,-10.816) BF31(2.729,-10.603) BF32(3.39,-10.687) BF33(4.068,-10.816) BF35(4.926,-10.603) BF36(5.587,-10.687) BF38(6.265,-10.816) BF40(7.123,-10.603) BG13(-6.072,-11.314) BG17(-3.875,-11.314) BG22(-1.678,-11.314) BG25(0,-11.314) BG28(1.678,-11.314) BG33(3.875,-11.314) BG37(6.072,-11.314) C11(-6.761,10.118) C12(-6.295,10.313) C16(-4.563,10.118) C17(-4.098,10.313) C20(-2.366,10.118) C21(-1.901,10.313) C25(0,10.298) C29(1.901,10.313) C30(2.366,10.118) C33(4.098,10.313) C34(4.563,10.118) C38(6.295,10.313) C39(6.761,10.118)
  oval 0.254x0.152 smd: AA1(-11.814,1.678) AA49(11.814,1.678) AB2(-11.187,1.193) AB48(11.187,1.193) AC2(-11.103,0.532) AC48(11.103,0.532) AD1(-11.814,0) AD2(-11.306,0) AD3(-10.798,0) AD47(10.798,0) AD48(11.306,0) AD49(11.814,0) AE2(-11.103,-0.532) AE48(11.103,-0.532) AF2(-11.187,-1.193) AF48(11.187,-1.193) AG1(-11.814,-1.678) AG49(11.814,-1.678) AH2(-11.316,-1.871) AH3(-10.813,-1.901) AH47(10.813,-1.901) AH48(11.316,-1.871) AJ3(-10.618,-2.366) AJ47(10.618,-2.366) AK2(-11.103,-2.729) AK48(11.103,-2.729) AL2(-11.187,-3.39) AL48(11.187,-3.39) AM1(-11.814,-3.875) AM2(-11.316,-4.068) AM3(-10.813,-4.098) AM47(10.813,-4.098) AM48(11.316,-4.068) AM49(11.814,-3.875) AN3(-10.618,-4.563) AN47(10.618,-4.563) AP2(-11.103,-4.926) AP48(11.103,-4.926) P2(-11.103,4.926) P48(11.103,4.926) R3(-10.618,4.563) R47(10.618,4.563) T1(-11.814,3.875) T2(-11.316,4.068) T3(-10.813,4.098) T47(10.813,4.098) T48(11.316,4.068) T49(11.814,3.875) U2(-11.187,3.39) U48(11.187,3.39) V2(-11.103,2.729) V48(11.103,2.729) W3(-10.618,2.366) W47(10.618,2.366) Y2(-11.316,1.871) Y3(-10.813,1.901) Y47(10.813,1.901) Y48(11.316,1.871)
  round 0.254 smd: AA5(-9.856,1.601) AA45(9.856,1.601) AC4(-10.06,0.579) AC46(10.06,0.579) AE4(-10.06,-0.579) AE46(10.06,-0.579) AG5(-9.856,-1.601) AG45(9.856,-1.601) AJ4(-10.098,-2.274) AJ46(10.098,-2.274) AK4(-10.06,-2.776) AK46(10.06,-2.776) AM5(-9.856,-3.799) AM45(9.856,-3.799) AN4(-10.098,-4.471) AN46(10.098,-4.471) AP4(-10.06,-4.973) AP46(10.06,-4.973) AT5(-9.856,-5.996) AT45(9.856,-5.996) AV4(-10.098,-6.668) AV46(10.098,-6.668) AW4(-10.06,-7.17) AW46(10.06,-7.17) B6(-9.397,10.811) B44(9.397,10.811) BA2(-11.316,-8.526) BA3(-10.809,-8.594) BA4(-10.304,-8.468) BA5(-9.856,-8.193) BA45(9.856,-8.193) BA46(10.304,-8.468) BA47(10.809,-8.594) BA48(11.316,-8.526) BB3(-11.318,-9.315) BB4(-10.826,-9.127) BB46(10.826,-9.127) BB47(11.318,-9.315) BC8(-8.193,-9.356) BC10(-7.17,-9.56) BC13(-5.996,-9.356) BC15(-4.973,-9.56) BC17(-3.799,-9.356) BC19(-2.776,-9.56) BC22(-1.601,-9.356) BC24(-0.579,-9.56) BC26(0.579,-9.56) BC28(1.601,-9.356) BC31(2.776,-9.56) BC33(3.799,-9.356) BC35(4.973,-9.56) BC37(5.996,-9.356) BC40(7.17,-9.56) BC42(8.193,-9.356) BD7(-8.914,-9.873) BD11(-6.668,-9.598) BD16(-4.471,-9.598) BD20(-2.274,-9.598) BD30(2.274,-9.598) BD34(4.471,-9.598) BD39(6.668,-9.598) BD43(8.914,-9.873) BE6(-9.091,-10.357) BE44(9.091,-10.357) BF6(-9.397,-10.811) BF44(9.397,-10.811) C6(-9.091,10.357) C44(9.091,10.357) D7(-8.914,9.873) D11(-6.668,9.598) D16(-4.471,9.598) D20(-2.274,9.598) D30(2.274,9.598) D34(4.471,9.598) D39(6.668,9.598) D43(8.914,9.873) E8(-8.193,9.356) E10(-7.17,9.56) E13(-5.996,9.356) E15(-4.973,9.56) E17(-3.799,9.356) E19(-2.776,9.56) E22(-1.601,9.356) E24(-0.579,9.56) E26(0.579,9.56) E28(1.601,9.356) E31(2.776,9.56) E33(3.799,9.356) E35(4.973,9.56) E37(5.996,9.356) E40(7.17,9.56) E42(8.193,9.356) F3(-11.318,9.315) F4(-10.826,9.127) F46(10.826,9.127) F47(11.318,9.315) G2(-11.316,8.526) G3(-10.809,8.594) G4(-10.304,8.468) G5(-9.856,8.193) G45(9.856,8.193) G46(10.304,8.468) G47(10.809,8.594) G48(11.316,8.526) J4(-10.06,7.17) J46(10.06,7.17) K4(-10.098,6.668) K46(10.098,6.668) M5(-9.856,5.996) M45(9.856,5.996) P4(-10.06,4.973) P46(10.06,4.973) R4(-10.098,4.471) R46(10.098,4.471) T5(-9.856,3.799) T45(9.856,3.799) V4(-10.06,2.776) V46(10.06,2.776) W4(-10.098,2.274) W46(10.098,2.274)
  oval 0.254x0.203 smd: AB3(-10.686,1.193) AB47(10.686,1.193) AC3(-10.559,0.692) AC47(10.559,0.692) AE3(-10.559,-0.692) AE47(10.559,-0.692) AF3(-10.686,-1.193) AF47(10.686,-1.193) AH4(-10.313,-1.82) AH46(10.313,-1.82) AK3(-10.559,-2.883) AK47(10.559,-2.883) AL3(-10.686,-3.39) AL47(10.686,-3.39) AM4(-10.313,-4.017) AM46(10.313,-4.017) AP3(-10.559,-5.08) AP47(10.559,-5.08) AR3(-10.686,-5.587) AR47(10.686,-5.587) AT1(-11.814,-6.097) AT49(11.814,-6.097) AU4(-10.313,-6.214) AU46(10.313,-6.214) AW3(-10.559,-7.277) AW47(10.559,-7.277) AY3(-10.686,-7.784) AY47(10.686,-7.784) BA1(-11.814,-8.32) BA49(11.814,-8.32) G1(-11.814,8.32) G49(11.814,8.32) H3(-10.686,7.784) H47(10.686,7.784) J3(-10.559,7.277) J47(10.559,7.277) L4(-10.313,6.214) L46(10.313,6.214) M1(-11.814,6.097) M49(11.814,6.097) N3(-10.686,5.587) N47(10.686,5.587) P3(-10.559,5.08) P47(10.559,5.08) T4(-10.313,4.017) T46(10.313,4.017) U3(-10.686,3.39) U47(10.686,3.39) V3(-10.559,2.883) V47(10.559,2.883) Y4(-10.313,1.82) Y46(10.313,1.82)
  oval 0.305x0.152 smd: AR2(-11.187,-5.587) AR48(11.187,-5.587) AU2(-11.316,-6.265) AU3(-10.813,-6.295) AU47(10.813,-6.295) AU48(11.316,-6.265) AV3(-10.618,-6.761) AV47(10.618,-6.761) AW2(-11.103,-7.123) AW48(11.103,-7.123) AY2(-11.187,-7.784) AY48(11.187,-7.784) H2(-11.187,7.784) H48(11.187,7.784) J2(-11.103,7.123) J48(11.103,7.123) K3(-10.618,6.761) K47(10.618,6.761) L2(-11.316,6.265) L3(-10.813,6.295) L47(10.813,6.295) L48(11.316,6.265) N2(-11.187,5.587) N48(11.187,5.587)
  oval 0.152x0.305 smd: B8(-8.462,10.816) B9(-7.784,10.687) B41(7.784,10.687) B42(8.462,10.816) BE8(-8.492,-10.313) BE42(8.492,-10.313) BF8(-8.462,-10.816) BF9(-7.784,-10.687) BF41(7.784,-10.687) BF42(8.462,-10.816) C8(-8.492,10.313) C42(8.492,10.313)
