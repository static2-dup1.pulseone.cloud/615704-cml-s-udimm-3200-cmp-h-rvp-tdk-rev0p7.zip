# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PS_ON_OUT_EC_N: length 165.4
  TOP w0.1: v1(120.77,24.13) R6J10.2 R6J11.2 ; U8F6.22 23.22,104.47 25.14,102.55 v1(25.14,101.98)
  LAY3 w0.1: v1(120.77,24.13) 119.5,24.13 118.99,23.62 117.72,23.62 117.47,23.87 114.42,23.87 113.88,24.42 107.76,24.42 105.92,26.26 101.72,26.26 99.99,27.99 98.08,27.99 97.57,28.5 96.89,28.5 96.63,28.25 81.76,28.25 81.06,27.54 77.56,27.54 76.87,26.85 71.64,26.85 71.25,27.24 65.48,27.24 64.77,27.96 v1(64.77,28.95)
  LAY8 w0.1: v1(25.14,101.98) 22.6,99.44 22.6,96.47 20.32,94.19 20.32,88.82 21.49,87.66 21.49,84.55 21.71,84.33 21.71,82.04 24.79,78.97 24.79,70.84 29.78,65.85 31.3,65.85 32.31,64.84 32.31,64.2 41.66,54.86 45.49,54.86 48.01,52.33 49.31,52.33 51.44,50.2 51.44,48.93 52.7,47.67 52.7,46.73 57.27,42.16 57.27,34.67 57.65,34.29 59.43,34.29 v1(64.77,28.95)
PS_ON_OUT_MECC_N: length 7.7
  TOP w0.1: J6J2.69 121,15.93 121,22.25 R6J10.1
PULSAR_38P4M_REFCLK: length 115.4
  TOP w0.089: v1(107.44,155.95) 107.41,155.98 U6E1.R6
  TOP w0.1: R7B41.2 80.41,242.19 83.56,245.34 83.56,246.76 84.45,247.65 v1(88.9,247.65)
  LAY5 w0.125: v1(107.44,155.95) 107.44,157.1 107.82,157.48 107.82,160.91 106.42,162.3 106.42,165.73 105.79,166.37 105.79,167.38 99.43,173.74 99.43,179.71 98.29,180.85 98.29,186.18 95.87,188.6 95.87,198.37 92.18,202.06 92.18,202.7 v1(90.8,204.09)
  LAY6 w0.125: v1(88.9,247.65) 88.64,247.39 88.64,239.9 89.16,239.38 89.16,235.27 88.38,234.49 88.38,227.28 89.52,226.14 89.52,224.01 88.57,223.06 88.57,206.32 v1(90.8,204.09)
  BOTTOM w0.1: R6R1.1 107.56,157.35 107.56,156.08 v1(107.44,155.95)
PWR_MON1_ADDR: length 2.4
  TOP w0.089: U3H1.C2 218.06,53.6 218.06,53.25 218.05,53.25 218.05,52.96
  TOP w0.1: 218.05,52.96 218.05,52.07 R3H38.1
PWR_MON1_PDN_N: length 5.2
  TOP w0.089: U3H1.B3 219.06,54.6 219.57,54.6 219.58,54.61
  TOP w0.1: 219.58,54.61 219.96,54.99 220.59,54.99 C3H5.1 ; 221.23,55.5 C3H5.1 ; C3H5.1 R3H28.1
PWR_MON1_SLOW: length 5.1
  TOP w0.089: 219.71,53.97 219.58,54.1 219.06,54.1 U3H1.C3
  TOP w0.1: R3H41.1 C3H8.1 221.23,52.45 220.77,52.91 220.77,53.54 220.34,53.97 219.71,53.97
PWR_MON2_ADDR: length 2.5
  TOP w0.089: U1E2.C2 282.82,154.56 282.82,154.42 282.83,154.42 282.83,153.67
  TOP w0.1: R1E19.1 282.19,153.03 282.83,153.67
PWR_MON2_PDN_N: length 5.2
  TOP w0.089: U1E2.B3 283.83,155.57 284.34,155.57 284.35,155.57
  TOP w0.1: C1E4.1 R1E16.1 ; C1E4.1 285.36,155.95 284.73,155.95 284.35,155.57 ; C1E4.1 R1E15.2
PWR_MON2_SLOW: length 4.7
  TOP w0.089: U1E2.C3 283.83,155.07 284.35,155.07 284.48,154.93
  TOP w0.1: 284.48,154.93 286,153.41 C1E6.1 R1E20.1
PWR_MON3_ADDR: length 2.3
  TOP w0.089: 283.33,144.4 283.34,144.41 283.34,144.92 U1E3.C2
  TOP w0.1: 283.33,144.4 R1E38.1
PWR_MON3_PDN_N: length 5.2
  TOP w0.089: 284.86,145.92 284.85,145.92 284.34,145.92 U1E3.B3
  TOP w0.1: 284.86,145.92 285.24,146.3 285.87,146.3 C1E9.1 ; R1E31.2 C1E9.1 ; C1E9.1 R1E35.1
PWR_MON3_SLOW: length 5.1
  TOP w0.089: U1E3.C3 284.34,145.41 284.86,145.41 284.99,145.28
  TOP w0.1: 284.99,145.28 285.62,145.28 286.05,144.85 286.05,144.22 286.51,143.76 C1E10.1 R1E40.1
PWR_MON4_ADDR: length 2.3
  TOP w0.089: 290.07,160.15 290.07,160.79 U1E1.C2
  TOP w0.1: R1E8.1 290.07,158.88 290.07,160.15
PWR_MON4_PDN_N: length 5.2
  TOP w0.089: U1E1.B3 291.07,161.79 291.58,161.79 291.59,161.8
  TOP w0.1: C1E1.1 292.6,162.18 291.97,162.18 291.59,161.8 ; C1E1.1 R1D16.2 ; C1E1.1 R1E4.1
PWR_MON4_SLOW: length 5.1
  TOP w0.089: 291.72,161.16 291.59,161.29 291.07,161.29 U1E1.C3
  TOP w0.1: 291.72,161.16 292.35,161.16 292.78,160.73 292.78,160.09 293.24,159.64 C1E2.1 R1E12.1
PWR_MON5_ADDR: length 3
  TOP w0.089: U4H1.C2 188.58,53.6 188.58,53.25 188.57,53.25 188.57,53.08
  TOP w0.1: 188.57,53.08 R4H35.1
PWR_MON5_PDN_N: length 5.5
  TOP w0.089: 190.1,54.61 190.09,54.6 189.58,54.6 U4H1.B3
  TOP w0.1: C4H8.1 R4H31.1 ; C4H8.1 191.62,54.86 190.35,54.86 190.1,54.61 ; C4H8.1 192.13,55.5
PWR_MON5_SLOW: length 5.3
  TOP w0.089: 190.35,53.85 190.1,54.1 189.58,54.1 U4H1.C3
  TOP w0.1: 190.35,53.85 190.99,53.85 191.62,53.21 191.62,52.58 C4H13.1 R4H36.1
PWR_MON6_ADDR: length 3.8
  TOP w0.089: 228.72,53.08 228.73,53.09 228.73,53.6 U3H2.C2
  TOP w0.1: R3H39.1 226.94,51.31 228.72,53.08
PWR_MON6_PDN_N: length 5.1
  TOP w0.089: 230.25,54.61 230.1,54.61 230.09,54.6 229.88,54.6 229.88,54.6 229.73,54.6 U3H2.B3
  TOP w0.1: 230.25,54.61 231.01,55.37 R3H23.2 C3H6.1 R3H29.1
PWR_MON6_SLOW: length 3.9
  TOP w0.089: U3H2.C3 229.73,53.6 229.73,52.96
  TOP w0.1: C3H9.1 R3H40.1 229.73,51.56 229.73,52.96
PWR_MON7_ADDR: length 2.3
  TOP w0.088: U4H2.C2 202.05,52.7 202.05,52.57 202.06,52.56 202.06,52.36 202.05,52.36 202.05,52.2
  TOP w0.1: 202.05,52.2 R4H38.1
PWR_MON7_SLOW: length 5.3
  TOP w0.089: 203.71,53.08 203.58,53.21 203.06,53.21 U4H2.C3
  TOP w0.1: R4H44.1 C4H14.1 205.23,52.58 204.72,53.08 203.71,53.08
PWR_MON_I2C_SCL: length 259.5
  TOP w0.1: U4H2.C4 203.57,52.7 203.86,52.7 203.96,52.6 v1(203.96,52.32) ; R1E24.2 v1(285.24,153.41) 284.54,154.11 284.54,154.36 U1E2.C4 ; U1E1.C4 291.58,160.78 291.97,160.78 v1(292.1,160.65) ; U4H1.C4 189.84,53.85 190.35,53.34 v1(190.48,53.34) ; U1E3.C4 284.85,144.91 285.24,144.91 v1(285.36,144.78) ; J4H1.1 173.99,33.02 R4H54.1 ; v1(230.75,53.47) 230.63,53.47 230.24,53.85 U3H2.C4 ; U3H1.C4 219.57,53.59 219.96,53.59 v1(220.09,53.47) ; R4H54.1 R4H53.1 ; R4H54.1 R5J1.2
  LAY5 w0.125: v1(292.1,160.65) 291.87,160.42 291.87,158.01 291.59,157.73 291.59,156.97 289.3,154.68 286.37,154.68 286.13,154.93 284.65,154.93 283.97,154.25 283.97,153.16 284.22,152.91 284.73,152.91 v1(285.24,153.41) 286.52,152.14 286.52,145.93 v1(285.36,144.78) 285.75,144.78 289.05,141.48 291.59,141.48 293.06,140 293.06,138.44 292.2,137.58 292.2,131.14 291.23,130.17 291.23,120.3 291.63,119.9 291.63,117.58 291.18,117.14 291.18,110.51 291.71,109.98 291.71,109.09 291.18,108.56 291.18,101.12 291.64,100.67 291.64,95.12 290.83,94.31 290.83,91.31 291.59,90.55 291.59,81.99 283.51,73.91 282.95,73.91 282.54,73.5 282.54,71.48 281.13,70.07 278.81,70.07 275.62,66.88 271.56,66.88 268.02,63.34 256.79,63.34 256.21,62.77 250.66,62.77 247.41,59.51 236.8,59.51 v1(230.75,53.47)
  BOTTOM w0.1: v1(230.75,53.47) 226.91,53.47 224.97,51.53 222.41,51.53 220.47,53.47 v1(220.09,53.47) 219.8,53.18 218.87,53.18 215.86,50.16 209.42,50.16 206.75,52.83 204.34,52.83 203.96,52.45 v1(203.96,52.32) 203.83,52.32 201.8,50.29 193.84,50.29 190.79,53.34 v1(190.48,53.34) 189.99,52.85 189.99,51.69 189.19,50.9 189.19,47.15 182.67,40.62 176.83,40.62 174.49,38.29 J4H1.1
PWR_MON_I2C_SDA: length 271.7
  TOP w0.1: v1(190.48,52.65) 190.4,52.65 189.83,53.22 U4H1.D4 ; v1(220.34,52.7) 220.11,52.7 219.46,53.35 U3H1.D4 ; J4H1.2 174.24,30.73 R5J2.2 R4J1.1 R4J3.1 ; U4H2.D4 203.31,52.31 203.8,51.81 204.21,51.81 v1(204.72,52.32) ; U3H2.D4 230.11,53.35 v1(230.75,52.7) ; U1E2.D4 284.08,153.81 v1(284.48,153.41) R1E23.2 ; v1(289.17,142.11) 288.67,141.6 286.38,141.6 285.87,142.11 285.87,143.53 284.74,144.66 U1E3.D4 ; v1(292.35,159.89) 292.12,159.89 291.47,160.54 U1E1.D4
  LAY5 w0.125: v1(230.75,52.7) 237.06,59.01 247.61,59.01 248.56,59.96 254.63,59.96 256.67,62 272.92,62 274.32,63.4 274.32,64.87 279.01,69.57 281.79,69.57 284.63,72.41 284.63,74.32 292.16,81.85 292.16,90.74 294.07,92.65 294.07,97.05 292.86,98.26 292.86,100.81 293.62,101.58 293.62,103.73 294.14,104.25 294.14,113.33 293.62,113.85 293.62,116.13 294.14,116.65 294.14,121.35 291.73,123.76 291.73,129.96 292.7,130.93 292.7,137.37 293.56,138.23 293.56,140.27 291.08,142.75 289.81,142.75 v1(289.17,142.11) 289.17,146.18 287.02,148.33 287.02,152.4 285.52,153.9 284.96,153.9 v1(284.48,153.41) 284.47,153.42 284.47,154.04 284.86,154.43 285.87,154.43 286.76,153.54 289.17,153.54 292.6,156.97 292.6,159.64 v1(292.35,159.89)
  BOTTOM w0.1: v1(230.75,52.7) 226.82,52.7 225.17,51.05 221.99,51.05 v1(220.34,52.7) 219.07,52.7 216.06,49.69 209.22,49.69 206.59,52.32 v1(204.72,52.32) 204.21,51.81 203.99,51.81 202,49.82 193.65,49.82 190.89,52.58 190.56,52.58 v1(190.48,52.65) 190.48,50.54 190.24,50.31 190.24,47.5 182.88,40.13 177.03,40.13 176.02,39.11 176.02,32.51 J4H1.2
PWRBTN_EC_IN_N: length 292.6
  TOP w0.1: R8F36.2 35.17,106.17 v1(34.67,105.66) 34.67,105.15 33.8,104.29 U8F6.127 ; J6J2.127 130.12,12.14 130.12,11 v1(129.92,10.79) ; R8H46.1 38.98,40.13 38.35,39.5 v1(34.54,39.5) ; R5H7.2 v1(145.79,37.59) 146.48,36.91 150.19,36.91 151.13,37.84 R5H10.2
  LAY5 w0.125: J8J13.1 26.41,8 33.9,8 34.54,8.63 34.54,9.65 v1(34.29,9.9) ; v1(34.29,31.49) 34.92,32.13 36.83,32.13 39.11,29.84 49.76,29.84 49.89,29.7 61.7,29.7 63.74,31.75 65.65,31.75 66.17,32.26 74.8,32.26 78.65,28.41 99.27,28.41 103.3,24.38 106.29,24.38 109.47,27.56 114.42,27.56 114.71,27.27 128.6,27.27 135.23,33.91 142.11,33.91 v1(145.79,37.59)
  LAY6 w0.125: v1(34.29,9.9) v1(34.29,31.49) 34.29,39.24 v1(34.54,39.5) 34.29,39.75 34.29,46.84 37.97,50.52 37.97,56.64 36.95,57.66 36.95,65.4 35.17,67.18 35.17,67.77 34.92,68.03 34.92,71.5 35.94,72.52 35.94,74.16 34,76.1 34,89.41 33.52,89.9 33.52,92.73 33.73,92.94 33.73,104.48 34.67,105.41 v1(34.67,105.66)
  LAY8 w0.1: v1(129.92,10.79) 130.05,10.79 130.68,11.43 132.46,11.43 134.23,13.21 134.23,14.6 136.01,16.38 138.92,16.38 139.95,17.41 139.95,25.39 145.79,31.23 v1(145.79,37.59)
PWRBTN_EC_OUT_N: length 281.6
  TOP w0.1: v1(20.32,99.95) 19.68,99.95 18.54,101.09 U8F6.42 17.02,101.09 16.12,101.98 15.74,101.98 15.36,102.36 R9F32.2 ; J6J2.63 v1(119.96,12.14) ; R5H15.2 v1(148.97,40.13)
  LAY5 w0.125: v1(19.3,33.4) 19.56,33.66 22.32,33.66 23.72,32.25 33.68,32.25 34.05,32.63 37.03,32.63 37.54,32.13 45.46,32.13 47.25,30.34 51.19,30.34 51.96,31.11 62.31,31.11 63.96,32.76 75.01,32.76 78.86,28.92 99.86,28.92 103.89,24.89 106.09,24.89 109.26,28.06 114.63,28.06 114.92,27.78 128.39,27.78 135.02,34.41 140.71,34.41 145.16,38.86 147.7,38.86 v1(148.97,40.13)
  LAY6 w0.125: v1(20.32,99.95) 20.32,99.82 19.13,98.63 19.13,81.38 18.41,80.67 18.41,70.61 19.2,69.82 19.2,65.69 19.75,65.15 19.75,49.68 18.92,48.86 18.92,40.82 19.68,40.06 19.68,33.78 v1(19.3,33.4) ; v1(119.96,12.14) 120.67,11.43 130.81,11.43 131.69,10.54 131.69,9.4 134.49,6.6 144.6,6.6 145.54,7.54 145.54,9.52 146.93,10.92 146.93,22.1 148.33,23.49 148.33,29.21 148.59,29.46 148.59,39.75 v1(148.97,40.13)
PWRBTN_N: length 298.5
  TOP w0.1: v1(152.14,44.58) 150.11,42.54 SW5H2.1 148.59,41.4 147.95,40.77 v1(147.95,40) C5H1.1 R5H8.1 R5H7.1 R5H14.2 144.65,41.91 144.01,42.54 SW5H2.2
  LAY3 w0.1: v1(152.14,44.58) 152.52,44.96 167.47,44.96 168.39,44.04 183.73,44.04 187.12,47.44 193.56,47.44 200.64,54.51 203.01,54.51 203.6,55.1 211.23,55.1 211.69,54.64 213.99,54.64 215.26,53.37 215.26,51.49 218.83,47.92 235.84,47.92 236.5,48.58 252.21,48.58 256.78,44.01 263.35,44.01 267.21,47.88 271.96,47.88 272.68,48.61 281.01,48.61 283.33,50.93 283.33,54.35 v1(283.46,54.48)
  LAY5 w0.125: v1(147.95,40) 145.94,40 140.6,34.66 134.92,34.66 128.28,28.03 115.02,28.03 114.65,28.4 109.17,28.4 105.91,25.14 104.01,25.14 99.99,29.17 78.96,29.17 75.11,33.02 63.86,33.02 62.2,31.36 51.3,31.36 v1(51.01,31.08)
  LAY6 w0.125: v1(51.01,31.08) 50.92,30.99 50.92,12.32 48.51,9.9 48.51,8.1 J8J13.23
PWRBTN_TTK_N: length 3.1
  TOP w0.1: J7G1.5 64.55,64.9
PWRGD_3V_EC: length 21.1
  TOP w0.1: R6J26.1 v1(114.93,7.87) ; J6J2.117 v1(128.85,14.68)
  LAY6 w0.125: v1(128.85,14.68) 128.14,13.97 119.76,13.97 118.68,12.89 118.68,9.88 117.48,8.68 117.48,7.75 116.96,7.24 115.57,7.24 v1(114.93,7.87)
PWRGD_3V_PU_HDR: length 2.6
  TOP w0.5: J8J6.3 32.51,14.6 R8J19.2
PWRGD_LED_D: length 1.7
  TOP w0.38: DS8H7.1 60.7,40.51
PWRGD_LED_DRV: length 2.3
  TOP w0.305: EU8H2.8 DS8H7.2
PWRGD_PS: length 430
  TOP w0.1: v1(31.36,44.45) 31.36,41.27 32.13,40.51 ; R8C59.1 27.3,201.8 v1(26.41,202.69) 26.25,202.85 21.43,202.85 20.95,203.33 16.41,203.33 16,203.73 13.74,203.73 13.46,203.45 10.28,203.45 v1(10.16,203.58) ; Q3G3.1 v1(224.66,78.36) ; v1(200.66,78.23) 202.43,76.45 C4G23.1 202.94,74.17 C4G24.1 R4G22.1 ; R8C36.1 v1(27.05,208.41)
  LAY5 w0.125: v1(224.66,78.36) 224.15,77.85 218.69,77.85 216.55,79.99 201.9,79.99 200.91,78.99 200.91,78.48 v1(200.66,78.23) 200.37,78.52 181.46,78.52 161.49,58.55 151.57,58.55 145.09,52.07 129.5,52.07 128.62,52.96 126.11,52.96 125.42,53.64 112.87,53.64 111.53,54.99 99.6,54.99 98.73,54.13 97.94,54.13 96.85,53.03 93.94,53.03 93.27,52.36 91.34,52.36 90.52,51.54 86.34,51.54 85.34,50.54 78.46,50.54 76.54,48.63 75.04,48.63 74.9,48.76 73.17,48.76 71.65,47.24 68.85,47.24 67.84,46.22 60.17,46.22 59.54,46.86 57.04,46.86 56.02,45.84 54.07,45.84 53.95,45.97 46.35,45.97 45.59,45.21 43.43,45.21 42.92,44.7 36.44,44.7 35.81,44.07 31.74,44.07 v1(31.36,44.45) 30.98,44.83 26.51,44.83 21.45,49.89 21.45,51.98 21.84,52.37 21.84,57.56 17.67,61.72 17.67,66.8 17.01,67.46 17.01,69.47 16.63,69.85 16.63,70.36 16.51,70.48 v1(16.51,71.25)
  LAY6 w0.125: v1(8.63,74.8) 7.23,76.21 7.23,99.05 7.49,99.31 7.49,99.69 7.16,100.02 7.16,120.12 8.07,121.03 8.07,136.92 9.4,138.26 9.4,141.45 10.16,142.21 10.16,152.64 7.29,155.51 7.29,160.71 9.52,162.94 9.52,170.18 8.5,171.2 8.5,201.93 v1(10.16,203.58) ; v1(27.05,208.41) 27.17,208.28 27.17,204.72 26.67,204.21 26.67,202.94 v1(26.41,202.69)
  BOTTOM w0.1: v1(16.51,71.25) 16.25,71.25 13.71,73.79 9.65,73.79 v1(8.63,74.8)
PWRGD_PS_1G97: length 6.2
  TOP w0.1: R8C59.2 29.21,201.17 30.98,201.17 31.24,201.42 C8C19.1 ; C8C19.1 31.62,201.8 31.7,201.88 32.33,201.88 32.44,201.99 U8C3.3 ; C8C19.1 R8C55.1
PWRGD_PS_OPT: length 14.7
  TOP w0.1: U8C3.4 32.87,201.42 v1(32,201.42) ; R8C68.1 v1(32,199.52) ; R8C82.1 38.1,194.44 R8D1.1 36.95,194.44 v1(36.7,194.69)
  BOTTOM w0.1: v1(36.7,194.69) 36.06,194.69 32,198.75 v1(32,199.52) 31.49,200.02 31.49,200.91 v1(32,201.42)
PWRGD_PS_OPT_RC: length 2.3
  TOP w0.1: R8D2.1 C8D1.1 R8C82.2
PWRGD_PS_R: length 8.6
  TOP w0.1: 203.83,72.39 204.21,72.39 208.53,68.07 J4G1.8
PWRGD_PS_SMBUS_ISOLATE: length 216.3
  TOP w0.1: Q7C1.6 83.43,224.53 83.05,224.15 ; 83.05,224.15 83.05,227.84 Q7B10.1 83.31,229.61 83.31,231.52 Q7B9.1 ; 83.05,224.15 83.51,223.7 83.51,221.31 v1(83.97,220.85) ; v1(111.88,102.61) 111.88,98.3 109.6,96.01 Q6G2.1 Q6G1.1
  LAY5 w0.125: v1(83.97,220.85) 84.96,220.85 91.82,213.99 92.83,213.99 93.34,214.5 94.31,214.5 97.26,211.55 118.2,211.55 119.88,213.23 121.56,213.23 123.04,214.71 125.36,214.71 126.21,213.87 128.13,213.87 130.42,211.58 130.42,208.95 131.06,208.32 131.06,202.79 132.2,201.65 132.2,196.56 132.42,196.34 132.42,192.7 131.89,192.17 131.89,191.28 130.94,190.33 130.94,185.93 130.44,185.43 130.44,184.57 129.81,183.94 129.81,179.73 131.82,177.72 131.82,176.46 132.77,175.5 132.77,171.72 133.95,170.55 133.95,168.88 133.13,168.06 133.13,164.77 132.34,163.97 132.34,160.18 139.76,152.76 139.76,137.96 133.84,132.04 133.84,124.28 128.81,119.25 126.94,119.25 124.93,121.26 123.7,121.26 121.82,119.37 119.7,119.37 114.06,113.73 114.06,109.99 113.73,109.67 113.73,107.26 113.41,106.93 112.64,106.93 112.39,106.68 112.39,103.5 111.88,103 v1(111.88,102.61)
PWRGD_PS_U6LH_PN8: length 1.9
  TOP w0.1: U8C4.4 34.67,195.84 35.05,196.21 R8C79.1
PWRGD_VCCSFR_OC: length 102.9
  TOP w0.1: R5E12.1 156.46,152.14 154.94,150.62 150.36,150.62 149.98,151 149.98,152.17 v1(149.47,152.68) ; v1(151.51,154.48) 151.53,154.51 151.56,154.51 153.89,156.84 R5E4.1 ; v1(153.03,197.48) R5C61.1 ; R5C25.2 v1(164.97,207.26)
  LAY5 w0.125: v1(151.51,154.48) 151.48,154.48 151.46,154.46 149.44,154.46 148.89,153.91 148.89,153.26 v1(149.47,152.68) ; v1(153.41,209.04) 153.41,210.82 155.57,212.98 159.63,212.98 160.14,212.47 160.14,209.93 158.36,208.15 158.36,206.63 158.87,206.12 162.71,206.12 163.81,207.23 164.93,207.23 v1(164.97,207.26)
  LAY6 w0.125: v1(149.47,152.68) 149.27,152.68 148.99,152.96 148.99,153.54 149.22,153.77 149.22,157.07 148.99,157.3 148.99,161.85 151.22,164.07 151.22,166.83 151.5,167.12 151.5,186.84 152.65,187.98 152.65,192.98 152.37,193.26 152.37,196.82 v1(153.03,197.48) 153.03,201.67 153.67,202.31 153.67,207.01 153.92,207.26 153.92,208.53 v1(153.41,209.04)
PWRGOOD_3.3V_TTK: length 1
  TOP w0.1: R7H7.1 R7H1.2
PWRGOOD_TTK: length 4.5
  TOP w0.1: J7G1.15 70.9,66.84 70.48,66.42 70.48,65.32 70.9,64.9 69.89,64.9
Q1LH_PIN5: length 4
  TOP w0.1: Q8C12.1 38.35,197.86 38.22,197.74 R8C75.1 37.33,197.23 36.57,197.23 R8C79.2
Q4TS_VDDQ: length 4.2
  TOP w0.305: Q2G1.3 251.14,82.99 R2G13.2
Q5D1BV_PIN5: length 3.8
  TOP w0.1: Q8C11.5 49.26,201.41 49.4,201.55 R8C57.2 48.76,201.93 48.64,202.06 Q8C11.6
Q7G10_P1_P3: length 1.8
  TOP w0.1: Q8C12.5 40.74,197.21 40.64,197.31 40.64,197.76 40.74,197.86 Q8C12.6
Q7G10_PIN5: length 2.1
  TOP w0.1: Q8C12.4 41.81,196.56 41.93,196.44 41.93,195.99 R8D2.2
Q7PR_PIN2: length 4
  TOP w0.1: C8C18.1 R8C46.2 37.84,205.99 38.22,205.61 Q8C8.1
Q7PR_PIN6: length 10.9
  TOP w0.1: 42.47,205.74 43.81,205.74 44.83,206.75 Q8C5.1 ; 42.47,205.74 U8C2.2 ; 42.47,205.74 40.89,205.74 40.13,206.5 Q8C8.3 39.17,207.33 39.11,207.39 R8C38.2
Q12LH_BF_CUT: length 31
  TOP w0.1: Q8C6.3 51.3,206.31 v1(51.3,206.5) ; Q8C3.2 Q8C4.2 30.6,208.91 31.62,208.91 32.63,209.93 38.92,209.93 38.99,210 42.63,210 43.05,209.58 44.53,209.58 44.99,210.04 51.04,210.04 v1(51.3,210.31)
  BOTTOM w0.1: v1(51.3,206.5) v1(51.3,210.31)
Q28BV_PIN1: length 8.8
  TOP w0.508: Q4H3.1 177.67,57.75 v1(176.68,57.75) ; Q4H3.4 180.56,55.34 v1(180.59,55.37) 180.61,55.34 181.32,55.34 R4H27.1
  BOTTOM w0.508: v1(176.68,57.75) 179.1,55.34 180.56,55.34 v1(180.59,55.37)
Q28BV_PIN2: length 4.7
  TOP w0.1: R4H12.2 180.84,57.15 178.68,57.15 178.35,56.82 178.35,56.18 178.16,55.99 Q4H3.2
Q28BV_PIN3: length 3.1
  TOP w0.305: Q4H3.6 179.07,56.64 178.68,56.26 178.68,54.35 R4H30.2
Q28BV_PIN6: length 2.9
  TOP w0.508: Q4H3.3 177.64,55.37 175.89,55.37 R4H29.1
Q36BV_PIN2: length 4.3
  TOP w0.508: R4H48.2 178.94,50.54 178.94,51.94 Q4H5.1
Q36BV_PIN4: length 1.3
  TOP w0.508: R4H50.2 Q4H4.2
Q41BV_PIN2: length 7.4
  TOP w0.1: Q8D12.1 38.98,182.62 37.84,183.77 R8D36.1 37.08,184.15 37.33,184.4 C8D13.1 37.33,185.42 37.08,185.67 R8D23.2
Q41BV_PIN2_R: length 6.9
  TOP w0.1: R8D23.1 35.43,186.05 34.95,185.57 34.95,183.62 35.56,183.01 CR8D1.2 CR8D1.1
Q41BV_PIN3: length 2.5
  TOP w0.1: R8D35.1 34.29,183.39 34.03,183.13 33.27,183.13 33.08,182.94 Q8D11.3
Q41BV_PIN3_R: length 4
  TOP w0.1: R8D34.2 31.49,183.26 32.89,183.26 R8D35.2 R8D28.1
Q41BV_PIN6: length 2.5
  TOP w0.1: Q8D12.3 39.94,182.94 39.75,183.13 38.98,183.13 38.73,183.39 R8D37.1
Q41BV_PIN6_R: length 2.4
  TOP w0.1: R8D29.1 R8D37.2 R8D30.2
Q47BV_PIN5: length 7.3
  TOP w0.1: Q4H1.5 Q4H1.2 176.29,58.4 R4H6.1 ; 175.89,59.94 R4H6.1 ; R4H6.1 175.89,56.51
Q18141_PIN6: length 6.6
  TOP w0.1: Q7A1.6 65.53,258.82 Q7B1.6 66.92,258.82 67.05,258.7 67.05,258.17 ; 68.07,256.67 68.07,257.43 67.32,258.17 67.05,258.17 ; 67.05,258.17 Q7B1.5
Q161258_PIN1: length 1.4
  TOP w0.1: Q8G4.1 R8G42.2
Q161310_PIN1: length 3.8
  TOP w0.1: Q8G1.1 57.91,95.38 56.51,93.98 R8G9.2
Q182122_PIN3: length 22.8
  TOP w0.1: Q7B6.3 67.11,250.95 Q7B5.2 62.71,251.87 62.71,255.36 62.29,255.78 60.7,255.78 60.47,256 60.47,260.25 60.7,260.48 63.11,260.48 63.43,260.79 63.43,261.68 63.62,261.87 65.91,261.87 66.29,261.49 Q7A1.3
Q_1G74_22: length 2.9
  TOP w0.1: U8D6.5 39.14,169.9 38.73,170.31 37.85,170.31 37.59,170.57 U8D8.6
R2Q1_GRNLED_BRD: length 1.6
  TOP w0.1: Q8G6.1 29.84,79.75 29.46,79.37 R8G47.2
R2Q1_GRNLED_HDR: length 1.6
  TOP w0.1: Q8G5.1 25.65,79.75 25.14,79.25 R8G46.2
RCIN_ESPI_ALRT1_HDR_N: length 136.1
  TOP w0.1: R7E54.2 75.1,132.25 73.46,132.25 73.01,131.8 70.56,131.8 70.23,131.47 70.23,130.75 68.63,129.15 68.63,127.56 68.07,127 v1(68.07,126.87) ; J7J1.23 106.29,30.22 105.15,31.37 v1(105.15,33.78)
  LAY3 w0.1: v1(68.07,126.87) 69.26,125.67 69.26,115.88 73.89,111.26 73.89,109.22 75.29,107.83 75.29,105.29 77.34,103.23 81.93,103.23 83.82,101.34 83.82,99.57 84.32,99.06 87.35,99.06 89.25,97.15 91.31,97.15 92.71,95.76 97.16,95.76 100.43,92.5 100.43,91.97 v1(102.1,90.3)
  LAY8 w0.1: v1(105.15,33.78) 106.38,35 106.38,44.02 107.06,44.71 107.06,61.17 104.22,64.01 104.22,85.13 102.74,86.61 102.74,89.66 v1(102.1,90.3)
RCIN_ESPI_ALRT1_N: length 24.4
  TOP w0.089: U6E1.BE39 92.44,140.01 91.68,140.01 91.64,139.98 90.64,139.98 90.51,139.84 88.1,139.84 87.08,138.83 85.1,138.83 81.86,135.58
  TOP w0.1: 81.86,135.58 81.81,135.53 78.82,135.53 77.02,133.73 R7E52.1 R7E54.1 76.7,132.71 76.45,132.46 75.73,132.46 75.29,132.03 73.55,132.03 72.84,131.32 R7E57.2
RCIN_N_EC: length 235.2
  TOP w0.1: v1(68.07,127.89) 68.19,127.89 68.4,128.09 68.4,129.24 70,130.84 70,131.6 70.43,132.03 72.91,132.03 73.36,132.48 74.56,132.48 R7E52.2 ; U8F6.49 21.19,98.29 22.98,100.07 v1(28.73,100.07) ; J6J2.84 v1(123.77,16.97)
  LAY3 w0.1: v1(68.07,127.89) 69.49,126.46 69.49,115.98 74.12,111.35 74.12,109.32 75.51,107.92 75.51,105.38 77.44,103.46 83.27,103.46 89.34,97.38 91.4,97.38 92.8,95.98 97.26,95.98 101.29,91.95 114.1,91.95 122.55,83.5 122.55,82.55 v1(123.69,81.41)
  LAY8 w0.1: v1(123.77,16.97) 125.34,18.54 125.34,23.94 128.9,27.5 128.9,31.46 126.78,33.58 123.64,33.58 121.74,35.48 121.74,49.07 120.94,49.88 120.94,56.9 118.87,58.96 118.87,76.59 v1(123.69,81.41)
  BOTTOM w0.1: v1(28.73,100.07) 28.76,100.1 28.76,100.92 32.31,104.47 32.31,105.4 34.32,107.41 35.78,107.41 36.9,108.53 39.7,108.53 44.7,113.54 44.7,114.87 46.51,116.68 55.55,116.68 64.82,125.96 66.14,125.96 v1(68.07,127.89)
REAR_FAN_CTRL: length 5.3
  TOP w0.1: Q9C2.3 10.73,209.36 7.87,206.5 J9C1.4
REAR_FAN_CTRL_EC: length 364.8
  TOP w0.1: v1(13.58,211.33) R9C8.2 R9C9.1 ; J6J2.157 v1(136.23,14.68) ; U8F6.47 16.79,99.09 16,98.3 14.22,98.3 13.84,97.92 10.54,97.92 v1(9.77,97.15)
  LAY3 w0.1: v1(107.18,10.67) 107.03,10.82 101.94,10.82 98.28,7.16 83.03,7.16 82.11,6.24 72.06,6.24 71.52,6.78 70.04,6.78 66.15,10.66 41.41,10.66 41.03,11.04 21.59,11.04 18.28,14.35 14.42,14.35 12.9,15.87 12.9,17.46 10,20.35 10,32.74 7.9,34.84 4.21,34.84 2.84,36.22 2.84,95.55 4.44,97.15 v1(9.77,97.15)
  LAY6 w0.125: v1(136.23,14.68) 134.2,12.65 132.3,12.65 130.81,14.14 130.81,15.87 130.2,16.48 122.07,16.48 121.72,16.83 116.92,16.83 116.58,16.48 115.84,16.48 115.44,16.89 114.3,16.89 113.89,16.48 109.25,16.48 106.68,13.91 106.68,11.17 v1(107.18,10.67) ; v1(9.77,97.15) 9.9,97.28 9.9,98.93 9.52,99.31 8.58,99.31 7.73,100.16 7.73,107.05 9.47,108.79 9.47,119.05 8.57,119.95 8.57,136.72 9.9,138.05 9.9,141.24 10.67,142 10.67,147.68 11.55,148.56 11.55,150.62 11.04,151.13 11.04,153.54 9.9,154.68 9.9,170.16 8.76,171.3 8.76,190.13 14.09,195.46 14.09,210.82 v1(13.58,211.33)
REAR_FAN_PWM_R: length 1.6
  TOP w0.1: Q9C2.1 12.95,208.53 R9C11.1
REAR_FAN_R_CTRL: length 2.7
  TOP w0.1: R9C10.2 R9C9.2 13.97,209.55 13.19,210.32 12.82,210.32
REAR_FAN_TACH: length 3
  TOP w0.1: C9C6.1 14.22,212.6 14.35,212.47 R9C6.1 R9C7.2
REAR_TACH_OUT: length 6.8
  TOP w0.1: J9C1.3 9.01,211.33 R9C5.2 R9C7.1
RECOVERY_CONFIGURE_PULLUP: length 7.1
  TOP w0.1: R8H75.2 35.43,34.54 35.17,34.29 35.17,29.72 J8J3.2
REV_FAB_ID0: length 6.4
  TOP w0.1: R8E21.2 30.86,151.26 29.33,151.26 28.95,150.87 R8E20.1 27.3,150.62 27.22,150.54 U8E3.4
REV_FAB_ID1: length 7
  TOP w0.1: R8E19.2 30.98,152.27 29.21,152.27 28.95,152.02 R8E18.1 28.95,151.51 28.29,150.85 27.3,150.85 26.96,151.19 U8E3.5
RING2_CONN: length 10.5
  TOP w0.2: J5A1.1 155.27,290.78 151.72,290.78 148.59,287.65 C5A3.1 148.59,286.18 FB5A1.2
RING2_FB_CONN: length 2.8
  TOP w0.2: R5A1.2 147.7,285.62 FB5A1.1 147.82,284.99 R5A4.2
RSMRST_N: length 20.5
  TOP w0.089: 90.45,131.18 93.87,134.61 93.87,135.21 93.83,135.26 93.83,135.66 U6E1.BA47
  TOP w0.1: R7F7.2 C7F3.1 80.57,125.35 83.25,128.03 87.32,128.03 90.45,131.16 90.45,131.18
RSMRST_PWRGD_EC_N: length 62.6
  TOP w0.1: v1(21.84,103.38) 22.82,104.36 U8F6.23 22.82,107.26 21.84,108.24 21.84,108.58 R9F18.1
  LAY5 w0.125: v1(21.84,103.38) 21.33,103.88 21.33,111.17 21.08,111.43 21.08,112.27 21.47,112.66 21.47,121.34 22.39,122.26 22.39,130.01 21.08,131.32 21.08,132.84 v1(20.57,133.35)
  BOTTOM w0.1: v1(20.57,133.35) 20.57,133.77 19.24,135.1 17.68,135.1 17.27,135.51 16.12,135.51 14.63,134.02 9.81,134.02 9.39,133.6 8.38,133.6 7.74,134.24 7.74,136.73 6.83,137.64 5.81,137.64 5.08,136.9 5.08,136.02 5.71,135.38 J9E9.3
RSMRST_PWRGD_N: length 314.2
  TOP w0.1: R8D84.2 41.2,167 40.88,166.69 40.19,166.69 39.37,167.51 38.35,167.51 37.71,166.88 30.6,166.88 29.97,166.24 U8D13.1 29.33,166.88 28.73,167.48 27.8,167.48 25.96,169.33 v1(20.52,169.33) ; TP9F3.1 20.95,110.74 20.95,110.36 21.46,109.85 ; TP9F3.1 20.19,111.38 19.3,110.49 18.66,110.49 18.03,109.85 17.52,110.36 17.52,111.76 17.14,112.14 16.63,112.14 16.38,111.89 16.38,110.62 v1(14.09,108.33) ; TP9F3.1 v1(20.32,112.39) ; v1(104.39,9.52) 109.73,9.52 J6J2.8 ; v1(16,8.76) 17.01,7.75 17.01,6.09 17.65,5.46 51.56,5.46 52.57,6.48 52.57,8.16 J8J13.30
  LAY3 w0.1: J8J13.30 54.61,8.03 54.61,6.48 54.86,6.22 58.78,6.22 60.94,4.06 68.58,4.06 69.72,2.92 71.12,2.92 73.4,5.21 77.85,5.21 80.13,2.92 86.1,2.92 86.99,3.81 88.51,3.81 89.16,4.46 97.04,4.46 101.47,8.89 103.75,8.89 v1(104.39,9.52)
  LAY6 w0.125: v1(14.09,108.33) 14.9,107.52 14.9,98.64 15.37,98.17 15.37,91.57 14.47,90.68 14.47,85.09 15.91,83.65 15.91,82.07 15.38,81.54 15.38,74.14 14.21,72.97 14.21,66.34 12.27,64.39 12.27,62.64 11.46,61.83 11.46,52.04 12.32,51.17 12.32,27.91 13.47,26.76 13.47,23.48 14.35,22.6 14.35,9.4 14.98,8.76 v1(16,8.76) ; v1(20.52,169.33) 21.69,168.15 21.69,157.61 21.2,157.12 21.2,149.46 21.97,148.7 21.97,141.62 23.36,140.23 23.36,131.94 24.91,130.39 24.91,124.83 20.95,120.87 20.95,113.03 v1(20.32,112.39)
RST_N_1G74_22: length 12.8
  TOP w0.1: U8D6.6 39.64,169.91 38.56,170.99 38.56,174.92 37.71,175.77 34.16,175.77 33.78,175.39 R8D65.2
RSVD1: length 2.6
  TOP w0.1: EU4B1.1 189.77,256.25 190.5,255.52 R4B16.2
RTC_RST_TTK_N: length 3.1
  TOP w0.1: J7G1.23 75.98,64.9
RX_IN: length 10.6
  TOP w0.1: J9B6.2 10.28,234.44 14.35,234.44 14.6,234.19 15.11,234.19 15.24,234.06 15.24,231.39 14.66,230.82 14.66,229.49
S3_LED_DRV: length 3.2
  TOP w0.203: DS8H3.2 51.56,44.7 51.81,44.96 52.57,44.96 53.26,45.64 EU8H1.8
S3_VTT_CNTL: length 4.3
  TOP w0.1: R2G39.2 R2G32.2 251.96,75.18 R2G34.1 250.26,75.87 U2G2.3
S4_LED_DRV: length 2.2
  TOP w0.203: DS8H5.2 54.86,45.08 54.46,45.48 EU8H1.11
S5_LED_DRV: length 2.5
  TOP w0.203: DS8H4.2 53.34,44.07 54.06,44.79 EU8H1.10
S_RAILS_PWRGD: length 5.8
  TOP w0.1: Q8D4.1 37.33,190.12 R8D12.1 R8D11.1 C8D3.1 34.03,189.61 Q8D3.1
SA_SET1_H: length 1.6
  TOP w0.2: R5B81.1 149.88,235.58 v1(149.83,235.64)
  BOTTOM w0.2: v1(149.83,235.64) 149.91,235.64 R5M12.2
SA_SET1_L: length 0.9
  TOP w0.2: R5B84.2 R5B86.1
SA_SET2_H: length 1.4
  TOP w0.2: v1(149.83,237.03) 150.42,237.03 R5B78.1
  BOTTOM w0.2: v1(149.83,237.03) 149.88,236.98 R5M11.2
SA_SET2_L: length 5
  TOP w0.2: v1(149.73,238.28) 149.73,238 149.98,237.74 151.71,237.74 152.27,238.3 R5B77.2
  BOTTOM w0.2: v1(149.73,238.28) 149.96,238.5 150.74,238.5 R5M7.1
SA_SET3_H: length 0.8
  TOP w0.2: R5B76.2 R5B75.1
SA_SET3_L: length 1.9
  TOP w0.2: R5B74.2 152.78,239.38 v1(152.78,239.01)
  BOTTOM w0.2: R5M9.1 v1(152.78,239.01)
SA_TSEN_H: length 2.7
  TOP w0.2: R5B57.1 156.71,247.01 R5B61.2
SA_TSEN_L: length 0.9
  TOP w0.2: R5B62.2 R5B68.1
SATA1B_DIRECT_RX_DN: length 3.5
  TOP w0.1: v1(142.51,4) 142.51,5.61 J5J2.5
  BOTTOM w0.1: v1(142.51,4) 142.2,4.31 142.2,5.04 C5W3.2
SATA1B_DIRECT_RX_DP: length 3.6
  TOP w0.1: v1(141.68,4) 141.68,5.63 J5J2.6
  BOTTOM w0.1: v1(141.68,4) 142,4.31 142,4.94 C5W4.2
SATA1B_DIRECT_TX_CMC_DN: length 3.9
  TOP w0.1: J5J2.3 145.28,5.08 145.82,4.55 145.82,4.24 145.57,4 v1(145.49,4)
  BOTTOM w0.1: v1(145.49,4) 145.75,4.26 145.75,5.38 U5W1.4
SATA1B_DIRECT_TX_CMC_DP: length 3.9
  TOP w0.1: J5J2.2 146.55,5.08 146.02,4.55 146.02,4.29 v1(146.32,4)
  BOTTOM w0.1: v1(146.32,4) 145.95,4.36 145.95,5.36 U5W1.3
SATA1B_DIRECT_TX_DN: length 1.7
  BOTTOM w0.1: 145.41,7.49 145.77,7.14 145.77,6.07 U5W1.1
SATA1B_DIRECT_TX_DP: length 1.7
  BOTTOM w0.1: 146.3,7.49 145.97,7.16 145.97,6.07 U5W1.2
SATA1B_RX_DN: length 4.3
  TOP w0.1: J6H1.5 125.82,66.89 125.82,69.24 125.93,69.34 C6G12.2
SATA1B_RX_DP: length 4.3
  TOP w0.1: C6G11.2 125.52,69.34 125.62,69.24 125.62,66.44 125.2,66.01 J6H1.6
SATA1B_RX_R_DN: length 80.4
  TOP w0.1: R6G10.2 v1(126.49,71.91)
  BOTTOM w0.1: C5W3.1 142.11,6.6 142.11,9.65 142.74,10.29 142.74,13.71 143.32,14.3 143.32,15.16 143.63,15.46 143.63,31.75 146.55,34.67 146.55,39.11 134.74,50.93 134.74,58.34 135.5,59.1 135.5,65.02 133.22,67.31 129.63,67.31 125.82,71.12 125.82,71.8 125.93,71.91 v1(126.49,71.91)
SATA1B_RX_R_DP: length 80.4
  TOP w0.1: R6G9.2 v1(124.96,71.91)
  BOTTOM w0.1: C5W4.1 141.91,6.53 141.91,9.73 142.54,10.37 142.54,13.8 143.12,14.38 143.12,15.24 143.43,15.55 143.43,31.83 146.35,34.75 146.35,39.03 134.54,50.84 134.54,58.42 135.3,59.18 135.3,64.94 133.14,67.11 129.55,67.11 125.62,71.04 125.62,71.8 125.52,71.91 v1(124.96,71.91)
SATA1B_TX_CMC_DN: length 3.8
  TOP w0.1: L6G3.3 129.54,69.41 129.54,66.74 J6H1.3
SATA1B_TX_CMC_DP: length 3.8
  TOP w0.1: L6G3.4 129.76,69.37 129.76,66.76 130.51,66.01
SATA1B_TX_DN: length 1.9
  TOP w0.1: L6G3.2 129.56,70.07 129.56,71.1 129.42,71.25 C6G9.2
SATA1B_TX_DP: length 1.9
  TOP w0.1: L6G3.1 129.76,70.08 129.76,71.1 129.91,71.25 C6G10.2
SATA1B_TX_R_DN: length 76.1
  TOP w0.1: R6G5.2 v1(128.9,73.81)
  BOTTOM w0.1: v1(128.9,73.81) 129.46,73.81 129.56,73.71 129.56,71.7 136.07,65.19 136.07,58.5 135.25,57.69 135.25,52.32 147.24,40.33 147.24,23.32 146.48,22.56 146.48,19 145.72,18.24 145.72,13.01 145.16,12.44 145.16,10.16 145.75,9.57 145.75,8.72 C5W2.1
SATA1B_TX_R_DP: length 76.1
  TOP w0.1: R6G6.2 v1(130.42,73.81)
  BOTTOM w0.1: C5W1.1 145.95,8.73 145.95,9.65 145.36,10.24 145.36,12.36 145.92,12.92 145.92,18.16 146.68,18.92 146.68,22.48 147.44,23.24 147.44,40.41 135.45,52.41 135.45,57.6 136.27,58.42 136.27,65.28 129.76,71.78 129.76,73.71 129.87,73.81 v1(130.42,73.81)
SATA2_RX_DN: length 3.7
  TOP w0.1: J6G2.5 107.64,68.43 107.46,68.6 107.46,70.89 C6G8.2
SATA2_RX_DP: length 3.7
  TOP w0.1: J6G2.6 107.01,68.43 107.26,68.68 107.26,71.04 C6G7.2
SATA2_TX_CMC_DN: length 3.8
  TOP w0.1: L6G2.3 111.08,71.47 111.08,68.72 110.79,68.43 J6G2.3
SATA2_TX_CMC_DP: length 3.8
  TOP w0.1: J6G2.2 111.38,68.43 111.28,68.53 111.28,71.49 L6G2.4
SATA2_TX_DN: length 1.1
  TOP w0.1: L6G2.2 111.07,72.18 111.07,72.69 C6G5.2
SATA2_TX_DP: length 1.1
  TOP w0.1: C6G6.2 111.27,72.66 111.27,72.19 L6G2.1
SATA3_RX_DN: length 4.1
  TOP w0.1: J6G1.5 107.69,79.6 107.45,79.84 107.45,82.43 C6G4.1
SATA3_RX_DP: length 4.1
  TOP w0.1: J6G1.6 106.91,79.6 107.25,79.95 107.25,82.48 C6G3.1
SATA3_TX_CMC_DN: length 3.8
  TOP w0.1: J6G1.3 110.84,79.6 110.96,79.72 110.96,82.62 L6G1.3
SATA3_TX_CMC_DP: length 3.8
  TOP w0.1: L6G1.4 111.16,82.64 111.16,79.97 111.53,79.6 J6G1.2
SATA3_TX_DN: length 1.1
  TOP w0.1: L6G1.2 110.95,83.33 110.95,83.87 C6G1.2
SATA3_TX_DP: length 1.2
  TOP w0.1: C6G2.2 111.15,83.84 111.15,83.34 L6G1.1
SATA_DIRECT_DEVSLP: length 145.2
  TOP w0.1: J5J2.10 v1(131.31,7.49)
  LAY5 w0.125: v1(131.31,7.49) 131.31,8.13 130.52,8.92 127.14,8.92 126.53,9.53 125.02,9.53 124.77,9.28 118.73,9.28 118.47,9.03 113.26,9.03 113,8.76 112.11,8.76 111.61,9.27 105.92,9.27 105.15,10.03 103.12,10.03 102.74,9.65 v1(102.48,9.65)
  LAY6 w0.125: v1(96.77,98.17) 97.28,97.66 97.28,95.29 98.68,93.89 98.68,63.06 101.22,60.52 101.22,43.33 103.5,41.04 103.5,36.83 102.23,35.56 102.23,9.9 v1(102.48,9.65)
  BOTTOM w0.1: R7T12.2 97.66,116.84 97.66,114.68 97.38,114.4 97.38,108.04 98.12,107.3 98.12,104.04 97.66,103.58 97.66,98.68 97.15,98.17 v1(96.77,98.17)
SD3_CD_R_N: length 7.3
  TOP w0.1: R9C16.2 R9C15.2 R9C14.2 CR9C1.1 10.12,204.47 9.18,203.52 J9D1.10
SD3_CDB: length 108.9
  TOP w0.089: U6E1.BE8 92.07,154.92 91.68,154.92 91.48,154.72 91.18,154.72 91.13,154.77 90.1,154.77 88.92,155.95 v1(88.13,155.95)
  TOP w0.1: R9C16.1 16.12,204.6 v1(17.65,204.6)
  BOTTOM w0.1: v1(17.65,204.6) 19.93,202.31 19.93,201.81 23.49,198.26 23.49,194.25 24.87,192.87 26.01,192.87 26.39,192.49 31.75,192.49 32.79,191.45 38.42,191.45 39.25,190.63 40.51,190.63 41.62,189.51 45.78,189.51 47.19,188.1 47.63,187.66 48.54,187.66 52.19,184.01 53.4,184.01 53.72,183.69 53.72,181.23 55.29,179.65 55.29,176.18 56.46,175.01 56.46,171.38 57.22,170.62 59.98,170.62 63.68,166.91 63.68,162.83 65.92,160.59 68.31,160.59 69.17,159.73 73.11,159.73 74.53,158.31 75.85,158.31 76.56,157.59 82.23,157.59 83.97,155.85 88.03,155.85 v1(88.13,155.95)
SD3_CLK: length 100.9
  TOP w0.089: U6E1.BD8 92.66,154.93 92.35,154.93 92.14,154.72 91.75,154.72 91.56,154.53 90.05,154.53 89.62,154.96 88.51,154.96 87.5,155.97 v1(87.5,156.34)
  TOP w0.1: R9C21.1 v1(25.27,200.02)
  BOTTOM w0.1: v1(25.27,200.02) 24.71,199.46 24.71,197.72 24.9,197.53 24.9,194.86 24.51,194.46 24.51,193.9 25.07,193.34 26.21,193.34 26.59,192.96 31.95,192.96 32.51,192.4 38.48,192.4 39.62,191.26 44.7,191.26 45.19,190.77 45.59,190.77 46.42,189.93 46.42,189.54 47.82,188.14 48.74,188.14 52.39,184.49 53.59,184.49 54.19,183.89 54.19,181.42 55.77,179.85 55.77,177.53 57.02,176.27 57.02,171.7 57.4,171.32 58.8,171.32 59.18,171.7 59.69,171.7 64.16,167.23 64.16,163.02 66.11,161.07 70.54,161.07 71.4,160.2 73.31,160.2 74.73,158.78 76.04,158.78 76.76,158.07 82.43,158.07 84.16,156.34 v1(87.5,156.34)
SD3_CLK_R: length 5.6
  TOP w0.1: 19.68,197.57 20.78,197.57 21.46,198.25 CR9C4.1 22.6,198.88 R9C22.1 R9C21.2
SD3_CMD: length 100.5
  TOP w0.1: v1(95.15,153.25) U6E1.AW13 ; v1(26.79,193.42) 25.93,194.28 25.09,194.28 24.51,193.7 R9D1.1 ; v1(58.03,194.05) 59.81,194.05 60.16,193.7 65.12,193.7 v1(65.27,193.55)
  LAY5 w0.125: v1(58.03,194.05) 57.96,194.13 49.89,194.13 48.67,192.91 37.95,192.91 37.45,192.41 35.22,192.41 34.58,191.77 28.78,191.77 27.71,192.85 27.36,192.85 v1(26.79,193.42)
  BOTTOM w0.089: 92.2,155.45 93.09,155.45 93.21,155.32 93.59,155.32 93.98,155.7 94.36,155.7 94.69,155.37 94.69,155.04 95.15,154.57 v1(95.15,153.25)
  BOTTOM w0.1: v1(65.27,193.55) 65.27,191.7 66.67,190.31 66.67,186.69 66.58,186.6 66.58,182.58 67.1,182.06 67.1,179.71 75.66,171.15 77.74,171.15 83.69,165.21 84.01,165.21 86.23,162.99 86.23,161.67 87.75,160.15 87.75,159.2 91.5,155.45 92.2,155.45
SD3_CMD_R: length 5.1
  TOP w0.1: R9D1.2 23.38,193.53 21.86,193.53 21.59,193.8 CR9D1.1 21.59,194.31 20.53,195.37 J9D1.3
SD3_D0: length 103.3
  TOP w0.089: U6E1.BE9 92.37,154.47 92.14,154.25 91.82,154.25 91.72,154.15 89.89,154.15 89.46,154.58 88.23,154.58 87.7,155.11
  TOP w0.1: 87.7,155.11 84.12,158.69 84.12,161.56 83.38,162.3 82.2,162.3 82.04,162.46 79.85,162.46 78.23,164.08 78.23,165.73 77.66,166.3 76.09,166.3 74.35,168.05 73.49,168.05 72.08,169.45 66.59,169.45 65.28,168.15 v1(65.02,168.15) ; v1(26.41,200.02) 25.27,201.17 R9C20.1
  BOTTOM w0.1: v1(65.02,168.15) 64.41,168.15 59.18,173.38 59.18,173.63 57.84,174.97 57.84,176.62 56.59,177.87 56.59,180.19 55.02,181.77 55.02,184.23 53.94,185.31 52.73,185.31 46.45,191.59 45.56,191.59 44.4,192.75 42.6,192.75 41.61,193.74 33.71,193.74 30.34,197.1 30.2,197.1 29.54,196.45 29.4,196.45 29.26,196.59 29.26,196.73 29.92,197.39 29.92,197.53 29.77,197.67 29.63,197.67 28.98,197.01 28.84,197.01 28.69,197.16 28.69,197.3 29.35,197.95 29.35,198.09 29.21,198.24 29.07,198.24 28.41,197.58 28.27,197.58 28.13,197.72 28.13,197.86 28.78,198.52 28.78,198.66 28.64,198.8 28.5,198.8 27.85,198.15 27.7,198.15 27.56,198.29 27.56,198.43 28.22,199.08 28.22,199.23 27.42,200.02 v1(26.41,200.02)
SD3_D0_R: length 4.5
  TOP w0.1: 19.68,199.77 21.96,199.77 CR9C3.1 23.36,201.17 R9C20.2
SD3_D1: length 100.7
  TOP w0.089: 87.81,157.61 90.17,155.24 91.74,155.24 U6E1.BF8
  TOP w0.1: v1(26.41,200.79) 24.89,202.31 R9C19.1 ; 87.81,157.61 86.22,157.61 84.83,158.99 84.83,161.84 83.5,163.17 82.56,163.17 80.25,165.47 79.93,165.47 77.51,167.89 77.11,167.89 74.85,170.15 65.88,170.15 v1(65.02,169.29)
  BOTTOM w0.1: v1(65.02,169.29) 63.76,169.29 59.53,173.52 59.53,173.78 58.19,175.11 58.19,176.76 56.94,178.01 56.94,180.34 55.49,181.78 55.49,184.25 54.08,185.66 52.88,185.66 46.6,191.94 45.7,191.94 44.54,193.1 42.74,193.1 41.76,194.09 35.78,194.09 34.71,195.16 34.57,195.16 34.03,194.61 33.88,194.61 33.74,194.76 33.74,194.9 34.28,195.44 34.28,195.58 34.14,195.72 34,195.72 33.46,195.18 33.32,195.18 33.18,195.32 33.18,195.46 33.72,196 33.72,196.14 33.58,196.29 33.44,196.29 32.89,195.75 32.75,195.75 32.61,195.89 32.61,196.03 33.15,196.57 33.15,196.71 32.84,197.02 32.7,197.02 32.09,196.41 31.95,196.41 31.81,196.55 31.81,196.69 32.42,197.3 32.42,197.44 31.55,198.31 31.55,199.2 30.04,200.71 26.49,200.71 v1(26.41,200.79)
SD3_D1_R: length 4.5
  TOP w0.1: 19.68,200.87 21.03,200.87 CR9C2.1 22.6,201.8 23.11,202.31 R9C19.2
SD3_D2: length 100.2
  TOP w0.089: 86.48,156.84 86.48,156.61 88.32,154.77 89.54,154.77 89.97,154.34 91.64,154.34 91.78,154.47 U6E1.BF9
  TOP w0.1: v1(62.23,166.37) 64.51,168.65 65.3,168.65 66.45,169.8 72.23,169.8 73.63,168.4 75.05,168.4 76.07,167.38 77.53,167.38 79.79,165.12 80.11,165.12 82.55,162.69 83.49,162.69 84.48,161.7 84.48,158.85 86.48,156.84 ; R9D3.1 v1(25.27,191.26)
  BOTTOM w0.1: v1(62.23,166.37) 62.23,164.13 62.06,163.97 61.7,163.97 61.59,164.07 61.59,167 59.27,169.32 56.68,169.32 55.16,170.84 55.16,174.47 53.94,175.69 53.94,177.11 53.1,177.94 53.1,178.83 49.31,182.62 48.13,182.62 47.62,183.13 47.62,183.91 45.23,186.31 43.03,186.31 41.8,187.54 40.49,187.54 37.88,190.15 27.78,190.15 27.68,190.25 27.68,191.07 27.58,191.17 27.38,191.17 27.28,191.07 27.28,190.25 27.18,190.15 26.98,190.15 26.88,190.25 26.88,191.07 26.78,191.17 26.58,191.17 26.48,191.07 26.48,190.25 26.38,190.15 26.13,190.15 25.27,191.01 v1(25.27,191.26)
SD3_D2_R: length 4.9
  TOP w0.1: R9D3.2 22.22,191.26 CR9D3.1 21.97,191.77 21.84,191.9 21.59,191.9 20.32,193.17 J9D1.1
SD3_D3: length 102.1
  TOP w0.089: U6E1.BG8 90.16,154.98 88.21,156.94 v1(86.99,156.94)
  TOP w0.1: R9D2.1 25.27,193.04 v1(25.27,193.8)
  BOTTOM w0.1: v1(25.27,193.8) 26.16,194.69 27.5,194.69 27.6,194.79 27.6,195.88 27.7,195.98 27.9,195.98 28,195.88 28,194.79 28.1,194.69 28.37,194.69 28.65,194.41 28.65,194.27 28.26,193.88 28.26,193.74 28.4,193.6 28.54,193.6 28.93,193.99 29.07,193.99 29.51,193.55 29.79,193.55 29.89,193.65 29.89,195.25 29.99,195.35 30.19,195.35 30.29,195.25 30.29,193.65 30.39,193.55 30.59,193.55 30.69,193.65 30.69,195.25 30.79,195.35 30.99,195.35 31.09,195.25 31.09,193.65 31.19,193.55 33.4,193.55 34.03,192.91 40.84,192.91 41.34,192.4 44.25,192.4 45.41,191.24 46.31,191.24 52.59,184.96 53.79,184.96 54.67,184.09 54.67,181.62 56.24,180.05 56.24,177.72 57.49,176.47 57.49,174.53 58.16,173.86 58.16,172.85 58.54,172.46 59.59,172.46 64.63,167.43 64.63,163.22 66.31,161.54 70.73,161.54 71.6,160.68 73.5,160.68 74.93,159.26 76.24,159.26 76.96,158.54 82.73,158.54 83.41,157.86 84.32,157.86 85.21,156.97 86.96,156.97 v1(86.99,156.94)
SD3_D3_R: length 5
  TOP w0.1: R9D2.2 21.84,192.28 21.59,192.53 CR9D2.1 21.59,192.91 20.23,194.27 J9D1.2
SD3_RCOMP_1P8: length 5.7
  TOP w0.305: U6E1.BE5 92.71,156.38 v1(92.71,156.18)
  BOTTOM w0.38: v1(92.71,156.18) 92.57,156.04 91.61,156.04 88.9,158.75 R7R7.1
SD3_RCOMP_3P3: length 3.7
  TOP w0.305: U6E1.BE4 91.87,156.79 v1(91.87,156.61)
  BOTTOM w0.38: R7R6.1 89.78,158.7 v1(91.87,156.61)
SD3_WP: length 133.9
  TOP w0.089: U6E1.AV13 v1(95.89,152.98)
  TOP w0.1: R9C17.2 R9C12.2 R9C13.1 20.19,206.14 21.89,207.84 23.79,207.84 v1(24.74,208.79) ; v1(72.77,202.56) 66.14,202.56 66.01,202.69 66.01,205.51 64.26,207.26 54.1,207.26 v1(53.34,208.02)
  LAY5 w0.125: v1(53.34,208.02) 53.14,207.83 44.23,207.83 42.61,206.21 36.9,206.21 36.17,206.93 34.02,206.93 32.33,208.61 28.62,208.61 27.83,207.83 25.9,207.83 24.94,208.79 v1(24.74,208.79) ; v1(95.89,152.98) 95.89,153.41 95.12,154.18 95.12,154.68 94.74,155.07 94.74,155.45 94.48,155.7 94.48,156.59 94.23,156.84 94.23,169.04 96.36,171.17 96.36,185.57 94.23,187.7 94.23,196.49 v1(93.24,197.48)
  LAY6 w0.125: v1(72.77,202.56) 75.05,200.28 76,200.28 77.4,198.87 85.93,198.87 86.92,199.86 91.41,199.86 93.24,198.03 v1(93.24,197.48)
SD_PWR_EN_N: length 135.2
  TOP w0.1: R7E48.1 v1(70.48,135) ; v1(20.7,190.5) 20.98,190.78 25.93,190.78 R8D9.1 27.43,191.77 27.55,191.64 Q8D2.1
  LAY6 w0.125: v1(20.7,190.5) 19.43,189.23 19.43,179.45 18.54,178.56 18.54,169.54 19.55,168.53 19.55,156.57 20.82,155.3 20.82,149.31 21.57,148.57 21.57,141.49 22.98,140.08 22.98,131.57 v1(22.35,130.94)
  BOTTOM w0.1: R7R63.2 72.26,135.38 71.88,135 v1(70.48,135) 70.23,135 69.17,133.94 67.76,133.94 66.08,132.26 64.08,132.26 61.84,130.02 61.84,127.13 54.39,119.68 40.54,119.68 33.35,126.87 26.41,126.87 v1(22.35,130.94)
SD_PWR_EN_R: length 6.3
  TOP w0.203: R8D9.2 27.55,192.66 27.9,193 Q8D2.3 28.32,193.02 28.32,193.55 28.44,193.67 R8D7.2 29.08,194.18 29.59,194.69 29.59,195.32 29.06,195.85 U8C6.2
SD_VDD1_PWR_EN_N_ISH_GP_7: length 143.5
  TOP w0.089: U6E1.BD38 92.69,140.48 92.54,140.63 92.01,140.63 91.98,140.66 91.67,140.66 91.48,140.85 90.32,140.85 90.27,140.8 90.26,140.8 90.25,140.8 87.22,140.8 v1(86.56,140.13)
  TOP w0.1: v1(58.54,50.04) 56.38,50.04 55.88,50.54 R8H25.1
  LAY5 w0.125: v1(66.16,94.49) 66.29,94.49 68.33,92.45 71.75,92.45 74.42,95.12 80.48,95.12 81.52,96.16 81.52,97.71 81.29,97.94 81.29,101.25 81.78,101.75 81.78,111.12 80.26,112.65 80.26,118.62 81.65,120.01 81.65,125.53 83.43,127.31 83.43,130.43 84.83,131.82 84.83,133.98 86.23,135.38 86.23,139.8 v1(86.56,140.13)
  LAY6 w0.125: v1(66.16,94.49) 65.65,93.98 65.65,93.72 64.64,92.71 64,92.71 63.34,92.04 63.34,88.96 62.6,88.22 62.6,82.38 62.96,82.01 62.96,78.38 65.04,76.3 65.04,75.65 63.98,74.59 63.98,70.3 60.99,67.31 60.07,67.31 58.86,66.1 58.35,66.1 57.65,65.4 57.65,60.81 58.44,60.02 58.44,58.85 59.69,57.6 59.69,55.37 59.19,54.87 59.19,50.68 v1(58.54,50.04)
  BOTTOM w0.1: R7R63.1 76.45,135.38 76.83,135 77.47,135 78.11,135.64 79.76,135.64 80.51,136.4 81.91,136.4 85.47,139.95 86.38,139.95 v1(86.56,140.13)
SD_VDD2_PWR_EN_N: length 22.9
  TOP w0.089: 85.29,140.92 85.31,140.94 86.53,140.94 86.96,141.37 90.02,141.37 90.07,141.42 90.64,141.42 91.72,141.42 91.8,141.34 92.11,141.34 92.34,141.1 U6E1.BE36
  TOP w0.1: 85.29,140.92 81.1,136.73 78.3,136.73 77.72,136.14 77.12,136.14 76.54,135.57 74.64,135.57 74.46,135.38 72.89,135.38 72.51,135 R7E48.2
SER_CTS_N: length 2.8
  TOP w0.1: FB9C2.1 16.76,222.25 16.61,222.4 U9C1.8
SER_CTS_N_FB: length 14.5
  TOP w0.1: FB9C2.2 16.76,218.82 15.67,217.73 10.09,217.73 9.32,218.5 9.32,221.94 J9B7.6
SER_RTS_N: length 2.9
  TOP w0.1: 15.96,223.65 15.96,222.08 15.62,221.74 FB9C1.1
SER_RTS_N_FB: length 15.5
  TOP w0.1: FB9C1.2 15.62,218.82 14.75,217.96 10.19,217.96 9.55,218.6 9.55,224.25 J9B7.4
SER_RX_IN: length 3
  TOP w0.1: FB9B2.1 14.6,231.65 14.01,231.06 U9C1.13
SER_RX_IN_FB: length 15
  TOP w0.1: FB9B2.2 13.94,234.21 11.51,234.21 10.82,233.52 10.82,231.9 10.23,231.32 8.81,231.32 6.47,228.98 6.47,227.07 J9B7.3
SER_TX_OUT: length 2.8
  TOP w0.1: FB9B1.1 13.33,231.01 13.36,230.98 13.36,229.49
SER_TX_OUT_FB: length 15.5
  TOP w0.1: FB9B1.2 11.3,233.55 11.04,233.3 11.04,231.81 10.33,231.09 8.9,231.09 6.7,228.89 6.7,224.76 J9B7.5
SERIRQ_ESPI_ALERT0_EC: length 93
  TOP w0.1: v1(27.68,98.55) 25.81,98.55 23.31,96.04 18.82,96.04 18.66,95.89 U8F6.55
  LAY3 w0.1: v1(63.11,118.11) 62.17,117.17 62.17,116.04 68.6,109.62 68.6,106.34 79.41,95.53 v1(84.81,95.53)
  BOTTOM w0.1: v1(63.11,118.11) 58.61,118.11 55.31,114.81 48.5,114.81 45.45,111.76 43.96,111.76 38.37,106.17 34.41,106.17 34.16,105.92 34.16,105.68 29.47,100.98 29.47,99.32 28.95,98.8 27.94,98.8 v1(27.68,98.55) ; v1(84.81,95.53) 85.03,95.76 85.85,95.76 R7U2.2
SERIRQ_ESPI_CS1_HDR_N: length 108
  TOP w0.1: v1(94.1,35.56) 95.5,35.56 96.13,34.92 J7J1.16
  LAY8 w0.1: v1(94.1,35.56) 94.1,36.57 93.72,36.96 93.72,38.93 91.92,40.73 91.92,54.07 91.82,54.17 91.62,54.17 91.52,54.07 91.52,41.97 91.42,41.87 91.22,41.87 91.12,41.97 91.12,54.47 91.22,54.57 91.82,54.57 91.92,54.67 91.92,66.5 89.53,68.89 89.53,71.75 86.48,74.8 86.48,81.58 82.97,85.09 82.97,85.23 83.12,85.37 83.26,85.37 86.31,82.32 86.45,82.32 86.59,82.46 86.59,82.6 83.73,85.47 83.73,88.04 83.63,88.14 83.43,88.14 83.33,88.04 83.33,86.3 83.23,86.2 83.03,86.2 82.93,86.3 v1(82.93,94.87)
  BOTTOM w0.1: R7U6.2 v1(82.93,94.87)
SERIRQ_ESPI_CS1_MECC_N: length 124.3
  TOP w0.1: v1(104.14,33.78) 105.58,35.23 112.17,35.23 113.03,34.37 113.03,29.63 116.37,26.3 134.4,26.3 137.25,23.44 139.22,23.44 140.07,22.59 140.07,18.28 J6J2.179
  LAY8 w0.1: v1(90.29,94.74) 89.91,94.74 89.63,94.46 89.63,90.77 90.2,90.2 91.23,90.2 94.33,87.11 94.33,78.07 95.47,76.93 95.47,62 99.27,58.2 99.27,54.33 95.83,50.89 95.83,39.2 96.04,38.99 96.04,37.43 97.4,36.07 101.85,36.07 v1(104.14,33.78)
  BOTTOM w0.1: R7U7.2 v1(90.29,94.74)
SERIRQ_ESPI_CS1_N: length 82.1
  TOP w0.089: v1(95.19,141.25) U6E1.AW35
  BOTTOM w0.089: v1(95.19,141.25) 95.19,141.26 94.97,141.48 94.36,141.48 94.18,141.3 93.51,141.3 93.22,141.6 92.66,141.6 91.8,140.74
  BOTTOM w0.1: R7U7.1 88.2,94.68 85.65,94.68 85.47,94.87 R7U3.1 85.09,94.87 R7U6.1 84.02,95.42 82.59,95.42 82.06,94.89 79.26,94.89 78.66,95.49 78.33,95.49 75.93,97.88 75.93,99.05 73.11,101.87 73.11,103.04 72.31,103.84 72.31,110.48 69.14,113.65 69.14,118.82 R7T7.2 R7T6.2 69.14,120.7 69.14,123.52 69.88,124.26 69.88,128.78 72.87,131.77 72.87,133.51 73.4,134.04 75.24,134.04 75.52,133.76 77.76,133.76 78.1,133.42 79.34,133.42 80.28,134.36 82.1,134.36 86.32,138.59 87.15,138.59 88.84,140.27 91.33,140.27 91.8,140.74
SERIRQ_TPM_R: length 4.3
  TOP w0.1: R7G36.1 89.15,73.91 89.4,74.17 R7G34.1 90.17,73.36 89.95,73.15 J7G1.46
SET1_H: length 1.2
  TOP w0.2: R2B42.1 273.68,234.44 R2B40.2
SET1_L: length 1.3
  TOP w0.2: R2B46.2 274.37,232.92 273.6,233.68 R2B41.1
SET2_H: length 1.5
  TOP w0.2: R2B45.2 273.68,232.92 274.44,232.15 R2B48.1
SET2_L: length 1.3
  TOP w0.2: R2B47.1 273.68,232.15 274.44,231.39 R2B50.2
SET3_H: length 1.5
  TOP w0.2: R2B62.1 R2B61.2
SET3_L: length 1.5
  TOP w0.2: R2B60.2 R2B59.1
SET4_H: length 1.5
  TOP w0.2: R2C3.1 R2C2.2
SET4_L: length 1.5
  TOP w0.2: R2C5.2 R2C4.1
SET5_H: length 1.2
  TOP w0.2: R2C14.1 275.97,222.63 R2C19.2
SET5_L: length 1.2
  TOP w0.2: R2C16.1 277.36,222.12 276.73,222.76 276.73,222.88
SHM_TRIG_PLT_RST_R: length 157.2
  TOP w0.1: R9G7.2 v1(14.47,92.33) ; J7J1.5 83.43,25.65 84.45,24.64 v1(84.45,23.97)
  LAY5 w0.125: v1(84.45,23.97) 76.48,23.97 75.94,24.51 67.13,24.51 66.36,23.74 53.33,23.74 53.15,23.56 51.45,23.56 50.26,22.37 46.93,22.37 46.46,22.84 39.2,22.84 38.81,23.23 31.87,23.23 31.23,23.87 28.82,23.87 27.68,22.73 14.09,22.73 v1(13.71,22.35)
  LAY6 w0.125: v1(14.47,92.33) 12.27,90.13 12.27,82.27 14.88,79.66 14.88,74.34 13.71,73.18 13.71,68.45 13.33,68.07 12.7,68.07 12.44,67.82 12.44,65.28 11.77,64.6 11.77,62.85 10.96,62.04 10.96,51.39 11.95,50.4 11.95,24.3 13.71,22.53 v1(13.71,22.35)
  BOTTOM w0.1: R7W3.2 R7W4.2 84.45,26.03 84.58,25.91 84.58,24.1 v1(84.45,23.97)
SLEEVE_CONN: length 3.1
  TOP w0.2: J5A1.6 154.55,280.67 C5A7.1 153.46,279.78 FB5A4.2
SLEEVE_FB_CONN: length 2.7
  TOP w0.2: FB5A4.1 R5A15.2 R5A9.2
SLG_OUT_SMC_INITCLK_J: length 2
  TOP w0.1: EU8F1.6 22.24,119.87 R9F1.1
SLG_OUT_SMC_RST_N: length 1.7
  TOP w0.1: R9F2.1 21.59,119.37 EU8F1.7
SLOT2_WAKE_N: length 25.1
  TOP w0.1: R8B24.1 v1(45.14,235.27) ; v1(53.46,234.69) 58.05,234.69 J7B1.B11 61,237.64 63.14,237.64 64.69,236.09 66.04,236.09 R7B65.1
  LAY5 w0.125: v1(45.14,235.27) 45.59,234.82 53.34,234.82 v1(53.46,234.69)
SLOT3_LAN_WAKE_N: length 100.3
  TOP w0.1: v1(95.47,247.78) 95.42,247.82 R7B24.2
  LAY5 w0.125: v1(95.47,247.78) 95.47,247.75 94.41,246.69 87.52,246.69 85.06,249.15 83.41,249.15 81.09,251.46 73.97,251.46 73.66,251.14 72.79,251.14 71.18,252.76 70.73,252.76 69.36,254.13 66.63,254.13 65.61,253.11 v1(51.43,253.11)
  LAY6 w0.125: J8B1.B30 36.83,216.5 36.83,235.58 37.46,236.22 37.97,236.22 39.24,237.49 42.67,237.49 43.56,236.6 46.22,236.6 47.24,237.62 47.24,238.63 48.77,240.16 50.04,240.16 52.57,242.7 52.57,252.09 51.56,253.11 v1(51.43,253.11)
SLOT3_LANPHYPC: length 2.8
  TOP w0.1: J8B1.A32 44.85,212.98 R8C30.1 R8C32.1
SLOT3_SLP_LAN_N_R: length 11.4
  TOP w0.1: J8B1.A19 41.37,227.46 38.98,227.46 38.35,226.82 37.33,226.82 36.57,226.06 36.57,223.65 35.3,222.38 R8C10.1
SLOT3_SMBCLK: length 6.6
  TOP w0.1: R8B18.2 R8B15.2 35.43,243.46 35.81,243.08 37.08,243.08 37.23,242.92 39.4,242.92 J8B1.B5
SLOT3_SMDAT: length 14.2
  TOP w0.1: J8B1.B6 37.11,241.65 36.66,242.1 28.26,242.1 26.18,240.03 R9B26.2 R9B29.2
SLOT3_WAKE_N: length 13.5
  TOP w0.1: R8B19.1 35.05,238.89 35.43,238.5 38.1,238.5 39.68,236.92 J8B1.B11 40.4,237.36 42.54,237.36 43.05,236.85 R8B21.1 R8B22.1
SLOTM_EN: length 1.8
  TOP w0.25: R8G70.2 49.01,69.72 U8G3.2
SLP_A_EC_N: length 292.7
  TOP w0.1: U8E3.9 27.31,153.79 v1(27.43,153.67) 28.19,152.91 R8E17.2 ; J6J2.128 v1(130.63,10.54)
  LAY3 w0.1: v1(27.43,153.67) 23.74,153.67 13.46,143.38 13.46,139.32 10.56,136.42 10.56,109.49 9.45,108.38 4.88,108.38 2.61,106.11 2.61,36.13 4.12,34.62 7.8,34.62 9.77,32.64 9.77,20.26 12.67,17.36 12.67,14.63 14.92,12.39 16.19,12.39 17.76,10.82 40.93,10.82 41.31,10.44 66.05,10.44 69.94,6.55 71.43,6.55 71.97,6.01 82.2,6.01 83.12,6.93 98.37,6.93 102.03,10.59 105.14,10.59 106.51,9.22 110.56,9.22 112.65,7.13 114.8,7.13 115.85,6.08 126.41,6.08 127,6.67 127,7.77 127.5,8.28 127.5,8.39 128.39,9.27 128.65,9.27 129.66,10.29 130.38,10.29 v1(130.63,10.54)
SLP_LAN_N: length 569.8
  TOP w0.089: U6E1.BF40 92.01,139.6 90.8,139.6 90.65,139.44 88.24,139.44 87.08,138.29 85.83,138.29
  TOP w0.1: 85.83,138.29 85.2,138.29 81.78,134.87 v1(81.78,134.87) C7E14.1 R7E51.1 ; R6J20.2 v1(128.27,9.78) ; R4B6.1 170.59,255.31 169.33,255.31 168.65,254.62 163.45,254.62 162.28,255.79 155.21,255.79 153.15,253.73 148.06,253.73 145.61,251.28 126.86,251.28 125.91,252.22 120.14,252.22 v1(119.63,252.73) ; v1(34.92,221.61) 34.54,221.61 R8C10.2 ; R6A41.1 109.72,273.43 v1(108.07,273.43)
  LAY3 w0.1: v1(81.78,134.87) C7E14.1 75.56,130.3 75.56,123.13 71.65,119.22 71.65,114.46 74.57,111.54 74.57,109.51 75.97,108.11 75.97,105.57 77.63,103.91 83.46,103.91 89.53,97.83 91.59,97.83 92.99,96.44 97.45,96.44 99.63,94.25 112.44,94.25 122.21,84.48 123.22,84.48 124.33,83.37 124.33,80.77 v1(124.84,80.26)
  LAY5 w0.125: v1(81.78,134.87) 81.78,135.13 83.94,137.29 83.94,143 85.09,144.14 85.09,146.05 84.07,147.07 84.07,148.44 86.58,150.95 86.58,154.18 86.2,154.57 86.2,158.08 88.04,159.92 88.48,159.92 90.44,161.89 90.44,174.19 86.61,178.02 86.61,192.02 91.82,197.23 92.71,197.23 v1(93.21,196.72) ; v1(108.07,273.43) 107.56,273.94 92.4,273.94 92.15,273.68 88.9,273.68 86.42,271.21 v1(86.42,270.53) 86.4,270.51 86.23,270.51 85.97,270.76 85.97,271.14 82.16,274.95 67.56,274.95 65.27,272.67 v1(48.05,272.67)
  LAY6 w0.125: v1(93.21,196.72) 93.98,197.48 93.98,197.82 92.83,198.97 92.83,204.65 90.93,206.56 90.93,223.14 91.18,223.39 91.18,243.56 91.69,244.07 91.69,246.25 89.78,248.16 86.36,248.16 85.97,248.54 85.97,268.09 86.86,268.98 86.86,270 86.42,270.44 v1(86.42,270.53) ; v1(48.05,272.67) 48.05,268.27 46.35,266.57 46.35,257.17 47.37,256.15 47.37,254.63 47.01,254.28 47.01,252.7 48,251.71 48,249.17 46.99,248.16 46.99,244.85 44.83,242.69 43.45,242.69 42.56,241.8 39.13,241.8 38.24,240.92 37.23,240.92 36.13,239.82 36.13,236.67 35.44,235.98 35.44,222.13 v1(34.92,221.61)
  LAY8 w0.1: v1(128.27,9.78) 128.14,9.9 128.14,18.92 127.12,19.94 127.12,21.97 128.14,22.99 128.14,24.51 130.71,27.08 130.71,32.57 128.64,34.64 123.62,34.64 122.42,35.83 122.42,56.01 121.62,56.81 121.62,57.18 119.56,59.25 119.56,73.01 122.64,76.09 122.64,78.06 v1(124.84,80.26)
  BOTTOM w0.1: v1(108.07,273.43) 109.48,272.02 109.48,268.86 107.56,266.94 107.56,262 107.69,261.87 109.09,261.87 109.48,261.48 109.48,260.32 107.69,258.53 107.69,254.38 107.95,254.13 109.08,254.13 109.83,253.38 118.98,253.38 v1(119.63,252.73)
