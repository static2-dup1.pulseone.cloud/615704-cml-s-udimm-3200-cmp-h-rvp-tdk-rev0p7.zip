# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Nets (continued)
+V5S: C1C9.1 C4G17.1 C4G21.1 C5C31.1 C5D16.1 C9G6.1 CR3A1.1 CR3A1.2 CR4A7.1 CR4A7.2 EU4G1.1 EU4G1.2 EU4G1.3(S3) EU4G2.1 EU4G2.2 EU4G2.3(S3) EU5C3.9(VCC) EU5D2.9(VCC) F6G1.1 F6G2.1 F6G3.1 J1B2.34 J9H1.9(IO9) Q1A1.1 Q1C2.1 Q2A1.1 Q2A2.1 Q3B1.1 Q3B1.2 Q4G3.2(SRC) Q9G5.3 R1A3.1 R1B45.2(B) R1C15.1 R1C16.1 R2A1.1 R2C23.1 R3M45.1 R4G20.2 R4G25.1 R4H1.1 R4H2.1 R6J29.1 R9G33.1 R9H1.1 R9H2.1 R9H4.1 RT2A1.1
+V5S_DONGLE: R1A3.2(B) R2A32.1 R2A33.1
+V5S_HDMIC_CONN1: C2A2.1 C2A4.1 C2A5.1 CR2A3.3 J2A1.B18 R2A21.1 RT2A1.2(B)
+V5S_HDMID_CONN2: C2A1.1 C2A3.1 C2A6.1 CR2A2.3 J3A2.18 R2A1.2(B)
+V5S_R: J4G1.4 J4G1.6 J4G1.21 J4G1.22 J4G1.23 R4G20.1
+V5S_SATADOM_SATA1B: F6G3.2(B) J6H1.7 R6G12.1
+V5S_SATADOM_SATA2: F6G2.2(B) J6G2.7 R6G7.1
+V5S_SATADOM_SATA3: F6G1.2(B) J6G1.7 R6G2.1
+V12S: C3G25.1 C3G26.1 C3G29.1 EU1E1.5 EU1E2.5 EU6B1.5 EU6B2.5 EU8B1.5 EU8B2.5 EU8B3.5 EU8B4.5 R1B12.1 R3G41.2 R3H4.1 R3H8.1 R3H9.1 R3H19.1 R3H22.1 R3H27.1 R4G5.1 R4H7.1 R5C48.1 R6A77.1 R6J28.1 R7B2.1 R7H72.1 R8D17.1 R8D18.1 R9A23.1
+V12S_AUDIO: R9A23.2 R9B2.2(B)
+V12S_CPU: C1A1.1 C1A2.1 J1A1.5 J1A1.6 J1A1.7 J1A1.8(AIO8) J1A2.5 J1A2.6 J1A2.7 J1A2.8(AIO8) J1A3.3 J1A3.4(IO4) R1B1.1 R2C32.1 R4C19.2 R5B54.2 R5D29.2
+V12S_CPU_R1: C2B6.1 C2B12.1 C2B15.1 C2B17.1 C2B18.1 C2M2.1 C2M3.1 C3B25.1 C3B26.1 C3B27.1 C3B28.1 C3B30.1 C3B31.1 C3M10.1 C3M11.1 C3M12.1 C3M13.1 C3M14.1 C3M15.1 C3M16.1 C4B19.1 C4B23.1 C4B25.1 C4B26.1 C4B27.1 C4B29.1 C4M9.1 C4M10.1 C4M11.1 C4M12.1 C4M13.1 C4M14.1 CR1B3.2 EU2B2.8 EU2B2.9 EU2B3.8 EU2B3.9 EU2B4.8 EU2B4.9 EU3B1.8 EU3B1.9 EU3B2.8 EU3B2.9 EU3B3.8 EU3B3.9 EU4B3.8 EU4B3.9 EU4B4.8 EU4B4.9 R1B1.2 R1B14.1
+V12S_CPU_R2: C1D1.1 C1D2.1 C1D6.1 C1D7.1 C1D8.1 C1P1.1 C1P3.1 EU1D1.8 EU1D1.9 EU1D2.8 EU1D2.9 R2C32.2
+V12S_FAN: C1E7.1 C9C5.1 J1E3.2 J9C1.2 R1E25.1 R1E32.2 R9C5.1
+V12S_FAN_R: EU1E1.1 EU1E1.2 EU1E1.3(S3) EU1E2.6 R1E32.1
+V12S_PCIE_SLOT2: C7B6.1 C8B10.1 C8B13.1 C8B14.1 J7B1.A2 J7B1.A3 J7B1.B1 J7B1.B2 J7B1.B3 R8B10.2
+V12S_PCIE_SLOT2_R: EU8B1.6 EU8B3.1 EU8B3.2 EU8B3.3(S3) R8B10.1
+V12S_PCIE_SLOT3: C8B7.1 C8B8.1 C8B9.1 C8B12.1 J8B1.A2 J8B1.A3 J8B1.B1 J8B1.B2 J8B1.B3 R8B5.2
+V12S_PCIE_SLOT3_R: EU8B2.1 EU8B2.2 EU8B2.3(S3) EU8B4.6 R8B5.1
+V12S_PEG_SLOT: C5B12.1 C5B15.1 C5B16.1 C6B4.1 J5B2.A2 J5B2.A3 J5B2.B1 J5B2.B2 J5B2.B3 R6B20.2
+V12S_PEG_SLOT_R: EU6B1.6 EU6B2.1 EU6B2.2 EU6B2.3(S3) R6B20.1
+V12S_R: J4G1.10 J4G1.11 R3G33.1 R3G35.1 R3G36.1 R3G37.1 R3G38.1 R3G39.1 R3G40.1 R3G41.1
+VBAT_EC: C8F18.1 R8F35.1 R8F36.1 R8F50.2 U8F6.122
+VBAT_EC_MIX: R8F49.2(B) R8F50.1 R8F53.2(B)
+VBUS_USBC_CONN_BP: C4L1.1 C4L2.1 C5L1.1 C5L2.1 CR6A2.1(CATHODE) FB5A5.2(B) J4A1.A4 J4A1.A9 J4A1.B4 J4A1.B9(VBUS_B2)
+VBUS_USBC_CONN_BP_L: C6A33.1 EU5A1.13 FB5A5.1 Q6A3.5 R6A65.1
+VBUS_USBC_CONN_FP3: C6C3.1 C6C4.1 C6C5.1 C6C11.1 CR6A3.1(CATHODE) FB5A6.2(B) J6C4.P1 J6C4.P7 J6C4.P11
+VBUS_USBC_CONN_FP3_L: C5A29.1 EU5A1.3 FB5A6.1
+VCC0V9_SVR: C5A14.1 C5A21.1 C5A24.1 C5L6.1 C5L7.1 C5L13.1 C5L14.1 C5L15.1 C5L19.1 C5L23.1 C5L24.1 C5L28.1 C5L29.1 C5L31.1 C5L32.1 C5L33.1 C5L34.1 L5A2.2(INB) U5A2.E8 U5A2.H9 U5A2.H11 U5A2.H12 U5A2.H13 U5A2.H15 U5A2.H16 U5A2.J13 U5A2.L11 U5A2.L13 U5A2.M8 U5A2.M11 U5A2.M13 U5A2.N6 U5A2.N8 U5A2.N11 U5A2.N13 U5A2.R8 U5A2.R11 U5A2.R13 U5A2.R16 U5A2.T8 U5A2.T9 U5A2.T11 U5A2.T12 U5A2.T13 U5A2.T15 U5A2.T16
+VCC3V3_S0: C5A15.1 C5A18.1 C5A23.1 C5A25.1 C5L8.1 C5L25.1 R5A16.1 R5A17.2(B) R5A18.2(B) R5A44.2(B) R5L13.2(B) R5L15.2(B) U5A2.E6 U5A2.G1 U5A2.G2 U5A2.H2 U5A2.L6
+VCC3V3_SX: C5L3.1 C5L30.1 R5A16.2(B) R5A20.2(B) R5A26.1 R5A27.2(B) R5A40.2(B) R5A49.2(B) R5A57.2(B) R5L21.2(B) U5A2.F18 U5A2.R6
+VCC_EDP_AMOLED: J1A4.2 R1B13.1
+VCC_EDP_BKLT: C1B5.1 J1B2.31 J1B2.38 R1B12.2(B) R1B13.2(B)
+VCC_ISH_EEPROM: C7H4.1 R7H51.2(B) U7H3.8
+VCC_OBS_AB_PCH: J6H2.43 R6H32.2(B) R6H33.2(B)
+VCC_OBS_CD_PCH: J6H2.44(VCC_OBS_CD) R6H6.2(B) R6H7.2(B)
+VCCA_SUSCLK: R7F46.1 U7F1.1
+VCCA_XTAL_1P05: C6D24.1 C6D25.1 L6D4.2(INB) R6D50.2(B) R6D54.2(B) U6E1.P2 U6E1.P3
+VCCA_XTAL_1P05_L: L6D4.1 R6D40.2 R6D50.1
+VCCAMPHYPLL_1P05: C6F1.1 C6F3.1 C6F4.1 L6F1.2(INB) R6F10.2(B) U6E1.C49 U6E1.D49 U6E1.E49
+VCCAMPHYPLL_1P05_L: L6F1.1 R6F10.1 R6F13.2(B) R6F16.2
+VCCAZPLL_1P05: C6D14.1 C6D15.1 L6D3.2(INB) R6D31.2(B) U6E1.D1 U6E1.E1
+VCCAZPLL_1P05_L: L6D3.1 R6D31.1 R6D33.2(B) R6D34.2
+VCCB_SUSCLK: R7F45.2(B) U7F1.6(VCCB)
+VCCCORE: C2C2.1 C3C1.1 C3C2.1 C3C3.1 C3C4.1 C3C5.1 C3C6.1 C3C7.1 C3C8.1 C3C9.1 C3C10.1 C3C11.1 C3C12.1 C3C13.1 C3C14.1 C3D1.1 C3D2.1 C3D3.1 C3D4.1 C3D5.1 C3D8.1 C3D9.1 C3D10.1 C3D11.1 C3D12.1 C3D15.1 C3D16.1 C3D17.1 C3D18.1 C3D19.1 C3D21.1 C3D23.1 C3D24.1 C3D25.1 C3D26.1 C3D28.1 C3D29.1 C3D30.1 C3D31.1 C3D32.1 C3P2.1 C3P3.1 C3P10.1 C3P11.1 C3P18.1 C4C1.1 C4C2.1 J3D1.A17 J3D1.A18 J3D1.A23 J3D1.A24 J3D1.A25 J3D1.A26 J3D1.A27 J3D1.A28 J3D1.A29 J3D1.A30 J3D1.A31 J3D1.A32 J3D1.A33 J3D1.A34 J3D1.A35 J3D1.AJ12 J3D1.AJ13 J3D1.AJ14 J3D1.AJ15 J3D1.AJ16 J3D1.AJ17 J3D1.AJ18 J3D1.AJ19 J3D1.AJ20 J3D1.AJ21 J3D1.AJ22 J3D1.AJ23 J3D1.AJ24 J3D1.AK13 J3D1.AK14 J3D1.AK15 J3D1.AK16 J3D1.AK17 J3D1.AK18 J3D1.AK19 J3D1.AK20 J3D1.AK21 J3D1.AK22 J3D1.AK23 J3D1.B17 J3D1.B18 J3D1.B23 J3D1.B25 J3D1.B27 J3D1.B29 J3D1.B31 J3D1.B33 J3D1.B35 J3D1.C17 J3D1.C18 J3D1.C19 J3D1.C20 J3D1.C21 J3D1.C22 J3D1.C23 J3D1.C24 J3D1.C25 J3D1.C26 J3D1.C27 J3D1.C28 J3D1.C29 J3D1.C30 J3D1.C31 J3D1.C32 J3D1.C33 J3D1.C34 J3D1.C35 J3D1.D17 J3D1.D19 J3D1.D21 J3D1.D23 J3D1.D25 J3D1.D27 J3D1.D29 J3D1.D31 J3D1.D33 J3D1.D34 J3D1.D35 J3D1.E17 J3D1.E18 J3D1.E19 J3D1.E20 J3D1.E21 J3D1.E22 J3D1.E23 J3D1.E24 J3D1.E25 J3D1.E26 J3D1.E27 J3D1.E28 J3D1.E29 J3D1.E30 J3D1.E31 J3D1.E32 J3D1.E33 J3D1.E34 J3D1.F17 J3D1.F19 J3D1.F21 J3D1.F23 J3D1.F25 J3D1.F27 J3D1.F29 J3D1.F31 J3D1.F33 J3D1.G17 J3D1.G18 J3D1.G19 J3D1.G20 J3D1.G21 J3D1.G22 J3D1.G23 J3D1.G24 J3D1.G25 J3D1.G26 J3D1.G27 J3D1.G28 J3D1.G29 J3D1.G30 J3D1.G31 J3D1.G32 J3D1.G33 J3D1.G34 J3D1.H17 J3D1.H19 J3D1.H21 J3D1.H23 J3D1.H25 J3D1.H27 J3D1.H29 J3D1.H31 J3D1.H33 J3D1.J17 J3D1.J18 J3D1.J19 J3D1.J20 J3D1.J21 J3D1.J22 J3D1.J23 J3D1.J24 J3D1.J25 J3D1.J26 J3D1.J27 J3D1.J28 J3D1.J29 J3D1.J30 J3D1.J31 J3D1.J32 J3D1.J33 J3D1.J34 J3D1.K17 J3D1.K19 J3D1.K21 J3D1.K23 J3D1.K25 J3D1.K27 J3D1.K29 J3D1.K31 J3D1.K32 J3D1.K33 J3D1.L17 J3D1.L18 J3D1.L19 J3D1.L20 J3D1.L21 J3D1.L22 J3D1.L23 J3D1.L24 J3D1.L25 J3D1.L26 J3D1.L27 J3D1.L28 J3D1.L29 J3D1.L30 J3D1.L31 J3D1.L32 J3D1.M17 J3D1.M19 J3D1.M21 J3D1.M23 J3D1.M25 J3D1.M27 J3D1.M29 J3D1.M31 J3D1.M32 J3D1.N17 J3D1.N18 J3D1.N19 J3D1.N20 J3D1.N21 J3D1.N22 J3D1.N23 J3D1.N24 J3D1.N25 J3D1.N26 J3D1.N27 J3D1.N28 J3D1.N29 J3D1.N30 J3D1.N32 R2B20.1 R2M18.2 R2M19.2 R2N1.2 R3M40.2 R3M41.2 R3M42.2 R4M27.2 R4M28.2
+VCCCORE_PH1_OUT: ISO3B8.1 L3B4.2(B) R2M19.1
+VCCCORE_PH2_OUT: ISO3B7.1 L3B3.2(B) R3M40.1
+VCCCORE_PH3_OUT: ISO3B6.1 L3B2.2(B) R3M41.1
+VCCCORE_PH4_OUT: ISO3B5.1 L3B1.2(B) R3M42.1
+VCCCORE_PH5_OUT: ISO2B5.1 L2B3.2(B) R2N1.1
+VCCCORE_PH6_OUT: ISO2B4.1 L2B2.2(B) R2M18.1
+VCCCORE_PH7_OUT: ISO4B4.1 L4B4.2(B) R4M28.1
+VCCCORE_PH8_OUT: ISO4B3.1 L4B3.2(B) R4M27.1
+VCCDDQ_EDGECAP1: C3P24.1 J3D1.AM24
+VCCDDQ_EDGECAP2: C3P20.1 J3D1.AM13
+VCCDPHY_1P24: C7E2.1 U6E1.AJ22 U6E1.AJ23 U6E1.AK22 U6E1.AK23 U6E1.BG5
+VCCDSW_1P05: C7E15.1 R7E59.2(B) U6E1.BG45 U6E1.BG46
+VCCGT: C2C3.1 C2D1.1 C2D2.1 C2D3.1 C2D4.1 C2D5.1 C2D6.1 C2D7.1 C3P5.1 C3P7.1 C3P9.1 C3P13.1 C3P15.1 C3P16.1 C3P19.1 J3D1.AA32 J3D1.AA34 J3D1.AA35 J3D1.AA36 J3D1.AA37 J3D1.AA38 J3D1.AB32 J3D1.AB33 J3D1.AB34 J3D1.AB35 J3D1.AB36 J3D1.AC32 J3D1.AD32 J3D1.AE32 J3D1.AF32 J3D1.AG32 J3D1.R40 J3D1.T37 J3D1.T38 J3D1.T39 J3D1.T40 J3D1.U33 J3D1.U34 J3D1.U35 J3D1.U36 J3D1.U37 J3D1.U38 J3D1.U39 J3D1.U40 J3D1.V32 J3D1.V33 J3D1.V34 J3D1.V36 J3D1.V38 J3D1.V40 J3D1.W32 J3D1.W34 J3D1.W35 J3D1.W36 J3D1.W37 J3D1.W38 J3D1.Y32 J3D1.Y33 J3D1.Y34 J3D1.Y36 J3D1.Y38 R1C4.1 R2P3.2 R2P5.2
+VCCGT_OUT1: ISO2D1.1 L2D1.2(B) R2P3.1
+VCCGT_OUT2: ISO2D3.1 L2D2.2(B) R2P5.1
+VCCIO_0: C3D14.1 C3D20.1 C3D22.1 C3P4.1 C3P6.1 C3P8.1 C3P12.1 C3P14.1 C3P17.1 C4D5.1 C4D6.1 C4D7.1 C4D8.1 C4D9.1 C4D10.1 J3D1.AA3 J3D1.AB8 J3D1.AC1 J3D1.AC7 J3D1.AD6 J3D1.U5 J3D1.V3 J3D1.V7 J3D1.W1 J3D1.W7 J3D1.W8 R1C38.1 R1C39.2(B) R1C55.1 R1C70.1 R1C80.1 R1C96.1 R4D1.2 R4D2.1
+VCCIO_0_OUT: C4C21.1 C4C22.1 C4D2.1 L4C1.2(INB) R4D1.1 R5C44.1
+VCCIO_1_2: C3D27.1 C3D33.1 C3P21.1 C3P22.1 C3P23.1 C4D11.1 C4D12.1 C5E2.1 C5E4.1 C5E6.1 C5E8.1 C5E9.1 C5E10.1 C5E11.1 C5E12.1 J3D1.AJ9 J3D1.AK10 J3D1.AK11 J3D1.AK25 J3D1.AL10 J3D1.AL11 J3D1.AL12 J3D1.AL24 J3D1.AM12 R5E1.2 R5E57.1
+VCCIO_1_2_OUT: C5D17.1 C5D29.1 C5E1.1 L5D1.2(INB) R5D23.1 R5E1.1
+VCCIO_CFG_PU: R1C39.1 R1C50.1 R1C51.1 R1C54.1 R1C56.1 R1C58.1 R1C60.1 R1C62.1 R1C66.1 R1C72.1 R1C77.1 R1C85.1 R1C88.1 R1C92.1 R1C93.1 R1C95.1 R1C98.1
+VCCPAZIO_3P3_1P8: J7D2.1 R7C50.2(B) R7C51.2(B) R7R5.2 U6E1.BB14
+VCCPAZIO_3P3_1P8_R: R7R2.2(B) R7R3.2(B) R7R5.1
+VCCPDSW_3P3: C7F9.1 R7F1.2 R7F45.1 U6E1.BE48 U6E1.BE49
+VCCPDSW_3P3_R: R7F1.1 R7F6.2(B) R7F8.2(B) R7F10.2(B)
+VCCPGPPA_3P3_1P8: R6F1.1 R7R48.2 U6E1.AN32
+VCCPGPPBC_3P3_1P8: C7E12.1 C7H1.1 EU7H1.15(VCCB) R7H27.1 R7H34.1 R7H38.1 R7H44.1 R7H55.1 R7H56.1 R7H60.1 R7R37.2 R8A1.1 R8A2.1 R8A3.1 R8A4.1 R8A5.1 R8A6.1 R8A7.1 R8A8.1 R8A22.1 R8A23.1 R8G53.1 R8G54.1 R8G66.1 U6E1.AN26 U6E1.AP26 U9A1.6(VCCB)
+VCCPGPPD_3P3_1P8: R7D6.1 R7D7.1 R7R14.1 R7R20.1 R7R24.1 R7R35.1 R7R36.2 R8A14.1 R8A15.1 R8A16.1 R8A17.1 R8A18.1 R8A19.1 R8A20.1 R8A21.1 R8D49.1 R8D63.1 R9D27.1 R9D29.1 U6E1.AN24 U7D1.2
+VCCPGPPEF_3P3_1P8: C7F2.1 R6H1.1 R7T13.1 R7T22.2 U6E1.AE35 U6E1.AE36
+VCCPGPPHK_3P3_1P8: C6F2.1 R6T12.2 U6E1.AC35 U6E1.AC36
+VCCPHVLDO_1P8: R7P11.2(B) R7P12.2(B) U6E1.AF19 U6E1.AF20
+VCCPRIM_1P05: C6D23.1 C6D26.1 C6D27.1 C6E1.1 C6E2.1 C6E3.1 C6E4.1 C6E5.1 C6E6.1 C6E7.1 C6E8.1 C6R1.1 C7D4.1 R5F11.2(B) R5G8.2(B) R6D34.1 R6D40.1 R6F16.1 R6F30.2 U6E1.AA22 U6E1.AA23 U6E1.AB20 U6E1.AB22 U6E1.AB23 U6E1.AB27 U6E1.AB28 U6E1.AB30 U6E1.AD20 U6E1.AD23 U6E1.AD27 U6E1.AD28 U6E1.AD30 U6E1.AD31 U6E1.AE17 U6E1.AF23 U6E1.AF27 U6E1.AF30 U6E1.AF31 U6E1.AG31 U6E1.B1 U6E1.B2 U6E1.B3 U6E1.C1 U6E1.C2 U6E1.U26 U6E1.U29 U6E1.V19 U6E1.V25 U6E1.V27 U6E1.V28 U6E1.V30 U6E1.V31 U6E1.W19 U6E1.W20 U6E1.W22 U6E1.W23 U6E1.W31
+VCCPRIM_1P8: C7D5.1 C7E3.1 C7E4.1 C7R10.1 R7P8.2(B) R7P10.2 R7P12.1 U6E1.AG19 U6E1.AG20 U6E1.AN15 U6E1.AR15 U6E1.BB11
+VCCPRIM_3P3: C7E1.1 C7E10.1 R7P5.2(B) R7P6.2 U6E1.AN21 U6E1.AT44 U6E1.AW9 U6E1.AY8 U6E1.BB7 U6E1.V23
+VCCPRTC_3P3: C7E17.1 C7E18.1 R7F5.2 R7F12.2(B) R7F13.1 U6E1.BC49 U6E1.BD49
+VCCPSPI_PCH_3P3_1P8: R7F31.1 R7F32.1 R7F33.1 R7T1.2(B) R7T4.2 R7T5.2(B) R7T15.1 U6E1.AN44 U7G1.2
+VCCRTCEXT: C7E16.1 U6E1.BF47 U6E1.BG47
+VCCSA: C3D6.1 C3D7.1 C3D13.1 C3P1.1 C4B31.1 C4B32.1 C4B33.1 C4B34.1 C4D1.1 C4D3.1 C4D4.1 C4M24.1 C4M25.1 C4M26.1 J3D1.B3 J3D1.B6 J3D1.D1 J3D1.G3 J3D1.H1 J3D1.L3 J3D1.L11 J3D1.L12 J3D1.M1 J3D1.M11 J3D1.M12 J3D1.N11 J3D1.N12 J3D1.N13 R4B41.2 R5B58.1
+VCCSFR: J3D1.R1 R4C24.2 R4C28.2(B)
+VCCSFR_MIX: R4C13.2(B) R4C14.2(B) R4C16.1 U4C1.6
+VCCSFR_OC: C4C10.1 J3D1.AU13 J3D1.AU27 R3R1.2(B) R4C16.2 R4C26.2(B)
+VCCSFR_OC_R1: C4C9.1 C5C25.1 EU5C2.5(VOS) L5C1.2(INB) R4C14.1 R5C34.1
+VCCSFR_OC_SW_VSNUB: C5C16.1 R5C20.2(B)
+VCCSFR_OC_VDD: C4C7.1 R4C15.1 U4C1.1(VDD)
+VCCST: J3D1.U2 J3D1.V1 J3D1.V2 R4C11.1 R4C23.2 R4C27.2(B)
+VCCST_VCCSFR: C4C16.1 C4C19.1 R2B21.1 R2B22.1 R2B23.1 R4B35.1 R4C1.1 R4C2.1 R4C3.1 R4C20.2(B) R4C23.1 R4C24.1 R4C26.1 R4D5.2(B) R7F46.2(B) R8H37.1 U4C2.6 U4C2.7
+VCCSTG: C4C20.1 E4C2.2 J3D1.R2 J3D1.R3 R2C26.1 R2C27.1 R2C29.1 R2C30.1 R2C31.1 R4C4.1 R4C30.2(B) R7D12.1 R7D18.1 R7D22.1 R7D26.1 R7D27.1 R8G25.1
+VCCSTG_LW: E4C1.1 E4C2.1 R4C21.2(B) U4C3.6 U4C3.7
+VCCSTG_OUT: E4C1.2 J3D1.R4 J3D1.T5 J3D1.T6 R4C29.2(B)
+VDD_ALS: C1B4.1 J1B2.39 R1B8.2(B) R6F38.1 R6F39.1
+VDD_EMB_S: C1C10.1 Q1C1.2(SRC) R1C12.2(B) R1C16.2(B) R1C21.1 R1C26.2(B)
+VDD_SLG4198: C8F7.1 EU8F1.1(VDD) R8F18.2(B) R8F19.2(B)
+VDDQ: C2F1.2(B) C2F2.2(B) C2F3.2(B) C2F4.2(B) C2F5.1 C2F6.1 C2G1.1 C2G8.1 C3E1.2(B) C3E2.2(B) C3E3.2(B) C3E4.2(B) C3E5.1 C3E6.1 C3E7.2(B) C3E8.2(B) C3E9.2(B) C3E11.1 C3E12.1 C3E14.1 C3F1.2(B) C3F4.2(B) C3F5.1 C3F6.2(B) C3F7.1 C3F8.1 C3F9.1 C3F10.1 C3F11.1 C3F13.2(B) C3F14.2(B) C3F15.2(B) C3F19.2(B) C3F20.2(B) C3F21.1 C3F22.1 C3F23.2(B) C3F24.2(B) C3G2.2(B) C3G3.2(B) C3G5.2(B) C3G6.2(B) C3G7.2(B) C3G8.2(B) C3G9.1 C3G11.1 C3G12.1 C3G13.1 C3G14.1 C3G15.1 C3G16.1 C3G17.1 C4C6.1 C4E1.1 C4E2.1 C4E3.1 C4F1.1 C4F2.1 C4F3.1 C4F4.1 C4F5.1 C4F6.2(B) C4F7.2(B) C4F8.1 C4F9.1 C4F10.2(B) C4F11.1 C4G1.1 C4G2.2(B) C4G3.2(B) C4G4.1 C4G5.1 C4G7.1 C4G8.1 C4G9.1 C4G10.1 C5E17.2(B) C5F5.1 C5F6.1 J1E5.7 J1E5.18 J1E5.29 J1E5.40 J1E5.51 J1E5.59 J1E5.61 J1E5.64 J1E5.67 J1E5.70 J1E5.73 J1E5.76 J1E5.80 J1E5.83 J1E5.85 J1E5.88 J1E5.90 J1E5.92 J1E5.99 J1E5.110 J1E5.121 J1E5.132 J1E5.204 J1E5.206 J1E5.209 J1E5.212 J1E5.215 J1E5.217 J1E5.220 J1E5.223 J1E5.226 J1E5.229 J1E5.231 J1E5.233 J1E5.236 J1F1.7 J1F1.18 J1F1.29 J1F1.40 J1F1.51 J1F1.59 J1F1.61 J1F1.64 J1F1.67 J1F1.70 J1F1.73 J1F1.76 J1F1.80 J1F1.83 J1F1.85 J1F1.88 J1F1.90 J1F1.92 J1F1.99 J1F1.110 J1F1.121 J1F1.132 J1F1.204 J1F1.206 J1F1.209 J1F1.212 J1F1.215 J1F1.217 J1F1.220 J1F1.223 J1F1.226 J1F1.229 J1F1.231 J1F1.233 J1F1.236 J1F2.7 J1F2.18 J1F2.29 J1F2.40 J1F2.51 J1F2.59 J1F2.61 J1F2.64 J1F2.67 J1F2.70 J1F2.73 J1F2.76 J1F2.80 J1F2.83 J1F2.85 J1F2.88 J1F2.90 J1F2.92 J1F2.99 J1F2.110 J1F2.121 J1F2.132 J1F2.204 J1F2.206 J1F2.209 J1F2.212 J1F2.215 J1F2.217 J1F2.220 J1F2.223 J1F2.226 J1F2.229 J1F2.231 J1F2.233 J1F2.236 J1F3.7 J1F3.18 J1F3.29 J1F3.40 J1F3.51 J1F3.59 J1F3.61 J1F3.64 J1F3.67 J1F3.70 J1F3.73 J1F3.76 J1F3.80 J1F3.83 J1F3.85 J1F3.88 J1F3.90 J1F3.92 J1F3.99 J1F3.110 J1F3.121 J1F3.132 J1F3.204 J1F3.206 J1F3.209 J1F3.212 J1F3.215 J1F3.217 J1F3.220 J1F3.223 J1F3.226 J1F3.229 J1F3.231 J1F3.233 J1F3.236 J3D1.AR14 J3D1.AT24 J3D1.AU15 J3D1.AU25 J3D1.AV17 J3D1.AV19 J3D1.AV23 J3D1.AW13 J3D1.AW15 J3D1.AW24 J3D1.AW26 J3D1.AW28 J3D1.AW30 J3D1.AY17 R1F3.1 R1F22.1 R1F34.1 R1F39.1 R2G2.2 R2G5.2(B) R2G13.1 R2G20.1 R2G22.2(B) R3F1.1 R3F2.1 R3F3.1 R3G1.1 R3G4.1 R3G5.1 R3R1.1 R4C13.1 R7F30.2(B) U2G2.6 U4C1.3
+VDDQ_VR_BST: EU2G1.18 R2G6.1
+VDDQ_VR_BST_R: C2G15.2(B) R2G6.2(B)
+VDDQ_VR_PHASE: C2G15.1 EU2G1.16 L2G1.1 R2G1.1 U2G1.9
+VDDQ_VR_PHASE_SNUB: C2G2.1 R2G1.2(B)
+VDDQ_VR_VIN: C2G10.1 C2G11.1 C2G14.1 C2G18.1 C2G19.1 R2G12.1 R2G27.2(B) U2G1.2
+VDDSPD: C5E13.1 C5E14.1 C5F3.1 C5F4.1 C5F15.1 C5F16.1 C5G1.1 C5G2.1 J1E5.284 J1F1.284 J1F2.284 J1F3.284 R5E48.1 R5E49.1 R5E53.1 R5E55.1 R5F3.1 R5F5.2(B) R5F6.2(B) R5F7.1 R5F14.1 R5F16.1
-12V: C4H1.1 J4G1.14 R8H71.1
AGND_V1P05A: EU5G3.11 ISO5G1.1 R4G1.2(B) R4G2.1 R5G1.1 R5U1.2(B)
GND: BH9C1.3 C1A1.2(B) C1A2.2(B) C1B1.2(B) C1B2.2(B) C1B3.2(B) C1B4.2(B) C1B5.2(B) C1B7.2(B) C1B8.2(B) C1B9.2(B) C1B16.2(B) C1C3.2(B) C1C4.2(B) C1C5.2(B) C1C7.2(B) C1C8.2(B) C1C9.2(B) C1C11.2(B) C1C12.2(B) C1C13.2(B) C1C14.2(B) C1C15.2(B) C1D1.2(B) C1D2.2(B) C1D4.2(B) C1D5.2(B) C1D6.2(B) C1D7.2(B) C1D8.2(B) C1D10.2(B) C1D11.2(B) C1D12.2(B) C1D13.2(B) C1E1.2(B) C1E2.2(B) C1E3.2(B) C1E4.2(B) C1E5.2(B) C1E6.2(B) C1E7.2(B) C1E8.2(B) C1E9.2(B) C1E10.2(B) C1E11.2(B) C1E13.2(B) C1E14.2(B) C1F2.2(B) C1F3.2(B) C1F8.2(B) C1F9.2(B) C1G1.2(B) C1G2.2(B) C1P1.2(B) C1P2.2(B) C1P3.2(B) C2A1.2(B) C2A2.2(B) C2A3.2(B) C2A4.2(B) C2A5.2(B) C2A6.2(B) C2A7.2(B) C2A8.2(B) C2A9.2(B) C2A10.2(B) C2A11.2(B) C2A12.2(B) C2A22.2(B) C2A23.2(B) C2A25.2(B) C2A26.2(B) C2A27.2(B) C2A28.2(B) C2A33.2(B) C2B6.2(B) C2B8.2(B) C2B11.2(B) C2B12.2(B) C2B13.2(B) C2B14.2(B) C2B15.2(B) C2B16.2(B) C2B17.2(B) C2B18.2(B) C2B19.2(B) C2B21.2(B) C2B22.2(B) C2B23.2(B) C2C1.1 C2C2.2(B) C2C3.2(B) C2D1.2(B) C2D2.2(B) C2D3.2(B) C2D4.2(B) C2D5.2(B) C2D6.2(B) C2D7.2(B) C2E1.2(B) C2F1.1 C2F2.1 C2F3.1 C2F4.1 C2F5.2(B) C2F6.2(B) C2G1.2(B) C2G2.2(B) C2G3.2(B) C2G4.2(B) C2G5.2(B) C2G6.2(B) C2G7.2(B) C2G8.2(B) C2G9.2(B) C2G10.2(B) C2G11.2(B) C2G12.2(B) C2G13.2(B) C2G14.2(B) C2G16.2(B) C2G17.2(B) C2G18.2(B) C2G19.2(B) C2G20.2(B) C2G21.2(B) C2G22.2(B) C2G24.2(B) C2G25.2(B) C2G26.2(B) C2G27.2(B) C2L1.2(B) C2L2.2(B) C2L3.2(B) C2L4.2(B) C2L5.2(B) C2L6.2(B) C2L7.2(B) C2L8.2(B) C2L9.2(B) C2L10.2(B) C2L11.2(B) C2L12.2(B) C2M1.2(B) C2M2.2(B) C2M3.2(B) C2M4.2(B) C2M7.2(B) C2M8.2(B) C2M9.2(B) C2M10.2(B) C2M11.2(B) C2P1.2(B) C3A1.2(B) C3A2.2(B) C3A3.2(B) C3A4.2(B) C3A5.2(B) C3A6.2(B) C3A7.2(B) C3A8.2(B) C3A9.2(B) C3A10.2(B) C3A11.2(B) C3A16.2(B) C3A23.2(B) C3A24.2(B) C3B8.2(B) C3B9.2(B) C3B22.2(B) C3B24.2(B) C3B25.2(B) C3B26.2(B) C3B27.2(B) C3B28.2(B) C3B29.2(B) C3B30.2(B) C3B31.2(B) C3B32.2(B) C3B33.2(B) C3C1.2(B) C3C2.2(B) C3C3.2(B) C3C4.2(B) C3C5.2(B) C3C6.2(B) C3C7.2(B) C3C8.2(B) C3C9.2(B) C3C10.2(B) C3C11.2(B) C3C12.2(B) C3C13.2(B) C3C14.2(B) C3D1.2(B) C3D2.2(B) C3D3.2(B) C3D4.2(B) C3D5.2(B) C3D6.2(B) C3D7.2(B) C3D8.2(B) C3D9.2(B) C3D10.2(B) C3D11.2(B) C3D12.2(B) C3D13.2(B) C3D14.2(B) C3D15.2(B) C3D16.2(B) C3D17.2(B) C3D18.2(B) C3D19.2(B) C3D20.2(B) C3D21.2(B) C3D22.2(B) C3D23.2(B) C3D24.2(B) C3D25.2(B) C3D26.2(B) C3D27.2(B) C3D28.2(B) C3D29.2(B) C3D30.2(B) C3D31.2(B) C3D32.2(B) C3D33.2(B) C3E1.1 C3E2.1 C3E3.1 C3E4.1 C3E5.2(B) C3E6.2(B) C3E7.1 C3E8.1 C3E9.1 C3E10.2(B) C3E11.2(B) C3E12.2(B) C3E13.2(B) C3E14.2(B) C3E15.2(B) C3F1.1 C3F2.2(B) C3F3.2(B) C3F4.1 C3F5.2(B) C3F6.1 C3F7.2(B) C3F8.2(B) C3F9.2(B) C3F10.2(B) C3F11.2(B) C3F12.2(B) C3F13.1 C3F14.1 C3F15.1 C3F16.2(B) C3F17.2(B) C3F18.2(B) C3F19.1 C3F20.1 C3F21.2(B) C3F22.2(B) C3F23.1 C3F24.1 C3G1.2(B) C3G2.1 C3G3.1 C3G4.2(B) C3G5.1 C3G6.1 C3G7.1 C3G8.1 C3G9.2(B) C3G10.2(B) C3G11.2(B) C3G12.2(B) C3G13.2(B) C3G14.2(B) C3G15.2(B) C3G16.2(B) C3G17.2(B) C3G24.2(B) C3G25.2(B) C3G26.2(B) C3G27.2(B) C3G28.2(B) C3G29.2(B) C3H1.2(B) C3H2.2(B) C3H3.2(B) C3H4.2(B) C3H5.2(B) C3H6.2(B) C3H8.2(B) C3H9.2(B) C3L1.2(B) C3L2.2(B) C3L3.2(B) C3L4.2(B) C3L5.2(B) C3L6.2(B) C3L7.2(B) C3L8.2(B) C3L9.2(B) C3L10.2(B) C3L11.2(B) C3L12.2(B) C3L13.2(B) C3L14.2(B) C3M1.2(B) C3M2.2(B) C3M3.2(B) C3M4.2(B) C3M5.2(B) C3M6.2(B) C3M7.2(B) C3M8.2(B) C3M9.2(B) C3M10.2(B) C3M11.2(B) C3M12.2(B) C3M13.2(B) C3M14.2(B) C3M15.2(B) C3M16.2(B) C3M17.2(B) C3M18.2(B) C3M23.2(B) C3M24.2(B) C3M25.2(B) C3M26.2(B) C3M27.2(B) C3M28.2(B) C3M29.2(B) C3M30.2(B) C3P1.2(B) C3P2.2(B) C3P3.2(B) C3P4.2(B) C3P5.2(B) C3P6.2(B) C3P7.2(B) C3P8.2(B) C3P9.2(B) C3P10.2(B) C3P11.2(B) C3P12.2(B) C3P13.2(B) C3P14.2(B) C3P15.2(B) C3P16.2(B) C3P17.2(B) C3P18.2(B) C3P19.2(B) C3P20.2(B) C3P21.2(B) C3P22.2(B) C3P23.2(B) C3P24.2(B) C4A1.2(B) C4A2.2(B) C4A3.2(B) C4A4.2(B) C4A5.2(B) C4A6.1 C4A7.2(B) C4A8.2(B) C4A19.2(B) C4A20.2(B) C4A21.2(B) C4A22.2(B) C4A24.2(B) C4A25.2(B) C4A26.2(B) C4A27.2(B) C4A29.2(B) C4A30.2(B) C4A31.2(B) C4A34.2(B) C4A36.2(B) C4B2.2(B) C4B3.2(B) C4B4.2(B) C4B5.2(B) C4B6.2(B) C4B7.2(B) C4B8.2(B) C4B19.2(B) C4B22.2(B) C4B23.2(B) C4B24.2(B) C4B25.2(B) C4B26.2(B) C4B27.2(B) C4B28.2(B) C4B29.2(B) C4B30.2(B) C4B31.2(B) C4B32.2(B) C4B33.2(B) C4B34.2(B) C4B35.2(B) C4B36.2(B) C4C1.2(B) C4C2.2(B) C4C3.2(B) C4C4.2(B) C4C5.2(B) C4C6.2(B) C4C7.2(B) C4C8.2(B) C4C9.2(B) C4C10.2(B) C4C11.2(B) C4C12.2(B) C4C13.2(B) C4C14.2(B) C4C15.2(B) C4C16.2(B) C4C17.2(B) C4C18.2(B) C4C19.2(B) C4C20.2(B) C4C21.2(B) C4C22.2(B) C4D1.2(B) C4D2.2(B) C4D3.2(B) C4D4.2(B) C4D5.2(B) C4D6.2(B) C4D7.2(B) C4D8.2(B) C4D9.2(B) C4D10.2(B) C4D11.2(B) C4D12.2(B) C4E1.2(B) C4E2.2(B) C4E3.2(B) C4F1.2(B) C4F2.2(B) C4F3.2(B) C4F4.2(B) C4F5.2(B) C4F6.1 C4F7.1 C4F8.2(B) C4F9.2(B) C4F10.1 C4F11.2(B) C4G1.2(B) C4G2.1 C4G3.1 C4G4.2(B) C4G5.2(B) C4G6.2(B) C4G7.2(B) C4G8.2(B) C4G9.2(B) C4G10.2(B) C4G12.2(B) C4G13.2(B) C4G14.2(B) C4G16.2(B) C4G17.2(B) C4G18.2(B) C4G19.2(B) C4G20.2(B) C4G21.2(B) C4G22.2(B) C4G23.2(B) C4G24.2(B) C4H1.2(B) C4H2.2(B) C4H3.2(B) C4H4.2(B) C4H5.2(B) C4H6.2(B) C4H7.2(B) C4H8.2(B) C4H9.2(B) C4H11.2(B) C4H13.2(B) C4H14.2(B) C4L1.2(B) C4L2.2(B) C4L3.2(B) C4M1.2(B) C4M2.2(B) C4M3.2(B) C4M4.2(B) C4M5.2(B) C4M6.2(B) C4M7.2(B) C4M8.2(B) C4M9.2(B) C4M10.2(B) C4M11.2(B) C4M12.2(B) C4M13.2(B) C4M14.2(B) C4M15.2(B) C4M18.2(B) C4M19.2(B) C4M20.2(B) C4M21.2(B) C4M22.2(B) C4M23.2(B) C4M24.2(B) C4M25.2(B) C4M26.2(B) C5A2.2(B) C5A3.2(B) C5A4.2(B) C5A5.2(B) C5A6.2(B) C5A7.2(B) C5A14.2(B) C5A15.2(B) C5A18.2(B) C5A19.2(B) C5A20.2(B) C5A21.2(B) C5A22.2(B) C5A23.2(B) C5A24.2(B) C5A25.2(B) C5A26.2(B) C5A27.2(B) C5A28.2(B) C5A29.2(B) C5A30.2(B) C5B9.2(B) C5B10.2(B) C5B12.2(B) C5B15.2(B) C5B16.2(B) C5B17.2(B) C5B19.2(B) C5B20.2(B) C5B22.2(B) C5B23.2(B) C5B34.2(B) C5B35.2(B) C5B36.2(B) C5B37.2(B) C5B39.2(B) C5B40.2(B) C5B41.2(B) C5B45.2(B) C5C5.2(B) C5C6.2(B) C5C7.2(B) C5C8.2(B) C5C9.2(B) C5C10.2(B) C5C11.2(B) C5C12.2(B) C5C13.2(B) C5C16.2(B) C5C17.2(B) C5C19.2(B) C5C20.2(B) C5C21.2(B) C5C23.2(B) C5C24.2(B) C5C25.2(B) C5C27.2(B) C5C31.2(B) C5C32.2(B) C5C33.2(B) C5C34.2(B) C5C37.2(B) C5C41.1 C5D1.2(B) C5D8.2(B) C5D16.2(B) C5D17.2(B) C5D19.2(B) C5D20.2(B) C5D23.2(B) C5D24.2(B) C5D25.2(B) C5D28.1 C5D29.2(B) C5E1.2(B) C5E2.2(B) C5E3.2(B) C5E4.2(B) C5E5.2(B) C5E6.2(B) C5E7.2(B) C5E8.2(B) C5E9.2(B) C5E10.2(B) C5E11.2(B) C5E12.2(B) C5E13.2(B) C5E14.2(B) C5E15.2(B) C5E16.2(B) C5F1.2(B) C5F2.2(B) C5F3.2(B) C5F4.2(B) C5F5.2(B) C5F6.2(B) C5F7.2(B) C5F8.2(B) C5F9.2(B) C5F10.2(B) C5F11.2(B) C5F12.2(B) C5F13.2(B) C5F14.2(B) C5F15.2(B) C5F16.2(B) C5F17.2(B) C5F18.2(B) C5F19.2(B) C5F20.2(B) C5F21.2(B) C5F22.2(B) C5G1.2(B) C5G2.2(B) C5G3.2(B) C5G4.2(B) C5G5.2(B) C5G6.2(B) C5G8.2(B) C5G10.2(B) C5G11.2(B) C5G12.2(B) C5G13.2(B) C5G14.2(B) C5G15.2(B) C5H1.2(B) C5J1.2(B) C5L1.2(B) C5L2.2(B) C5L3.2(B) C5L4.2(B) C5L5.2(B) C5L6.2(B) C5L7.2(B) C5L8.2(B) C5L9.2(B) C5L10.2(B) C5L11.2(B) C5L12.2(B) C5L13.2(B) C5L14.2(B) C5L15.2(B) C5L16.2(B) C5L17.2(B) C5L18.2(B) C5L19.2(B) C5L20.2(B) C5L21.2(B) C5L22.2(B) C5L23.2(B) C5L24.2(B) C5L25.2(B) C5L26.2(B) C5L27.2(B) C5L28.2(B) C5L29.2(B) C5L30.2(B) C5L31.2(B) C5L32.2(B) C5L33.2(B) C5L34.2(B) C5L35.2(B) C5L36.2(B) C5M2.2(B) C5U1.2(B) C6A1.2(B) C6A4.2(B) C6A5.2(B) C6A7.2(B) C6A10.2(B) C6A12.2(B) C6A19.2(B) C6A22.2(B) C6A23.2(B) C6A24.2(B) C6A26.2(B) C6A27.2(B) C6A28.2(B) C6A29.2(B) C6A30.2(B) C6A31.2(B) C6A32.1 C6A33.2(B) C6A34.2(B) C6A35.2(B) C6A37.2(B) C6A39.2(B) C6A43.2(B) C6A44.2(B) C6A45.2(B) C6A46.2(B) C6A48.2(B) C6A49.2(B) C6A50.2(B) C6B1.2(B) C6B2.2(B) C6B3.2(B) C6B4.2(B) C6B5.2(B) C6B6.2(B) C6B7.2(B) C6B8.2(B) C6B9.2(B) C6B10.2(B) C6C3.2(B) C6C4.2(B) C6C5.2(B) C6C6.2(B) C6C7.2(B) C6C8.2(B) C6C9.2(B) C6C10.2(B) C6C11.2(B) C6C12.2(B) C6D13.2(B) C6D14.2(B) C6D15.2(B) C6D16.2(B) C6D17.2(B) C6D21.2(B) C6D22.2(B) C6D23.2(B) C6D24.2(B) C6D25.2(B) C6D26.2(B) C6D27.2(B) C6E1.2(B) C6E2.2(B) C6E3.2(B) C6E4.2(B) C6E5.2(B) C6E6.2(B) C6E7.2(B) C6E8.2(B) C6F1.2(B) C6F2.2(B) C6F3.2(B) C6F4.2(B) C6F5.2(B) C6F6.2(B) C6J1.2(B) C6J2.2(B) C6J3.2(B) C6J4.2(B) C6L1.2(B) C6L2.2(B) C6L3.2(B) C6L4.2(B) C6L5.2(B) C6M1.2(B) C6M2.2(B) C6R1.2(B) C6R2.2(B) C6R3.2(B) C6R4.2(B) C6W1.2(B) C6W2.2(B) C6W3.2(B) C7A1.2(B) C7A2.1 C7A3.2(B) C7A4.1 C7A5.2(B) C7A6.2(B) C7A7.1 C7A8.1 C7A9.2(B) C7A10.2(B) C7B1.2(B) C7B2.2(B) C7B3.2(B) C7B4.2(B) C7B5.2(B) C7B6.2(B) C7B7.2(B) C7B8.2(B) C7B9.2(B) C7B10.2(B) C7B11.2(B) C7B12.2(B) C7B13.2(B) C7B14.2(B) C7B15.2(B) C7C1.2(B) C7C2.2(B) C7C3.2(B) C7C4.2(B) C7C5.1 C7C6.2(B) C7C7.2(B) C7C8.2(B) C7C9.2(B) C7C10.2(B) C7D2.2(B) C7D4.2(B) C7D5.2(B) C7E1.2(B) C7E2.2(B) C7E3.2(B) C7E4.2(B) C7E5.2(B) C7E6.2(B) C7E7.2(B) C7E8.2(B) C7E9.2(B) C7E11.1 C7E12.2(B) C7E13.1 C7E14.2(B) C7E15.2(B) C7E16.2(B) C7E17.2(B) C7E18.2(B) C7F1.2(B) C7F2.2(B) C7F3.2(B) C7F4.2(B) C7F5.2(B) C7F6.2(B) C7F7.2(B) C7F8.2(B) C7F9.2(B) C7F10.2(B) C7G1.2(B) C7G2.2(B) C7G3.2(B) C7G4.2(B) C7G5.2(B) C7G6.2(B) C7G7.2(B) C7G8.2(B) C7G9.2(B) C7G10.2(B) C7G11.2(B) C7G12.2(B) C7G13.2(B) C7H1.2(B) C7H2.2(B) C7H3.1 C7H4.2(B) C7H5.2(B) C7H6.2(B) C7H7.2(B) C7H8.2(B) C7H9.2(B) C7H10.2(B) C7H11.2(B) C7J1.2(B) C7J2.2(B) C7J3.2(B) C7J4.2(B) C7J5.2(B) C7J6.2(B) C7J7.2(B) C7J8.2(B) C7L1.2(B) C7L2.2(B) C7L3.2(B) C7L4.2(B) C7L5.2(B) C7L6.2(B) C7L7.2(B) C7L8.2(B) C7M1.2(B) C7M2.2(B) C7M3.2(B) C7M4.2(B) C7M5.2(B) C7M6.2(B) C7M7.2(B) C7M8.2(B) C7R1.2(B) C7R2.2(B) C7R3.2(B) C7R4.2(B) C7R5.2(B) C7R6.2(B) C7R7.2(B) C7R8.2(B) C7R9.2(B) C7R10.2(B) C7T1.2(B) C7U1.2(B) C7U2.2(B) C7U3.2(B) C7W1.2(B) C7W2.2(B) C8A1.2(B) C8A2.2(B) C8A3.2(B) C8A4.2(B) C8A5.2(B) C8B1.2(B) C8B2.2(B) C8B3.2(B) C8B4.2(B) C8B5.2(B) C8B6.2(B) C8B7.2(B) C8B8.2(B) C8B9.2(B) C8B10.2(B) C8B11.2(B) C8B12.2(B) C8B13.2(B) C8B14.2(B) C8B15.2(B) C8B16.2(B) C8B17.2(B) C8B18.2(B) C8B19.2(B) C8B20.2(B) C8B21.2(B) C8B22.2(B) C8B23.2(B) C8B24.2(B) C8B25.2(B) C8B26.2(B) C8B27.2(B) C8B32.2(B) C8B33.2(B) C8B34.2(B) C8B35.2(B) C8B36.2(B) C8C3.2(B) C8C4.2(B) C8C5.2(B) C8C6.2(B) C8C9.2(B) C8C16.2(B) C8C17.2(B) C8C18.2(B) C8C19.2(B) C8C20.2(B) C8C21.2(B) C8C22.2(B) C8C23.2(B) C8C24.2(B) C8C25.2(B) C8C26.2(B) C8C27.1 C8C28.2(B) C8D1.2(B) C8D2.2(B) C8D3.2(B) C8D4.2(B) C8D5.2(B) C8D6.2(B) C8D7.2(B) C8D9.2(B) C8D12.2(B) C8D13.2(B) C8D16.2(B) C8D17.2(B) C8D19.2(B) C8D22.2(B) C8D23.2(B) C8D25.2(B) C8D27.2(B) C8D28.2(B) C8D29.2(B) C8D30.2(B) C8D31.2(B) C8D32.2(B) C8D33.2(B) C8D34.2(B) C8D35.2(B) C8E1.2(B) C8E2.2(B) C8E3.2(B) C8E4.2(B) C8E5.2(B) C8E6.2(B) C8E7.2(B) C8E8.2(B) C8E9.2(B) C8E10.2(B) C8E11.2(B) C8E12.2(B) C8E13.2(B) C8E14.2(B) C8E15.2(B) C8E16.2(B) C8E17.2(B) C8E18.2(B) C8E19.2(B) C8F1.2(B) C8F2.2(B) C8F3.2(B) C8F4.2(B) C8F5.2(B) C8F6.2(B) C8F7.2(B) C8F8.2(B) C8F9.2(B) C8F10.2(B) C8F11.2(B) C8F12.2(B) C8F13.2(B) C8F14.2(B) C8F15.2(B) C8F17.2(B) C8F18.2(B) C8F19.2(B) C8F20.2(B) C8F21.2(B) C8F22.2(B) C8G1.2(B) C8G2.2(B) C8G3.2(B) C8G4.2(B) C8G6.2(B) C8G7.2(B) C8G8.2(B) C8G9.2(B) C8G10.2(B) C8G12.2(B) C8G13.2(B) C8G14.2(B) C8G15.2(B) C8G16.2(B) C8G17.2(B) C8G18.2(B) C8G19.2(B) C8G20.2(B) C8G21.2(B) C8G22.2(B) C8H1.2(B) C8H2.2(B) C8H3.2(B) C8H4.2(B) C8H5.2(B) C8H6.2(B) C8H7.2(B) C8H8.2(B) C8H17.2(B) C8H18.2(B) C8H19.2(B) C8H20.2(B) C8H21.2(B) C8H22.2(B) C8H23.2(B) C8H24.2(B) C8H25.2(B) C8J1.2(B) C8L1.2(B) C8L2.2(B) C8L3.2(B) C8L4.2(B) C8N1.2(B) C9A1.2(B) C9A2.2(B) C9A3.2(B) C9B1.2(B) C9B2.2(B) C9B3.2(B) C9B4.2(B) C9C1.2(B) C9C4.2(B) C9C5.2(B) C9C6.2(B) C9C7.2(B) C9C8.2(B) C9C9.2(B) C9D1.2(B) C9D2.2(B) C9D3.2(B) C9D4.2(B) C9D5.2(B) C9D6.2(B) C9D7.2(B) C9D8.2(B) C9D9.2(B) C9E1.2(B) C9E2.2(B) C9E3.2(B) C9F1.2(B) C9F2.2(B) C9F3.2(B) C9F4.2(B) C9G1.2(B) C9G2.2(B) C9G3.2(B) C9G4.2(B) C9G5.2(B) C9G6.2(B) C9G7.2(B) C9G8.2(B) C9G9.2(B) C9G10.2(B) CP9H1.5(B<0>) CP9H1.6 CP9H1.7 CP9H1.8 CR2A1.3(VN) CR3A2.3(VN) CR3A3.2(A2) CR3A4.2(A2) CR3A5.2(A2) CR3A6.2(A2) CR3A7.2(A2) CR3A8.2(A2) CR3A9.2(A2) CR3A10.2(A2) CR4A1.2(K2) CR4A2.2(K2) CR4A3.2(K2) CR4A4.2(K2) CR4A5.2(K2) CR4A6.2(K2) CR4A8.2(A2) CR4A9.2(A2) CR4A10.2(A2) CR4A11.2(A2) CR4L1.2(K2) CR4L2.2(K2) CR5A1.2(K2) CR5A2.2(K2) CR5A3.1 CR5A4.1 CR5A5.2(K2) CR5A6.2(K2) CR6A1.2 CR6A2.2 CR6A3.2 CR6C1.1 CR6C2.1 CR6C3.2(A2) CR6C4.2(A2) CR6C5.2(A2) CR6C6.1 CR6C7.2(A2) CR6C8.1 CR6D3.1 CR6D4.1 CR7C2.2(K2) CR7C3.2(K2) CR7C5.1 CR7C6.1 CR7C7.1 CR7C8.1 CR9C1.2(K2) CR9C2.2 CR9C3.2 CR9C4.2 CR9D1.2 CR9D2.2 CR9D3.2 CR9H1.2 CR9H1.4(C2) CRP7J1.2 CRP7J1.5(COMMON_2) DS9J1.2(C) EU1B1.61 EU1D1.12 EU1D1.28 EU1D1.32 EU1D2.12 EU1D2.28 EU1D2.32 EU1E2.4 EU1E2.9 EU2A1.3(VN) EU2A2.3(VN) EU2A3.3(VN) EU2A4.3(VN) EU2A5.3(VN) EU2A6.3(VN) EU2A7.49 EU2B1.1 EU2B1.9 EU2B2.12 EU2B2.28 EU2B2.32 EU2B3.12 EU2B3.28 EU2B3.32 EU2B4.12 EU2B4.28 EU2B4.32 EU2G1.1 EU2G1.3 EU2G1.11 EU2G1.14 EU2G1.21 EU2M1.17 EU3A1.3(VN) EU3B1.12 EU3B1.28 EU3B1.32 EU3B2.12 EU3B2.28 EU3B2.32 EU3B3.12 EU3B3.28 EU3B3.32 EU3B4.43 EU3M1.17 EU3M2.17 EU4B1.49 EU4B2.8 EU4B3.12 EU4B3.28 EU4B3.32 EU4B4.12 EU4B4.28 EU4B4.32 EU4B5.43 EU4M1.17 EU5A1.20 EU5A1.51 EU5A1.59 EU5B1.9 EU5B2.29 EU5C2.2 EU5C2.3 EU5C2.9 EU5C3.15 EU5C4.9 EU5D2.12 EU5D2.15 EU5D3.9 EU5F1.2 EU5F1.3 EU5F1.9 EU5G1.1 EU5G1.2 EU5G1.3(S3) EU6A1.49 EU6A2.2 EU6A2.3 EU6A2.15 EU6B1.4 EU6B1.9 EU6B3.8 EU6D1.41 EU7A3.57 EU7G3.4 EU7G3.9 EU7H1.10 EU7H1.17 EU8B1.4 EU8B1.9 EU8B4.4 EU8B4.9 EU8F1.5 EU8F1.9 EU8F2.11 EU8G1.11 EU8G3.5 EU8G3.8 EU8G3.10 EU8G3.12 EU8G3.17 EU8H1.7 EU8H1.13 EU8H2.5 EU8H2.9 EU9E1.4 EU9E1.9 ISO5G1.2(B<0>) ISO6L1.2(B<0>) ISO6L2.2(B<0>) J1A1.1 J1A1.2 J1A1.3 J1A2.1 J1A2.2 J1A2.3 J1A3.1 J1A3.2 J1A4.3(IO3) J1B1.1 J1B2.6 J1B2.7 J1B2.8 J1B2.9 J1B2.13 J1B2.16 J1B2.19 J1B2.22 J1B2.25 J1B2.33 J1B2.40 J1B2.MH1 J1B2.MH2 J1B2.MH3 J1B2.MH4 J1B2.MH5 J1B2.MH6 J1B2.MH7 J1B2.MH8 J1B2.MH9 J1B2.MH10 J1B2.MH11 J1C1.2 J1C1.7 J1C1.8 J1C1.13 J1C1.14 J1C1.19 J1C1.20 J1C1.25 J1C1.26 J1C1.31 J1C1.32 J1C1.37 J1C1.38 J1C1.49 J1C1.50 J1C1.59 J1D1.2(IO2) J1D2.1 J1D4.2(IO2) J1D9.3(IO3) J1E1.2(IO2) J1E5.2 J1E5.4 J1E5.6 J1E5.9 J1E5.11 J1E5.13 J1E5.15 J1E5.17 J1E5.20 J1E5.22 J1E5.24 J1E5.26 J1E5.28 J1E5.31 J1E5.33 J1E5.35 J1E5.37 J1E5.39 J1E5.42 J1E5.44 J1E5.46 J1E5.48 J1E5.50 J1E5.53 J1E5.55 J1E5.57 J1E5.94 J1E5.96 J1E5.98 J1E5.101 J1E5.103 J1E5.105 J1E5.107 J1E5.109 J1E5.112 J1E5.114 J1E5.116 J1E5.118 J1E5.120 J1E5.123 J1E5.125 J1E5.127 J1E5.129 J1E5.131 J1E5.134 J1E5.136 J1E5.138 J1E5.147 J1E5.149 J1E5.151 J1E5.154 J1E5.156 J1E5.158 J1E5.160 J1E5.162 J1E5.165 J1E5.167 J1E5.169 J1E5.171 J1E5.173 J1E5.176 J1E5.178 J1E5.180 J1E5.182 J1E5.184 J1E5.187 J1E5.189 J1E5.191 J1E5.193 J1E5.195 J1E5.198 J1E5.200 J1E5.202 J1E5.238 J1E5.239 J1E5.241 J1E5.243 J1E5.246 J1E5.248 J1E5.250 J1E5.252 J1E5.254 J1E5.257 J1E5.259 J1E5.261 J1E5.263 J1E5.265 J1E5.268 J1E5.270 J1E5.272 J1E5.274 J1E5.276 J1E5.279 J1E5.281 J1E5.283 J1F1.2 J1F1.4 J1F1.6 J1F1.9 J1F1.11 J1F1.13 J1F1.15 J1F1.17 J1F1.20 J1F1.22 J1F1.24 J1F1.26 J1F1.28 J1F1.31 J1F1.33 J1F1.35 J1F1.37 J1F1.39 J1F1.42 J1F1.44 J1F1.46 J1F1.48 J1F1.50 J1F1.53 J1F1.55 J1F1.57 J1F1.94 J1F1.96 J1F1.98 J1F1.101 J1F1.103 J1F1.105 J1F1.107 J1F1.109 J1F1.112 J1F1.114 J1F1.116 J1F1.118 J1F1.120 J1F1.123 J1F1.125 J1F1.127 J1F1.129 J1F1.131 J1F1.134 J1F1.136 J1F1.138 J1F1.147 J1F1.149 J1F1.151 J1F1.154 J1F1.156 J1F1.158 J1F1.160 J1F1.162 J1F1.165 J1F1.167 J1F1.169 J1F1.171 J1F1.173 J1F1.176 J1F1.178 J1F1.180 J1F1.182 J1F1.184 J1F1.187 J1F1.189 J1F1.191 J1F1.193 J1F1.195 J1F1.198 J1F1.200 J1F1.202 J1F1.238 J1F1.239 J1F1.241 J1F1.243 J1F1.246 J1F1.248 J1F1.250 J1F1.252 J1F1.254 J1F1.257 J1F1.259 J1F1.261 J1F1.263 J1F1.265 J1F1.268 J1F1.270 J1F1.272 J1F1.274 J1F1.276 J1F1.279 J1F1.281 J1F1.283 J1F2.2 J1F2.4 J1F2.6 J1F2.9 J1F2.11 J1F2.13 J1F2.15 J1F2.17 J1F2.20 J1F2.22 J1F2.24 J1F2.26 J1F2.28 J1F2.31 J1F2.33 J1F2.35 J1F2.37 J1F2.39 J1F2.42 J1F2.44 J1F2.46 J1F2.48 J1F2.50 J1F2.53 J1F2.55 J1F2.57 J1F2.94 J1F2.96 J1F2.98 J1F2.101 J1F2.103 J1F2.105 J1F2.107 J1F2.109 J1F2.112 J1F2.114 J1F2.116 J1F2.118 J1F2.120 J1F2.123 J1F2.125 J1F2.127 J1F2.129 J1F2.131 J1F2.134 J1F2.136 J1F2.138 J1F2.147 J1F2.149 J1F2.151 J1F2.154 J1F2.156 J1F2.158 J1F2.160 J1F2.162 J1F2.165 J1F2.167 J1F2.169 J1F2.171 J1F2.173 J1F2.176 J1F2.178 J1F2.180 J1F2.182 J1F2.184 J1F2.187 J1F2.189 J1F2.191 J1F2.193 J1F2.195 J1F2.198 J1F2.200 J1F2.202 J1F2.238 J1F2.239 J1F2.241 J1F2.243 J1F2.246 J1F2.248 J1F2.250 J1F2.252 J1F2.254 J1F2.257 J1F2.259 J1F2.261 J1F2.263 J1F2.265 J1F2.268 J1F2.270 J1F2.272 J1F2.274 J1F2.276 J1F2.279 J1F2.281 J1F2.283 J1F3.2 J1F3.4 J1F3.6 J1F3.9 J1F3.11 J1F3.13 J1F3.15 J1F3.17 J1F3.20 J1F3.22 J1F3.24 J1F3.26 J1F3.28 J1F3.31 J1F3.33 J1F3.35 J1F3.37 J1F3.39 J1F3.42 J1F3.44 J1F3.46 J1F3.48 J1F3.50 J1F3.53 J1F3.55 J1F3.57 J1F3.94 J1F3.96 J1F3.98 J1F3.101 J1F3.103 J1F3.105 J1F3.107 J1F3.109 J1F3.112 J1F3.114 J1F3.116 J1F3.118 J1F3.120 J1F3.123 J1F3.125 J1F3.127 J1F3.129 J1F3.131 J1F3.134 J1F3.136 J1F3.138 J1F3.147 J1F3.149 J1F3.151 J1F3.154 J1F3.156 J1F3.158 J1F3.160 J1F3.162 J1F3.165 J1F3.167 J1F3.169 J1F3.171 J1F3.173 J1F3.176 J1F3.178 J1F3.180 J1F3.182 J1F3.184 J1F3.187 J1F3.189 J1F3.191 J1F3.193 J1F3.195 J1F3.198 J1F3.200 J1F3.202 J1F3.238 J1F3.239 J1F3.241 J1F3.243 J1F3.246 J1F3.248 J1F3.250 J1F3.252 J1F3.254 J1F3.257 J1F3.259 J1F3.261 J1F3.263 J1F3.265 J1F3.268 J1F3.270 J1F3.272 J1F3.274 J1F3.276 J1F3.279 J1F3.281 J1F3.283 J2A1.B2 J2A1.B5 J2A1.B8 J2A1.B11 J2A1.B17 J2A1.MH1 J2A1.MH2 J2A1.MH3 J2A1.MH4 J2A1.T2 J2A1.T5 J2A1.T8 J2A1.T11 J2A1.T16 J2A1.T19 J3A1.14 J3A1.17 J3A1.24 J3A1.27 J3A1.34 J3A1.38 J3A1.MH1 J3A1.MH2 J3A1.MH3 J3A1.MH4 J3A1.MH5 J3A1.MH6 J3A2.2 J3A2.5 J3A2.8 J3A2.11 J3A2.17 J3A2.MH1 J3A2.MH2 J3A2.MH3 J3A2.MH4 J3D1.A4 J3D1.A7 J3D1.A13 J3D1.A36 J3D1.A38 J3D1.AA6 J3D1.AA33 J3D1.AB5 J3D1.AC4 J3D1.AC8 J3D1.AC34 J3D1.AC35 J3D1.AC36 J3D1.AD3 J3D1.AD33 J3D1.AD37 J3D1.AD38 J3D1.AD39 J3D1.AD40 J3D1.AE1 J3D1.AE5 J3D1.AE6 J3D1.AE7 J3D1.AE8 J3D1.AE33 J3D1.AE35 J3D1.AE37 J3D1.AF4 J3D1.AF33 J3D1.AF35 J3D1.AF37 J3D1.AF39 J3D1.AG1 J3D1.AG2 J3D1.AG3 J3D1.AG4 J3D1.AG6 J3D1.AG7 J3D1.AG33 J3D1.AG37 J3D1.AG39 J3D1.AH4 J3D1.AH34 J3D1.AH35 J3D1.AH36 J3D1.AH37 J3D1.AJ2 J3D1.AJ4 J3D1.AJ5 J3D1.AJ6 J3D1.AJ7 J3D1.AJ8 J3D1.AJ11 J3D1.AJ25 J3D1.AJ29 J3D1.AJ33 J3D1.AJ37 J3D1.AJ38 J3D1.AJ39 J3D1.AJ40 J3D1.AK2 J3D1.AK4 J3D1.AK9 J3D1.AK12 J3D1.AK24 J3D1.AK27 J3D1.AK29 J3D1.AK31 J3D1.AK33 J3D1.AK35 J3D1.AK37 J3D1.AL4 J3D1.AL6 J3D1.AL7 J3D1.AL9 J3D1.AL13 J3D1.AL14 J3D1.AL15 J3D1.AL16 J3D1.AL17 J3D1.AL19 J3D1.AL20 J3D1.AL21 J3D1.AL22 J3D1.AL23 J3D1.AL25 J3D1.AL27 J3D1.AL29 J3D1.AL31 J3D1.AL33 J3D1.AL35 J3D1.AL37 J3D1.AL39 J3D1.AM1 J3D1.AM2 J3D1.AM3 J3D1.AM4 J3D1.AM9 J3D1.AM10 J3D1.AM11 J3D1.AM25 J3D1.AM29 J3D1.AM33 J3D1.AM37 J3D1.AM39 J3D1.AN4 J3D1.AN5 J3D1.AN6 J3D1.AN7 J3D1.AN8 J3D1.AN9 J3D1.AN13 J3D1.AN14 J3D1.AN16 J3D1.AN18 J3D1.AN20 J3D1.AN22 J3D1.AN24 J3D1.AN26 J3D1.AN27 J3D1.AN28 J3D1.AN29 J3D1.AN30 J3D1.AN31 J3D1.AN32 J3D1.AN33 J3D1.AN34 J3D1.AN35 J3D1.AN36 J3D1.AN37 J3D1.AP2 J3D1.AP4 J3D1.AP9 J3D1.AP11 J3D1.AP13 J3D1.AP27 J3D1.AP32 J3D1.AP37 J3D1.AP38 J3D1.AP39 J3D1.AP40 J3D1.AR2 J3D1.AR4 J3D1.AR6 J3D1.AR7 J3D1.AR9 J3D1.AR11 J3D1.AR13 J3D1.AR15 J3D1.AR17 J3D1.AR19 J3D1.AR21 J3D1.AR23 J3D1.AR25 J3D1.AR27 J3D1.AR29 J3D1.AR30 J3D1.AR32 J3D1.AR34 J3D1.AR35 J3D1.AR37 J3D1.AT4 J3D1.AT9 J3D1.AT13 J3D1.AT15 J3D1.AT16 J3D1.AT17 J3D1.AT18 J3D1.AT20 J3D1.AT22 J3D1.AT27 J3D1.AT32 J3D1.AT37 J3D1.AT39 J3D1.AU1 J3D1.AU2 J3D1.AU3 J3D1.AU4 J3D1.AU5 J3D1.AU6 J3D1.AU7 J3D1.AU8 J3D1.AU9 J3D1.AU10 J3D1.AU11 J3D1.AU12 J3D1.AU26 J3D1.AU28 J3D1.AU29 J3D1.AU30 J3D1.AU31 J3D1.AU33 J3D1.AU34 J3D1.AU35 J3D1.AU36 J3D1.AU37 J3D1.AU39 J3D1.AV6 J3D1.AV10 J3D1.AV12 J3D1.AV21 J3D1.AV32 J3D1.AV37 J3D1.AW4 J3D1.AW6 J3D1.AW8 J3D1.AW12 J3D1.AW32 J3D1.AW34 J3D1.AW35 J3D1.AW37 J3D1.AY3 J3D1.AY6 J3D1.AY12 J3D1.AY32 J3D1.B10 J3D1.B24 J3D1.B26 J3D1.B28 J3D1.B30 J3D1.B32 J3D1.B34 J3D1.C2 J3D1.C5 J3D1.C8 J3D1.C12 J3D1.C13 J3D1.C37 J3D1.C39 J3D1.D4 J3D1.D7 J3D1.D9 J3D1.D11 J3D1.D15 J3D1.D18 J3D1.D20 J3D1.D22 J3D1.D24 J3D1.D26 J3D1.D28 J3D1.D30 J3D1.D32 J3D1.D36 J3D1.D39 J3D1.E3 J3D1.E5 J3D1.E8 J3D1.E9 J3D1.E10 J3D1.E11 J3D1.E13 J3D1.E14 J3D1.E16 J3D1.E35 J3D1.E38 J3D1.F1 J3D1.F4 J3D1.F7 J3D1.F10 J3D1.F12 J3D1.F14 J3D1.F16 J3D1.F18 J3D1.F20 J3D1.F22 J3D1.F24 J3D1.F26 J3D1.F28 J3D1.F30 J3D1.F32 J3D1.F34 J3D1.F37 J3D1.F40 J3D1.G5 J3D1.G8 J3D1.G15 J3D1.G35 J3D1.G38 J3D1.H4 J3D1.H7 J3D1.H9 J3D1.H11 J3D1.H13 J3D1.H16 J3D1.H18 J3D1.H20 J3D1.H22 J3D1.H24 J3D1.H26 J3D1.H28 J3D1.H30 J3D1.H32 J3D1.H34 J3D1.H37 J3D1.H40 J3D1.J3 J3D1.J5 J3D1.J8 J3D1.J10 J3D1.J11 J3D1.J12 J3D1.J13(VSS_299) J3D1.J14 J3D1.J16 J3D1.J35 J3D1.J38 J3D1.K1 J3D1.K4 J3D1.K7 J3D1.K8 J3D1.K10 J3D1.K14 J3D1.K15 J3D1.K18 J3D1.K20 J3D1.K22 J3D1.K24 J3D1.K26 J3D1.K28 J3D1.K30 J3D1.K34 J3D1.K37 J3D1.K40 J3D1.L5 J3D1.L8 J3D1.L9 J3D1.L10 J3D1.L16 J3D1.M4 J3D1.M7 J3D1.M13 J3D1.M18 J3D1.M20 J3D1.M22 J3D1.M24 J3D1.M26 J3D1.M28 J3D1.M30 J3D1.M34 J3D1.M36 J3D1.M39 J3D1.N3 J3D1.N5 J3D1.N8 J3D1.N10 J3D1.N16 J3D1.N33 J3D1.P1 J3D1.P4 J3D1.P7 J3D1.P32 J3D1.P35 J3D1.P40 J3D1.R5 J3D1.R8 J3D1.R37 J3D1.R38 J3D1.R39 J3D1.T2 J3D1.T8 J3D1.T34 J3D1.T35 J3D1.T36 J3D1.U3 J3D1.U4 J3D1.U6 J3D1.U32 J3D1.V6 J3D1.V8 J3D1.V35 J3D1.V37 J3D1.V39 J3D1.W4 J3D1.W33 J3D1.Y5 J3D1.Y8 J3D1.Y35 J3D1.Y37 J4A1.A1 J4A1.A12 J4A1.B1 J4A1.B12 J4A1.MH1 J4A1.MH2 J4A1.MH3 J4A1.MH4 J4A1.MH5 J4A1.MH6 J4A2.4 J4A2.7 J4A2.13 J4A2.16 J4A2.33 J4A2.34 J4A2.35 J4A2.36 J4A2.37 J4A2.38 J4A2.39 J4A2.40 J4G1.3 J4G1.5 J4G1.7 J4G1.15 J4G1.17 J4G1.18 J4G1.19 J4G1.24 J4H1.3(IO3) J4J2.2(IO2) J4J4.2(IO2) J4R1.1 J4R1.6(GND_6) J4R1.11 J4R1.16 J4R1.21 J4R1.26 J4R1.31 J4R1.36 J4R1.41 J5B1.3 J5B2.A4 J5B2.A12 J5B2.A15 J5B2.A18 J5B2.A20 J5B2.A23 J5B2.A24 J5B2.A27 J5B2.A28 J5B2.A31 J5B2.A34 J5B2.A37 J5B2.A38 J5B2.A41 J5B2.A42 J5B2.A45 J5B2.A46 J5B2.A49 J5B2.A51 J5B2.A54 J5B2.A55 J5B2.A58 J5B2.A59 J5B2.A62 J5B2.A63 J5B2.A66 J5B2.A67 J5B2.A70 J5B2.A71 J5B2.A74 J5B2.A75 J5B2.A78 J5B2.A79 J5B2.A82 J5B2.B4 J5B2.B7 J5B2.B13 J5B2.B16 J5B2.B18 J5B2.B21 J5B2.B22 J5B2.B25 J5B2.B26 J5B2.B29 J5B2.B32 J5B2.B35 J5B2.B36 J5B2.B39 J5B2.B40 J5B2.B43 J5B2.B44 J5B2.B47 J5B2.B49 J5B2.B52 J5B2.B53 J5B2.B56 J5B2.B57 J5B2.B60 J5B2.B61 J5B2.B64 J5B2.B65 J5B2.B68 J5B2.B69 J5B2.B72 J5B2.B73 J5B2.B76 J5B2.B77 J5B2.B80 J5B3.1 J5B3.3 J5B3.9 J5B3.15 J5B3.21 J5B3.27 J5B3.33 J5B3.39 J5B3.45 J5B3.51 J5B3.57 J5B3.71 J5B3.73 J5B3.75 J5B3.MP1 J5B3.MP2 J5D1.1(GND) J5E1.1(GND) J5H1.A3 J5H1.A6 J5H1.A9 J5H1.B3 J5H1.B6 J5H1.B9 J5H1.C3 J5H1.C6 J5H1.C9 J5H1.D3 J5H1.D6 J5H1.D9 J5H1.MH1 J5H1.MH2 J5J1.7 J5J1.8 J5J1.19 J5J1.20 J5J2.1 J5J2.4 J5J2.7 J5J2.11 J5J2.12 J5J2.13 J5J2.17 J5J2.19 J5J2.M1 J5J2.M2 J6B1.5 J6B1.14 J6B2.1(GND) J6B5.4 J6B5.7 J6B5.MH1 J6B5.MH2 J6B5.MH3 J6B5.MH4 J6C3.MH1 J6C3.MH2 J6C3.MH3 J6C3.MH4 J6C3.MH5 J6C3.MH6 J6C3.P1 J6C3.P4 J6C3.P7 J6C3.P11 J6C3.P14 J6C3.P17 J6C4.MH1 J6C4.MH2 J6C4.MH3 J6C4.MH4 J6C4.MH5 J6C4.MH6 J6C4.P4 J6C4.P14 J6C4.P17 J6G1.1 J6G1.4 J6G2.1 J6G2.4 J6H1.1 J6H1.4 J6H2.1 J6H2.2 J6H2.6 J6H2.7 J6H2.8 J6H2.13 J6H2.14 J6H2.19 J6H2.20 J6H2.22 J6H2.25 J6H2.26 J6H2.31 J6H2.32 J6H2.37 J6H2.38 J6H2.49 J6H2.50 J6H2.59 J6H2.60 J6J1.5 J6J1.19 J6J1.20 J6J2.2 J6J2.3 J6J2.6 J6J2.10 J6J2.12 J6J2.13 J6J2.16 J6J2.18 J6J2.22 J6J2.26 J6J2.33 J6J2.34 J6J2.36 J6J2.41 J6J2.42 J6J2.45 J6J2.50 J6J2.58 J6J2.64 J6J2.65 J6J2.73 J6J2.75 J6J2.77 J6J2.79 J6J2.82 J6J2.83 J6J2.88 J6J2.95 J6J2.105 J6J2.107 J6J2.109 J6J2.114 J6J2.122 J6J2.124 J6J2.129 J6J2.145 J6J2.150 J6J2.152 J6J2.154 J6J2.162 J6J2.169 J6J2.172 J6J2.176 J6J2.178 J6J2.193 J6J2.195 J6J2.197 J6J2.200 J6J2.202 J6J2.209 J6J2.214 J6J2.218 J6J2.226 J6J2.228 J6J2.233 J6J2.235 J6J2.240(AIO240) J7A1.MH1 J7A1.MH2 J7A2.6 J7A2.9(IO9) J7A2.10 J7B1.A1 J7B1.A4 J7B1.A12 J7B1.A15 J7B1.A18 J7B1.A20 J7B1.A23 J7B1.A24 J7B1.A27 J7B1.A28 J7B1.A31 J7B1.B4 J7B1.B7 J7B1.B13 J7B1.B16 J7B1.B18 J7B1.B21 J7B1.B22 J7B1.B25 J7B1.B26 J7B1.B29 J7B1.B32 J7C1.1 J7C1.7 J7C1.13 J7C1.18 J7C1.19 J7C1.33 J7C1.39 J7C1.45 J7C1.51 J7C1.57 J7C1.63 J7C1.69 J7C1.75 J7C2.2 J7C2.MH1 J7C2.MH2 J7C3.2 J7C3.MH1 J7C3.MH2 J7C7.3 J7C7.4 J7C9.2 J7G1.17 J7G1.18 J7G1.35 J7G1.44 J7G2.5 J7G2.14 J7H1.1 J7H1.2 J7H1.5 J7H1.8 J7H1.9 J7J1.2 J7J1.12 J7J1.17 J7J4.3 J7J4.4 J7J6.3 J7J6.9(P9) J7J6.MH1 J7J6.MH2 J7J6.MH3 J7J6.MH4 J7J6.MH5 J8B1.A1 J8B1.A4 J8B1.A12 J8B1.A15 J8B1.A18 J8B1.A20 J8B1.A23 J8B1.A24 J8B1.A27 J8B1.A28 J8B1.A31 J8B1.B4 J8B1.B7 J8B1.B13 J8B1.B16 J8B1.B18 J8B1.B21 J8B1.B22 J8B1.B25 J8B1.B26 J8B1.B29 J8B1.B32 J8H1.3 J8H1.9 J8H1.15 J8H1.21 J8H1.27 J8H1.33 J8H1.39 J8H1.45 J8H1.51 J8H1.57 J8H1.71 J8H1.73 J8H1.75 J8H2.5 J8H2.8 J8H2.13 J8H2.14 J8H2.19 J8H2.26 J8H2.27 J8H2.28 J8H2.29 J8H2.30 J8H2.39 J8H2.45 J8H2.49 J8H2.61 J8H2.62 J8H2.63 J8H2.64 J8H6.4(IO4) J8J1.3(IO3) J8J5.2 J8J7.1 J8J8.2 J8J10.1 J8J11.1 J8J12.2 J8J13.16 J9A3.2 J9A4.2 J9A4.6 J9A4.16 J9A5.3 J9B1.3 J9B1.7 J9B2.2 J9B2.4(IO4) J9B3.2 J9B3.4(IO4) J9B4.6(IO6) J9B7.9(IO9) J9D1.6(VSS) J9D1.9 J9D1.11 J9D1.12 J9D1.13 J9D1.14 J9D2.10 J9D3.5 J9D3.6(IO6) J9D4.5(P5) J9D4.6 J9D4.7 J9D5.8(IO8) J9E4.2(IO2) J9E8.2(IO2) J9E9.5 J9E9.14 J9F2.2(IO2) J9F3.2(IO2) J9F5.3 J9F6.2 J9G1.2(IO2) J9G5.2(IO2) J9G6.2(IO2) J9G7.2(IO2) J9H1.5 J9H1.8 J9H2.8(IO8) J9H3.8(IO8) J9H4.5 J9H4.6(IO6) J9J1.5 J9J1.6(IO6) J9J2.8(IO8) MH1B1.1 MH1B1.2 MH1B1.3 MH1B1.4 MH1B1.5 MH1B1.6 MH1B1.7 MH1B1.8 MH1F1.1 MH1F1.2 MH1F1.3 MH1F1.4 MH1F1.5 MH1F1.6 MH1F1.7 MH1F1.8 MH1H1.1 MH1H1.2 MH1H1.3 MH1H1.4 MH1H1.5 MH1H1.6 MH1H1.7 MH1H1.8 MH5A1.1 MH5A1.2 MH5A1.3 MH5A1.4 MH5A1.5 MH5A1.6 MH5A1.7 MH5A1.8 MH5F1.1 MH5F1.2 MH5F1.3 MH5F1.4 MH5F1.5 MH5F1.6 MH5F1.7 MH5F1.8 MH5H1.1 MH5H1.2 MH5H1.3 MH5H1.4 MH5H1.5 MH5H1.6 MH5H1.7 MH5H1.8 MH7A1.1 MH7A1.2 MH7A1.3 MH7A1.4 MH7A1.5 MH7A1.6 MH7A1.7 MH7A1.8 MH9A1.1 MH9A1.2 MH9A1.3 MH9A1.4 MH9A1.5 MH9A1.6 MH9A1.7 MH9A1.8 MH9F1.1 MH9F1.2 MH9F1.3 MH9F1.4 MH9F1.5 MH9F1.6 MH9F1.7 MH9F1.8 MH9H1.1 MH9H1.2 MH9H1.3 MH9H1.4 MH9H1.5 MH9H1.6 MH9H1.7 MH9H1.8 Q1C3.2(S) Q2A5.2(SRC) Q2A8.2(SRC) Q2G1.2(SRC) Q3G2.1(S) Q3G2.4 Q3G3.2(S) Q4G1.1(S) Q4G1.4 Q4H1.1(E<0>) Q4H1.4 Q4H2.1(S) Q4H2.4 Q4H5.2(E) Q5C2.4 Q5C3.1(S) Q5C3.4 Q5C4.4 Q5D1.1(S) Q5D1.4 Q5E1.1(S) Q5E1.4 Q5E2.1(S) Q5E2.4 Q5E3.2(S) Q5M1.2(SRC) Q5M3.2(SRC) Q6A1.1(S) Q6A1.4 Q6A2.1(S) Q6A2.4 Q6L1.2(S) Q7A1.1(S) Q7A1.4 Q7B1.1(S) Q7B1.4 Q7B2.2(S) Q7B3.2(S) Q7B6.2(S) Q7C1.1(S) Q7C1.4 Q7F1.2(SRC) Q7G1.2(S) Q7G2.1(E<0>) Q7H1.1(E<0>) Q7H1.4 Q8C5.2(S) Q8C6.2(S) Q8C7.1(S) Q8C7.4 Q8C8.2(S) Q8C9.1(S) Q8C9.4 Q8C10.1(S) Q8C10.4 Q8C11.1(S) Q8C11.4 Q8C12.2 Q8C13.4 Q8D1.1(S) Q8D1.4 Q8D2.2(SRC) Q8D3.2(VSS) Q8D4.2(VSS) Q8D5.2(S) Q8D7.2(S) Q8D8.2(S) Q8D9.2(S) Q8D10.2(VSS) Q8D11.2(S) Q8D12.2(S) Q8D13.2(SRC) Q8D14.2(SRC) Q8E1.2(S) Q8E2.2(S) Q8E3.2(S) Q8E4.2(S) Q8F1.2(S) Q8G5.2(S) Q8G6.2(S) Q8H1.1(E2) Q8H2.2(S) Q8H3.2(SRC) Q8H4.2(SRC) Q8H5.1(E2) Q8H6.2(SRC) Q8H7.2(SRC) Q9G1.2(S) Q9G2.2(S) Q9G3.2(S) Q9G6.1(S) Q9G6.4 R1A5.2(B) R1A6.2(B) R1B7.2(B) R1B10.2(B) R1B16.2(B) R1B23.2(B) R1B34.1 R1B40.2(B) R1B42.2(B) R1B43.1 R1B44.2(B) R1B47.2(B) R1B48.2(B) R1B49.2(B) R1C9.2(B) R1C15.2(B) R1C31.1 R1E4.2(B) R1E8.2(B) R1E12.2(B) R1E16.2(B) R1E17.2(B) R1E19.2(B) R1E20.2(B) R1E33.2(B) R1E35.2(B) R1E38.2(B) R1E40.2(B) R1E47.2(B) R1F5.2(B) R1F7.2(B) R1F8.2(B) R1F21.2(B) R1F25.2(B) R1F32.2(B) R1F43.2(B) R1F50.2(B) R2A2.2(B) R2A7.2(B) R2A9.2(B) R2A10.2(B) R2A19.1 R2A37.2(B) R2A43.2(B) R2A49.2(B) R2A63.2(B) R2A66.2(B) R2A67.2(B) R2A68.1 R2A69.2(B) R2B9.2(B) R2B14.2(B) R2B30.2(B) R2B34.2(B) R2B35.1 R2B41.2(B) R2B47.2(B) R2B59.2(B) R2C4.2(B) R2C7.1 R2C12.2(B) R2C16.2(B) R2C17.2(B) R2C28.2(B) R2G15.1 R2G34.2(B) R2G35.1 R2G36.2(B) R3A1.2(B) R3A2.2(B) R3A5.2(B) R3A22.2(B) R3A24.2(B) R3A28.2(B) R3A31.2(B) R3A32.2(B) R3A34.2(B) R3A35.2(B) R3A40.2(B) R3A46.2(B) R3B8.2(B) R3B9.1 R3B10.1 R3B13.2(B) R3B14.2(B) R3B15.2(B) R3B22.2(B) R3B23.2(B) R3B24.2(B) R3B25.1 R3B36.2(B) R3B37.2(B) R3B38.2(B) R3B39.2(B) R3B43.2(B) R3G42.2(B) R3H28.2(B) R3H29.2(B) R3H33.2(B) R3H38.2(B) R3H39.2(B) R3H40.2(B) R3H41.2(B) R3L1.1 R3L3.2(B) R3M3.2(B) R3M4.2(B) R3M5.2(B) R3M6.2(B) R3M13.2(B) R4A1.2(B) R4A4.2(B) R4A11.1 R4A13.2(B) R4A14.2(B) R4A16.2(B) R4A17.2(B) R4A22.2(B) R4A25.1 R4B3.2(B) R4B5.2(B) R4B13.2(B) R4B14.2(B) R4B19.1 R4B27.2(B) R4B30.2(B) R4C5.2(B) R4D2.2(B) R4G10.2(B) R4G14.2(B) R4G18.2(B) R4H4.2(B) R4H23.2(B) R4H31.2(B) R4H35.2(B) R4H36.2(B) R4H38.2(B) R4H39.2(B) R4H44.2(B) R4J4.2(B) R4J7.2(B) R4M1.2(B) R4M2.2(B) R4M5.2(B) R4M6.2(B) R5A23.2(B) R5A28.2(B) R5A34.2(B) R5A35.2(B) R5A41.2(B) R5A42.2(B) R5A48.2(B) R5A50.2(B) R5A51.2(B) R5A56.2(B) R5A64.2(B) R5B8.2(B) R5B16.2(B) R5B17.2(B) R5B38.2(B) R5B39.2(B) R5B63.2(B) R5B64.1 R5B68.2(B) R5B86.2(B) R5C8.2(B) R5C24.2(B) R5C38.2(B) R5C41.2(B) R5C42.2(B) R5C43.2(B) R5C47.2(B) R5C54.2(B) R5D10.2(B) R5D13.2(B) R5D14.2(B) R5D19.2(B) R5D21.2(B) R5D22.2(B) R5D24.2(B) R5D28.2(B) R5D37.2(B) R5E14.2(B) R5E50.2(B) R5E51.2(B) R5E52.2(B) R5E54.2(B) R5E57.2(B) R5F4.2(B) R5F8.2(B) R5F15.2(B) R5F17.2(B) R5F18.2(B) R5G20.2(B) R5G23.2(B) R5L3.2(B) R5L5.2(B) R5L8.2(B) R5L9.2(B) R5L10.2(B) R5L14.2(B) R5L16.2(B) R5L19.2(B) R5L20.2(B) R5L23.2(B) R5M6.2(B) R5M7.2(B) R5M9.2(B) R5M10.2(B) R6A32.2(B) R6A39.2(B) R6A43.2(B) R6A44.2(B) R6A45.2(B) R6A46.2(B) R6A47.2(B) R6A59.2(B) R6A66.2(B) R6A69.2(B) R6A71.1 R6A75.2(B) R6A78.2(B) R6B1.1 R6B6.2(B) R6B11.1 R6B12.2(B) R6B19.1 R6B25.2(B) R6B27.2(B) R6B35.2(B) R6C19.2(B) R6C21.2(B) R6D3.2(B) R6D4.2(B) R6D5.2(B) R6D6.2(B) R6D26.2(B) R6D27.2(B) R6D28.2(B) R6D32.2(B) R6D36.2(B) R6D43.2(B) R6D44.2(B) R6D52.2(B) R6D53.2(B) R6D65.1 R6D68.1 R6F3.2(B) R6F5.2(B) R6G2.2(B) R6G7.2(B) R6G12.2(B) R6J9.2(B) R6J17.2(B) R6J18.2(B) R6R1.2(B) R6T6.2(B) R6T18.2(B) R7A6.1 R7A8.2(B) R7A11.2(B) R7A13.2(B) R7B36.2(B) R7B44.2(B) R7B45.2(B) R7B53.2(B) R7B64.2(B) R7B79.2(B) R7B82.2(B) R7B84.2(B) R7C2.2(B) R7C15.2(B) R7C21.2(B) R7C30.1 R7C45.2(B) R7D25.2(B) R7D33.2(B) R7D35.2(B) R7D39.2(B) R7D41.2(B) R7D51.2(B) R7E8.2(B) R7E11.2(B) R7E15.2(B) R7E20.2(B) R7E22.2(B) R7E31.2(B) R7E37.2(B) R7E43.2(B) R7E51.2(B) R7E55.2(B) R7F2.1 R7F3.2(B) R7F13.2(B) R7F22.2(B) R7F24.2(B) R7F37.2(B) R7F38.2(B) R7F39.2(B) R7F47.2(B) R7G2.2(B) R7G7.2(B) R7G36.2(B) R7H2.2(B) R7H22.2(B) R7H24.2(B) R7H28.2(B) R7H39.2(B) R7H46.2(B) R7H54.1 R7H57.2(B) R7J1.2(B) R7J11.2(B) R7M1.2(B) R7P3.2(B) R7P9.2(B) R7R4.2(B) R7R6.2(B) R7R7.2(B) R7R8.2(B) R7R47.2(B) R7R50.2(B) R7R51.2(B) R7T10.2(B) R7T17.2(B) R7T26.2(B) R7U12.2(B) R7U34.2(B) R8B39.2(B) R8C1.2(B) R8C13.2(B) R8C19.2(B) R8C20.2(B) R8C42.2(B) R8C48.2(B) R8C52.2(B) R8C54.2(B) R8C55.2(B) R8C62.2(B) R8C71.2(B) R8C75.2(B) R8C76.2(B) R8D10.2(B) R8D13.2(B) R8D24.2(B) R8D25.2(B) R8D27.2(B) R8D46.2(B) R8D64.2(B) R8D66.2(B) R8D69.2(B) R8D77.1 R8D85.2(B) R8E8.2(B) R8E18.2(B) R8E20.2(B) R8E24.2(B) R8E26.2(B) R8E32.2(B) R8E43.2(B) R8E52.2(B) R8E53.2(B) R8E66.2(B) R8F6.2(B) R8F10.2(B) R8F15.2(B) R8F31.2(B) R8F34.2(B) R8F48.2(B) R8G7.2(B<0>) R8G13.2(B) R8G19.2(B) R8G20.1 R8G30.2(B) R8G38.2(B) R8G40.2(B) R8G61.2(B) R8G65.2(B) R8G67.1 R8G76.2(B) R8G77.2(B) R8G87.2(B) R8H7.1 R8H40.2(B) R8H43.2(B) R8H45.2(B) R8H49.2(B) R8H53.2(B) R8H55.2(B) R8H56.2(B) R8H64.2(B) R8H67.2(B) R8H68.2(B) R8H76.2(B) R8J2.2(B) R8J4.2(B) R8J6.2(B) R8J9.1 R8J11.2(B) R8J22.2(B) R8L5.2(B) R9A3.2(B) R9A22.2(B) R9B4.1 R9B8.1 R9C2.2(B) R9C6.2(B) R9C13.2(B) R9C22.2(B) R9D13.2(B) R9D23.2(B) R9D25.1 R9E3.2(B) R9E5.2(B) R9E8.2(B) R9E10.2(B) R9E11.2(B) R9E13.2(B) R9E14.2(B) R9E16.2(B) R9E18.2(B) R9E21.2(B) R9E23.2(B) R9E27.2(B) R9E28.2(B) R9F3.2(B) R9F13.2(B) R9F25.2(B) R9F26.2(B) R9G6.2(B) R9G10.2(B) R9G11.2(B) R9G22.2(B) R9G25.2(B) R9G30.2(B) R9H20.2(B) RM8E1.1(GND) RM8F1.1(GND) RT8G1.2(B<0>) SW5H1.3 SW5H1.4(P4) SW5H2.3 SW5H2.4(P4) SW8F1.3 SW8F1.4(P4) U1B1.2 U1B1.4 U1B2.3 U1E1.B4 U1E2.B4 U1E3.B4 U2B1.4 U2G1.5 U2G1.6 U2G1.7(TR2 SOURCE3) U2G2.7 U2G3.3 U3A4.3 U3A5.B3 U3A5.B6 U3A5.D4 U3A5.D5 U3A5.E4 U3A5.E5 U3A5.G3 U3A5.G6 U3A6.3 U3A6.8 U3A7.3 U3A7.8 U3H1.B4 U3H2.B4 U4A1.3 U4A1.8 U4A2.3 U4A2.8 U4C1.8 U4C2.8 U4C3.8 U4H1.B4 U4H2.B4 U5A2.A1 U5A2.A2 U5A2.A4 U5A2.A6 U5A2.A8 U5A2.A10 U5A2.A12 U5A2.A14 U5A2.A16 U5A2.A18 U5A2.A20 U5A2.A22 U5A2.A23 U5A2.AA22 U5A2.AA23 U5A2.AB1 U5A2.AB2 U5A2.AB4 U5A2.AB6 U5A2.AB8 U5A2.AB10 U5A2.AB12 U5A2.AB14 U5A2.AB16 U5A2.AB18 U5A2.AB20 U5A2.AB22 U5A2.AC1 U5A2.AC2 U5A2.AC4 U5A2.AC6 U5A2.AC8 U5A2.AC10 U5A2.AC12 U5A2.AC14 U5A2.AC16 U5A2.AC18 U5A2.AC20 U5A2.AC22 U5A2.AC23 U5A2.B1 U5A2.B2 U5A2.B4 U5A2.B6 U5A2.B8 U5A2.B10 U5A2.B12 U5A2.B14 U5A2.B16 U5A2.B18 U5A2.B20 U5A2.B22 U5A2.C22 U5A2.C23 U5A2.D1 U5A2.D2 U5A2.D4 U5A2.D5 U5A2.D6 U5A2.D8 U5A2.D9 U5A2.D11 U5A2.D12 U5A2.D13 U5A2.D15 U5A2.D16 U5A2.D18 U5A2.E4 U5A2.E9 U5A2.E11 U5A2.E12 U5A2.E13 U5A2.E15 U5A2.E18 U5A2.E22 U5A2.E23 U5A2.F1 U5A2.F2 U5A2.F4 U5A2.F5 U5A2.F6 U5A2.F8 U5A2.F9 U5A2.F11 U5A2.F12 U5A2.F13 U5A2.F15 U5A2.F16 U5A2.F20 U5A2.G22 U5A2.G23 U5A2.H1 U5A2.H20 U5A2.J1 U5A2.J2 U5A2.J12 U5A2.J15 U5A2.J16 U5A2.J19 U5A2.J20 U5A2.J22 U5A2.J23 U5A2.L8 U5A2.L9 U5A2.L12 U5A2.L15 U5A2.L20 U5A2.L22 U5A2.L23 U5A2.M1 U5A2.M2 U5A2.M6 U5A2.M9 U5A2.M12 U5A2.M15 U5A2.M20 U5A2.N9 U5A2.N12 U5A2.N15 U5A2.N18 U5A2.N19 U5A2.N20 U5A2.N22 U5A2.N23 U5A2.R4 U5A2.R9 U5A2.R12 U5A2.R15 U5A2.R18 U5A2.R19 U5A2.R20 U5A2.R22 U5A2.R23 U5A2.T6 U5A2.T18 U5A2.T20 U5A2.U22 U5A2.U23 U5A2.V9 U5A2.V11 U5A2.V12 U5A2.V13 U5A2.V15 U5A2.V16 U5A2.V18 U5A2.V20 U5A2.W8 U5A2.W9 U5A2.W11 U5A2.W12 U5A2.W13 U5A2.W15 U5A2.W22 U5A2.W23(VSS_ANA_99) U5A2.Y5 U5A2.Y8 U5A2.Y9 U5A2.Y11 U5A2.Y12 U5A2.Y13 U5A2.Y15 U5B1.4 U5C1.3 U5C2.2 U5D1.3 U5E1.3 U5G2.3 U6A1.8 U6A2.8 U6A3.8 U6A4.2 U6B1.4 U6B2.4 U6C1.3 U6C1.8 U6D1.3 U6D1.8 U6D2.3 U6D2.8 U6D3.3 U6D3.8 U6D7.3 U6D7.8 U6E1.A2 U6E1.A3 U6E1.A4 U6E1.A5 U6E1.A8 U6E1.A28 U6E1.A33 U6E1.A37 U6E1.A45 U6E1.A46 U6E1.A47 U6E1.A48 U6E1.AA5 U6E1.AA19 U6E1.AA20 U6E1.AA25 U6E1.AA27 U6E1.AA28 U6E1.AA30 U6E1.AA31 U6E1.AA49 U6E1.AB19 U6E1.AB25 U6E1.AB31 U6E1.AC4 U6E1.AC12 U6E1.AC17 U6E1.AC33 U6E1.AC38 U6E1.AC46 U6E1.AD1 U6E1.AD2 U6E1.AD19 U6E1.AD22 U6E1.AD25 U6E1.AD49 U6E1.AE4 U6E1.AE12 U6E1.AE33 U6E1.AE38 U6E1.AE46 U6E1.AF22 U6E1.AF25 U6E1.AF28 U6E1.AG1 U6E1.AG22 U6E1.AG23 U6E1.AG25 U6E1.AG27 U6E1.AG28 U6E1.AG30 U6E1.AG49 U6E1.AH12 U6E1.AH17 U6E1.AH33 U6E1.AH38 U6E1.AJ19 U6E1.AJ20 U6E1.AJ25 U6E1.AJ27 U6E1.AJ28 U6E1.AJ30 U6E1.AJ31 U6E1.AK4 U6E1.AK19 U6E1.AK20 U6E1.AK25 U6E1.AK27 U6E1.AK28 U6E1.AK30 U6E1.AK31 U6E1.AK46 U6E1.AL12 U6E1.AL17 U6E1.AL21 U6E1.AL24 U6E1.AL26 U6E1.AL29 U6E1.AL33 U6E1.AL38 U6E1.AM1 U6E1.AM18 U6E1.AM32 U6E1.AM49 U6E1.AN12 U6E1.AN16 U6E1.AN34 U6E1.AN38 U6E1.AP4 U6E1.AP46 U6E1.AR12 U6E1.AR16 U6E1.AR34 U6E1.AR38 U6E1.AT1 U6E1.AT16 U6E1.AT18 U6E1.AT21 U6E1.AT24 U6E1.AT26 U6E1.AT29 U6E1.AT32 U6E1.AT34 U6E1.AT45 U6E1.AV11 U6E1.AV39 U6E1.AW4 U6E1.AW10 U6E1.AW40 U6E1.AW46 U6E1.B47 U6E1.B48 U6E1.B49 U6E1.BA5 U6E1.BA6 U6E1.BA12 U6E1.BA14 U6E1.BA44 U6E1.BB9 U6E1.BB41 U6E1.BB43 U6E1.BC8 U6E1.BC10 U6E1.BC13 U6E1.BC15 U6E1.BC19 U6E1.BC24 U6E1.BC26 U6E1.BC31 U6E1.BC35 U6E1.BC40 U6E1.BC45 U6E1.BD43 U6E1.BE44 U6E1.BF1 U6E1.BF2 U6E1.BF3 U6E1.BF48 U6E1.BF49 U6E1.BG2 U6E1.BG3 U6E1.BG4 U6E1.BG17 U6E1.BG22 U6E1.BG25 U6E1.BG28 U6E1.BG33 U6E1.BG37 U6E1.BG48 U6E1.C4 U6E1.C5 U6E1.C12 U6E1.C25 U6E1.C30 U6E1.C48 U6E1.D8 U6E1.D12 U6E1.D16 U6E1.D17 U6E1.D30 U6E1.D33 U6E1.E8 U6E1.E10 U6E1.E13 U6E1.E15 U6E1.E17 U6E1.E19 U6E1.E22 U6E1.E24 U6E1.E26 U6E1.E31 U6E1.E33 U6E1.E35 U6E1.E40 U6E1.E42 U6E1.F41 U6E1.F43 U6E1.F47 U6E1.G6 U6E1.G44 U6E1.H8 U6E1.J4 U6E1.J9 U6E1.J10 U6E1.J26 U6E1.J29 U6E1.J40 U6E1.J46 U6E1.J47 U6E1.J48 U6E1.K11 U6E1.K39 U6E1.M5 U6E1.M16 U6E1.M18 U6E1.M21 U6E1.M24 U6E1.M32 U6E1.M34 U6E1.M49 U6E1.N12 U6E1.N16 U6E1.N34 U6E1.N35 U6E1.N37 U6E1.N38 U6E1.P4 U6E1.P26 U6E1.P29 U6E1.P46 U6E1.R3 U6E1.R4 U6E1.R12 U6E1.R16 U6E1.R26 U6E1.R29 U6E1.R34 U6E1.R38 U6E1.T4 U6E1.T5 U6E1.T7 U6E1.T17 U6E1.T18 U6E1.T32 U6E1.T49 U6E1.U12 U6E1.U15 U6E1.U17 U6E1.U21 U6E1.U24 U6E1.U33 U6E1.U38 U6E1.V4 U6E1.V20 U6E1.V22 U6E1.V46 U6E1.W25 U6E1.W27 U6E1.W28 U6E1.W30 U6E1.Y9 U6E1.Y10 U6E1.Y12 U6E1.Y17 U6E1.Y33 U6E1.Y38 U6J1.8 U7B2.3 U7B3.3 U7C1.2 U7D1.1 U7F1.2 U7F1.5 U7G1.7 U7G2.7 U7G4.10 U7G5.3 U7H1.3 U7H2.1 U7H3.1 U7H3.2 U7H3.3 U7H3.4 U7H4.12 U7U1.7 U7U2.7 U8A1.8 U8B1.8 U8B2.8 U8B3.8 U8C1.2 U8C2.3 U8C3.2 U8C4.3 U8C5.C1 U8C6.8 U8D1.3 U8D2.8 U8D5.3 U8D6.4 U8D7.3 U8D8.2 U8D9.2 U8D10.2 U8D11.2 U8D12.3 U8D13.3 U8D14.3 U8E1.1 U8E2.1 U8E3.12(VSS) U8E4.1 U8E5.1 U8F1.3 U8F2.3 U8F3.3 U8F4.1 U8F5.3 U8F6.17 U8F6.64 U8F6.84 U8F6.100 U8F6.112 U8F6.124 U8G1.3 U8G2.1 U8G3.8 U8H5.5 U8J2.4 U8L1.8 U8L2.1 U8L2.2 U8L2.3 U8L2.4 U8N1.2 U9A1.2 U9A1.5 U9C1.15 U9C2.3 Y3A1.2 Y3A1.4 Y4A1.2 Y4A1.4(CASE2) Y4A2.2(GND2) Y4A2.4 Y6A1.2 Y6D1.2 Y6D1.4(CASE2) Y7A1.2(GND2) Y7A1.4
GND_ESD1_FOX: EU7A2.11 R7A13.1
GND_ESD2_FOX: EU7A1.11 R7A11.1
V1P05A_BOOT: EU5G3.10 R5G10.1
V1P05A_BOOT_R: C5G9.1 R5G10.2(B)
V1P05A_CS: EU5G3.2 R5U1.1
