# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCSTG_OUT on LAY6: 181.86,194.69 182.11,194.69 184.02,196.59 184.02,197.48 183.64,197.86 181.86,197.86 181.22,197.23 181.22,195.32
+VDD_EMB_S on TOP: 293.49,223.01 295.65,223.01 295.91,222.76 295.91,220.72 295.78,220.6 294.51,220.6 292.98,222.12 292.98,222.5
+VDDQ on TOP: 261.62,88.01 261.74,87.88 261.74,86.74 261.49,86.49 258.57,86.49 258.31,86.74 258.31,87.88 258.44,88.01
+VDDQ on TOP: 248.41,95.5 248.41,88.26 247.9,87.76 247.14,87.76 246.38,88.52 242.18,88.52 241.42,87.76 195.58,87.76 194.05,89.28 191.13,89.28 190.62,89.79 190.62,97.79 190.88,98.04 196.85,98.04 197.99,96.9 213.1,96.9 214.88,95.12 216.02,95.12 216.15,95.25 216.15,95.5 216.28,95.63 216.66,95.63 217.17,95.12 219.2,95.12 219.58,95.5 219.58,96.65 219.83,96.9 231.52,96.9 232.28,96.14 235.2,96.14 236.6,97.53 248.03,97.53 248.53,97.03 248.53,95.63
+VDDQ on TOP: 177.29,211.83 177.16,211.71 176.4,211.71 176.14,211.96 170.56,211.96 170.3,212.22 170.3,214.63 170.43,214.76 172.72,214.76 173.73,213.74 176.78,213.74 177.29,213.23
+VDDQ on LAY2: outline of 308 points within 147.67,87.86 278.28,217.79 ; 1 cut-out
+VDDQ on LAY5: 257.93,86.49 260.6,86.49 260.85,86.74 260.85,94.74 259.84,95.76 232.91,95.76 231.9,96.77 221.1,96.77 220.47,96.14 220.47,95.88 226.06,90.3 254.12,90.3
+VDDQ_VR_PHASE on TOP: 264.54,96.77 268.35,96.77 268.6,96.52 268.6,94.61 267.58,93.6 267.58,91.57 268.09,91.06 272.28,91.06 272.41,90.93 272.41,89.03 272.28,88.9 264.54,88.9 264.41,89.03 264.41,96.65
+VDDQ_VR_VIN on TOP: 268.47,88.14 274.57,88.14 274.7,88.01 274.7,81.66 274.57,81.53 269.87,81.53 269.49,81.91 269.49,86.36 268.35,87.5 268.35,88.01
+VDDSPD on LAY6: 155.57,127 159.76,127 160.02,126.74 160.02,97.92 159.38,97.28 155.7,97.28 155.06,97.92 155.06,126.49
-12V on TOP: 50.54,36.96 51.81,36.96 52.07,36.7 52.07,35.05 51.94,34.92 50.41,34.92 50.29,35.05 50.29,36.7
AGND_V1P05A on TOP: 164.21,92.96 163.7,92.45 163.7,91.57 163.57,91.44 162.94,91.44 162.68,91.69 162.68,96.01 162.81,96.14 164.08,96.14 164.21,96.01
GND on TOP (solid shape): 157.96,180.85 155.62,180.85 155.62,187.27 157.96,187.27
GND on TOP (solid shape): 166.46,180.85 164.12,180.85 164.12,187.27 166.46,187.27
GND on TOP (solid shape): 213.46,158.38 212.89,158.38 212.89,160.13 213.46,160.13
GND on TOP (solid shape): 219.58,186.18 219.58,174.37 219.45,174.24 218.82,174.24 218.69,174.37 218.69,186.05 218.94,186.31 219.45,186.31
GND on TOP (solid shape): 222.75,185.42 222.75,174.62 222.37,174.24 221.99,174.24 221.86,174.37 221.86,185.42 221.99,185.55 222.63,185.55
GND on TOP (solid shape): 230.88,185.42 230.88,175.89 230.25,175.26 229.99,175.26 229.87,175.39 229.87,175.77 229.99,175.89 229.99,185.42 230.12,185.55 230.75,185.55
GND on TOP (solid shape): 226.44,186.18 226.44,185.93 225.93,185.42 225.93,175.13 226.31,174.75 226.31,174.5 226.18,174.37 225.55,174.37 225.04,174.88 225.04,185.55 225.8,186.31 226.31,186.31
GND on TOP (solid shape): 234.34,163.29 234.34,163.24 234.18,163.1 234.12,162.89 234.18,162.68 234.34,162.54 234.34,162.25 234.32,162.23 234.32,159.56 235.2,158.68 235.2,157.05 234.82,156.66 234.48,156.66 234.41,157.05 234.29,157.33 234.29,157.33 233.79,158.74 233.78,158.75 233.78,161.9 233.87,161.98 233.87,163.35 233.91,163.4 234.23,163.4
GND on TOP (solid shape): 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 232.68,38.61 232.68,39.17 299.8,39.17 302.58,40.32 303.73,43.1 303.73,287.1 302.58,289.88 299.8,291.03 163.76,291.03 163.76,291.59
GND on TOP (solid shape): 115.22,291.03 68.41,291.03 68.41,291.03 5,291.03 2.22,289.88 1.07,287.1 1.07,5 2.22,2.22 5,1.07 172.8,1.07 175.58,2.22 176.73,5 176.73,39.17 187.41,39.17 187.41,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 67.85,291.59 115.22,291.59
GND on BOTTOM (solid shape): 202.43,178.86 202.83,178.48 203.24,178.86 203.36,178.86 203.54,178.68 204.78,178.68 204.79,178.68 206.09,178.68 206.3,178.47 206.29,178.42 206.29,178.37 206.41,178.08 206.69,177.96 206.89,178.01 207.04,178.16 207.26,178.16 207.41,178.01 207.61,177.96 207.78,178 207.93,178.12 208.04,178.12 208.04,177.97 207.95,177.88 205.3,177.88 204.84,178.33 197.59,178.33 197.43,178.5 197.43,178.51 197.77,178.86
GND on BOTTOM (solid shape): 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 232.68,38.61 232.68,39.17 299.8,39.17 302.58,40.32 303.73,43.1 303.73,287.1 302.58,289.88 299.8,291.03 163.76,291.03 163.76,291.59
GND on BOTTOM (solid shape): 115.22,291.03 68.41,291.03 68.41,291.03 5,291.03 2.22,289.88 1.07,287.1 1.07,5 2.22,2.22 5,1.07 172.8,1.07 175.58,2.22 176.73,5 176.73,39.17 187.41,39.17 187.41,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 67.85,291.59 115.22,291.59
GND on BOTTOM (solid shape): outline of 312 points within 12.64,278.08 21.52,286.96
GND on BOTTOM (solid shape): outline of 312 points within 12.64,123.14 21.52,132.02
GND on BOTTOM (solid shape): outline of 312 points within 12.64,50.75 21.52,59.63
GND on BOTTOM (solid shape): outline of 312 points within 91.38,278.07 100.26,286.95
GND on BOTTOM (solid shape): outline of 312 points within 137.1,278.08 145.98,286.96
GND on BOTTOM (solid shape): outline of 312 points within 137.1,123.14 145.98,132.02
GND on BOTTOM (solid shape): outline of 312 points within 137.1,50.75 145.98,59.63
GND on BOTTOM (solid shape): outline of 312 points within 294.58,255.22 303.46,264.1
GND on BOTTOM (solid shape): outline of 312 points within 294.58,123.14 303.46,132.02
GND on BOTTOM (solid shape): outline of 312 points within 294.58,50.75 303.46,59.63
GND on LAY3 (solid shape): 215.44,162.36 215.44,161.61 214.5,160.68 214.5,160.67 212.33,158.5 212.33,157.58 212.24,157.49 212.24,155.64 211.88,155.64 211.78,155.74 211.78,158.77 214.78,161.77 214.78,162.36 214.97,162.55 215.24,162.55
GND on LAY3 (solid shape): 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 232.68,38.61 232.68,39.17 299.8,39.17 302.58,40.32 303.73,43.1 303.73,287.1 302.58,289.88 299.8,291.03 163.76,291.03 163.76,291.59
GND on LAY3 (solid shape): 115.22,291.03 68.41,291.03 68.41,291.03 5,291.03 2.22,289.88 1.07,287.1 1.07,5 2.22,2.22 5,1.07 172.8,1.07 175.58,2.22 176.73,5 176.73,39.17 187.41,39.17 187.41,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 67.85,291.59 115.22,291.59
GND on LAY5 (solid shape): 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 232.68,38.61 232.68,39.17 299.8,39.17 302.58,40.32 303.73,43.1 303.73,67.18 303.91,67.36 303.91,215.39 303.73,215.56 303.73,287.1 302.58,289.88 299.8,291.03 163.76,291.03 163.76,291.59
GND on LAY5 (solid shape): 115.22,291.03 68.41,291.03 68.41,291.03 5,291.03 2.22,289.88 1.07,287.1 1.07,5 2.22,2.22 5,1.07 172.8,1.07 175.58,2.22 176.73,5 176.73,39.17 187.41,39.17 187.41,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 67.85,291.59 115.22,291.59
GND on LAY6 (solid shape): 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 232.68,38.61 232.68,39.17 299.8,39.17 302.58,40.32 303.73,43.1 303.73,287.1 302.58,289.88 299.8,291.03 163.76,291.03 163.76,291.59
GND on LAY6 (solid shape): 115.22,291.03 68.41,291.03 68.41,291.03 5,291.03 2.22,289.88 1.07,287.1 1.07,5 2.22,2.22 5,1.07 172.8,1.07 175.58,2.22 176.73,5 176.73,39.17 187.41,39.17 187.41,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 67.85,291.59 115.22,291.59
GND on LAY8 (solid shape): 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 232.68,38.61 232.68,39.17 299.8,39.17 302.58,40.32 303.73,43.1 303.73,287.1 302.58,289.88 299.8,291.03 163.76,291.03 163.76,291.59
GND on LAY8 (solid shape): 115.22,291.03 68.41,291.03 68.41,291.03 5,291.03 2.22,289.88 1.07,287.1 1.07,5 2.22,2.22 5,1.07 172.8,1.07 175.58,2.22 176.73,5 176.73,39.17 187.41,39.17 187.41,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 67.85,291.59 115.22,291.59
GND on TOP: 162.3,263.78 163.57,263.78 163.83,263.52 163.83,261.49 163.57,261.24 161.29,261.24 161.03,261.49 161.03,262.51
GND on TOP: 157.48,90.3 157.22,90.04 152.78,90.04 152.52,90.3 152.52,93.47 152.9,93.85 157.35,93.85 157.48,93.72
GND on TOP: outline of 484 points within 98.91,143.07 106.44,150.89
GND on TOP: 282.06,188.85 282.06,184.78 282.32,184.53 283.46,184.53 283.59,184.4 283.59,183.26 283.33,183.01 280.03,183.01 279.9,183.13 279.9,187.45 280.54,188.09 280.54,188.97 280.67,189.1 281.81,189.1
GND on TOP: 170.81,205.48 171.45,204.85 171.45,203.96 171.32,203.83 167.51,203.83 167.25,204.09 167.25,205.36 167.38,205.48
GND on TOP: outline of 207 points within 218.86,97.15 234.95,119.23
GND on TOP: 62.61,88.39 64.77,88.39 65.02,88.14 65.02,83.06 63.75,81.79 62.61,81.79 62.48,81.91 62.48,88.26
GND on TOP: 188.59,39.37 188.59,41.53 195.7,48.64 231.01,48.64 232.28,47.37 232.28,39.75 232.19,39.66 231.71,39.66 231.71,39.41 231.58,39.41 231.58,39.07 219.15,39.07 219.13,39.05 188.91,39.05 ; 3 cut-outs
GND on TOP: 227.71,242.95 230.88,242.95 231.01,243.08 231.01,244.35 231.14,244.47 232.28,244.47 232.41,244.35 232.41,240.92 232.28,240.79 225.67,240.79 225.42,241.04 225.42,242.7 225.55,242.82 227.58,242.82
GND on TOP: 180.72,187.2 183,187.2 183.13,187.07 183.13,184.15 182.75,183.77 180.72,183.77 180.59,183.89 180.59,187.07
GND on TOP: 159.76,159.13 162.05,159.13 162.3,158.88 162.3,149.1 163.7,147.7 163.7,144.39 161.81,142.49 160.02,142.49 159.38,143.13 159.38,158.75
GND on TOP: 24,59.82 25.01,59.82 25.14,59.69 25.14,56.39 25.01,56.26 24,56.26 23.87,56.39 23.87,59.69
GND on TOP: 117.85,208.66 118.11,208.91 118.11,209.93 117.98,210.06 115.06,210.06 114.8,209.8 114.8,208.79 114.93,208.66
GND on TOP: 133.22,100.71 133.35,100.58 143,100.58 143.38,100.96 143.38,101.85 143,102.23 140.46,102.23 140.08,102.61 140.08,103.25 139.7,103.63 133.6,103.63 133.22,103.25
GND on TOP: 173.22,183.64 173.22,187.83 173.86,188.47 175.51,188.47 176.27,187.7 176.27,183.77 175.89,183.39 173.48,183.39
GND on TOP: 54.35,85.22 54.22,85.09 52.95,85.09 52.7,85.34 52.7,90.17 52.83,90.3 53.97,90.3 54.35,89.91
GND on TOP: 155.62,148.87 155.62,142.44 157.96,142.44 157.96,148.87
GND on TOP: 122.04,265.05 127.5,265.05 127.76,264.79 127.76,263.4 127.5,263.14 121.79,263.14 121.66,263.27 121.66,264.67
GND on TOP: 204.34,242.95 207.26,242.95 207.51,243.2 207.51,244.22 207.77,244.47 208.91,244.47 209.04,244.35 209.04,240.92 208.91,240.79 203.07,240.79 202.94,240.92 202.94,242.44 203.07,242.57 203.96,242.57
GND on TOP: 23.36,66.42 23.49,66.29 25.52,66.29 25.65,66.42 25.65,67.82 25.14,68.32 23.62,68.32 23.36,68.07
GND on TOP: 181.61,242.95 184.4,242.95 184.53,243.08 184.53,244.22 184.65,244.35 185.92,244.35 186.05,244.22 186.05,240.92 185.92,240.79 182.37,240.79 181.61,240.03 180.21,240.03 179.95,240.28 179.95,242.44 180.08,242.57 181.22,242.57
GND on TOP: 165.98,244.85 165.98,248.03 166.11,248.16 166.87,248.16 167.83,247.2 169.22,247.2 169.41,247.01 169.41,245.24 168.02,243.84 168.02,239.65 167.76,239.39 165.22,239.39 164.97,239.65 164.97,243.84
GND on TOP: 169.29,155.95 173.1,155.95 173.35,155.7 173.35,151.89 170.94,149.48 169.54,149.48 169.29,149.73 169.29,150.49 168.78,151 168.78,155.45
GND on TOP: 213.23,97.15 198.5,97.15 197.23,98.42 197.23,100.84 197.99,101.6 197.99,102.74 198.37,103.12 198.37,108.71 197.48,109.6 197.48,109.73 198.24,110.49 198.24,113.54 197.73,114.04 197.86,114.17 212.34,114.17 213.86,112.65 213.86,97.79
GND on TOP: 243.08,180.2 254.51,180.2 263.59,171.12 266.86,171.12 267.38,170.61 267.72,170.61 269.28,169.05 269.28,169.03 269.98,169.03 273.38,165.64 281.86,165.64 282.3,165.2 282.3,161.29 277.84,156.83 277.84,143.94 282.4,139.37 282.4,128.65 282.88,128.18 282.88,120.23 280.84,118.19 280.54,118.19 280.54,113.66 279.78,112.9 235.07,112.9 234.82,113.16 234.82,114.93 235.71,115.82 235.71,119.12 237.99,119.12 239.26,117.85 241.65,117.85 241.81,118 242.45,118 243.25,118.8 243.25,119.32 243.34,119.41 243.34,119.64 242.63,121.9 242.63,122.44 243.84,123.64 243.84,124.36 243.67,125.84 243.65,125.96 243.65,127.34 243.34,127.65 243.34,128.15 243.65,128.47 243.65,132.13 241.11,134.68 241.11,135.39 240.75,135.75 238.18,135.75 237.49,136.43 237.49,148.96 237.11,149.35 236.52,150.98 236.14,151.36 236.14,152.04 233.87,158.31 233.61,158.56 233.61,159.87 233.68,159.94 233.68,161.85 233.87,162.03 233.87,165.01 235,166.14 235,177.7 235.29,178 238.18,178 238.63,177.55 241.69,177.55 242.02,177.87 242.02,179.14 ; 1 cut-out
GND on TOP: 162.56,211.2 163.44,210.31 163.44,208.66 163.57,208.53 163.57,208.28 163.44,208.15 162.43,208.15 162.3,208.28 162.3,209.04 162.17,209.17 161.79,209.17 161.67,209.29 161.67,209.93 161.79,210.06 162.05,210.06 162.17,210.18 162.17,210.44 160.78,211.83 160.78,213.99 161.16,214.37 162.3,214.37 162.56,214.12
GND on TOP: 53.08,47.88 54.73,47.88 54.86,47.75 54.86,46.86 54.73,46.73 53.08,46.73 52.95,46.86 52.95,47.75
GND on TOP: 121.28,207.77 121.41,207.64 123.19,207.64 123.31,207.77 123.31,208.79 123.19,208.91 121.41,208.91 121.28,208.79
GND on TOP: 167.13,200.28 173.48,200.28 173.6,200.15 173.6,199.52 172.46,198.37 167.25,198.37 167,198.63 167,200.15
GND on TOP: 152.4,174.5 155.7,174.5 155.82,174.37 155.82,173.73 155.7,173.61 153.28,173.61 152.65,172.97 151.51,172.97 151.25,173.23 151.25,173.61 151.76,173.61 152.01,173.86 152.01,174.12
GND on TOP: 246.25,87.88 243.07,87.88 242.95,87.76 242.95,86.23 243.33,85.85 246.25,85.85 246.5,86.1 246.5,87.63
GND on TOP: 141.6,271.14 141.85,271.14 141.98,271.02 141.98,270.38 142.24,270.13 145.03,270.13 145.16,270 145.16,264.79 144.9,264.54 141.85,264.54 141.6,264.79
GND on TOP: 267.33,242.92 267.46,243.05 267.46,244.22 267.58,244.35 268.85,244.35 268.98,244.22 268.98,241.04 268.96,241.02 268.96,240.89 268.83,240.77 263.01,240.77 262,241.78 262,242.95 262.12,243.08 262.89,243.08 263.27,242.7 264.16,242.7 264.38,242.92
GND on TOP: 217.69,187.87 216.99,188.23 210.61,188.23 209.52,187.14 209.52,186.32 209.52,186.32 209.52,181.61 209.77,181.35 209.8,181.35 210.05,181.61 210.56,181.61 210.69,181.48 210.69,180.97 209.52,179.8 209.52,178.05 206.12,178.05 206.12,176.22 209.44,176.22 209.52,176.15 209.52,172.78 211.41,170.89 211.71,171.19 211.45,171.45 211.45,171.7 211.8,172.05 214.63,172.05 215.16,172.59 215.16,173.26 216.49,174.58 216.49,186.16 217.69,187.36 ; 1 cut-out
GND on TOP: 56.26,107.69 58.8,107.69 58.92,107.57 58.92,106.68 58.8,106.55 54.35,106.55 54.22,106.68 54.22,107.95 54.48,108.2 55.75,108.2
GND on TOP: 159.76,268.98 161.41,268.98 161.41,268.73 161.54,268.6 161.79,268.6 161.92,268.48 161.92,268.35 161.79,268.22 159.12,268.22 156.58,270.76 156.58,271.78 155.95,272.41 155.95,275.59 156.08,275.72 157.98,275.72 158.24,275.46 158.24,270.51
GND on TOP: 47.87,126.08 48.76,126.08 48.89,125.95 48.89,125.44 49.02,125.32 52.32,125.32 52.45,125.19 52.45,123.16 52.32,123.03 48.51,123.03 48.26,123.28 48.26,124.55 47.87,124.93
GND on TOP: 206.12,176.5 206.64,176.5 206.64,176.49 210.17,176.49 210.26,176.4 210.26,172.48 215.9,166.84 215.9,163.27 215.63,162.86 214.95,162.47 214.09,161.33 213.7,159.5 213.7,157.64 211.48,155.42 211.48,155.4 201.72,145.65 201.38,145.65 200.42,144.69 200.42,133.93 199.16,132.67 199.16,129.58 198.39,128.82 198.39,127.29 199.09,126.6 199.09,125.8 198.81,125.52 198.81,123.24 199.11,122.94 199.11,118.65 198.3,117.83 184.57,117.83 184.31,118.08 175.21,118.08 174.96,117.83 169.62,117.83 167.56,115.77 160.7,115.77 159.74,116.73 159.74,121.11 159.75,121.12 159.75,123.48 159.74,123.48 159.74,128.61 159.86,128.73 159.86,132.04 160.12,132.29 160.12,134.53 159.8,134.85 159.17,134.85 158.97,135.04 158.97,135.85 159.04,135.91 159.74,135.91 159.95,136.13 159.95,136.5 159.98,136.55 159.98,142.19 166.73,148.94 168.46,148.94 168.8,149.28 168.8,151.01 181.5,163.71 182.98,163.71 185.94,166.68 185.94,168.15 193.96,176.17 205.79,176.17 ; 1 cut-out
GND on TOP: 251.33,242.95 254,242.95 254.25,243.2 254.25,244.35 254.38,244.47 255.52,244.47 255.65,244.35 255.65,240.92 255.52,240.79 249.04,240.79 248.79,241.04 248.79,242.44 248.92,242.57 250.95,242.57
GND on TOP: 171.06,273.05 171.45,273.05 171.83,272.67 171.83,271.27 171.57,271.02 170.81,271.02 170.68,271.14 170.68,272.67
GND on TOP: 79.75,162.18 81.78,162.18 81.91,162.05 81.91,161.67 81.78,161.54 81.78,158.24 81.66,158.11 81.02,158.11 80.89,158.24 80.89,159.38 79.62,160.65 79.62,162.05
GND on TOP: 107.56,6.22 108.83,6.22 108.96,6.35 110.36,6.35 110.61,6.09 110.61,4.44 110.36,4.19 107.82,4.19 107.44,4.57 107.44,6.09
GND on TOP: 47.95,162.55 48.84,162.55 48.97,162.43 48.97,161.92 49.09,161.79 52.4,161.79 52.52,161.66 52.52,159.88 52.51,159.87 52.51,159.64 52.37,159.5 48.71,159.5 48.33,159.88 48.33,161.03 47.95,161.41
GND on TOP: 168.65,214.88 168.65,212.72 168.78,212.6 170.05,212.6 170.18,212.72 170.18,214.76 169.92,215.01 168.78,215.01
GND on TOP: 89.15,86.23 92.2,86.23 92.32,86.1 92.32,82.04 92.2,81.91 89.15,81.91 89.02,82.04 89.02,86.1
GND on TOP: 33.9,71.12 33.78,70.99 33.78,69.21 33.9,69.09 36.19,69.09 36.32,69.21 36.32,70.99 36.19,71.12
GND on TOP: 258.44,94.87 249.17,94.87 248.92,95.12 248.92,96.9 249.04,97.03 249.93,97.03 250.19,96.77 258.44,96.77 258.57,96.65 258.57,94.99
GND on TOP: 179.19,238.89 180.97,238.89 181.1,238.76 181.1,237.23 180.97,237.11 179.45,237.11 179.07,237.49 179.07,238.76
GND on TOP: 113.41,136.4 114.04,136.4 114.3,136.14 114.3,134.87 114.04,134.62 113.66,134.62 113.41,134.87 113.41,135 113.28,135.13 113.28,136.27
GND on TOP: 59.3,47.75 60.57,47.75 60.7,47.62 60.7,47.12 60.57,46.99 59.3,46.99 59.18,47.12 59.18,47.62
GND on TOP: 282.06,174.01 282.06,171.32 282.32,171.07 283.46,171.07 283.59,170.94 283.59,169.67 283.48,169.57 280.03,169.57 279.9,169.7 279.9,173.48 279.01,174.37 279.01,176.78 279.14,176.91 281.3,176.91 281.55,176.66 281.55,174.52
GND on TOP: 112.26,266.19 113.91,266.19 114.17,265.94 114.17,262.25 114.04,262.13 112.26,262.13 112.14,262.25 112.14,266.06
GND on TOP: 269.49,91.82 274.44,91.82 274.57,91.95 274.57,95.88 274.38,96.07 273.87,96.07 273.81,96.14 272.92,96.14 272.79,96.01 272.79,95.25 272.16,94.61 269.36,94.61 269.24,94.49 269.24,92.07
GND on TOP: 107.06,267.97 108.2,267.97 108.33,267.84 108.33,263.78 108.2,263.65 106.04,263.65 105.66,264.03 105.66,265.81 106.55,266.7 106.55,267.46
GND on TOP: 47.9,153.41 48.79,153.41 48.92,153.28 48.92,152.77 49.04,152.65 52.34,152.65 52.47,152.52 52.47,150.74 52.46,150.73 52.46,150.5 52.32,150.36 48.66,150.36 48.28,150.74 48.28,151.88 47.9,152.27
GND on TOP: 47.92,144.26 48.81,144.26 48.94,144.14 48.94,143.63 49.07,143.5 52.37,143.5 52.5,143.38 52.5,141.6 52.48,141.58 52.48,141.36 52.34,141.22 48.69,141.22 48.31,141.6 48.31,142.74 47.92,143.12
GND on TOP: 244.09,242.92 244.34,243.18 244.34,244.35 244.47,244.47 245.49,244.47 245.74,244.22 245.74,242.57 245.71,242.54 245.71,240.89 245.59,240.77 241.17,240.77 241.02,240.92 239.01,240.92 238.76,241.17 238.76,242.82 238.86,242.92
GND on TOP: 159.89,169.92 166.62,169.92 166.87,169.67 166.87,168.27 166.37,167.77 163.95,167.77 163.57,168.15 159.89,168.15 159.76,168.27 159.76,169.8
GND on TOP: 112.39,239.39 114.93,239.39 115.69,240.16 115.69,242.57 115.31,242.95 114.42,242.95 113.91,243.46 112.14,243.46 112.01,243.33 112.01,239.77
GND on TOP: 159.51,90.8 159.38,90.68 159.38,88.64 159.51,88.52 160.65,88.52 161.79,89.66 161.79,90.55 161.54,90.8
GND on TOP: 38.6,66.29 38.98,66.29 39.37,66.67 42.41,66.67 42.67,66.93 42.67,68.45 42.54,68.58 38.98,68.58 38.48,68.07 38.48,66.42
GND on TOP: 275.71,85.22 277.11,85.22 277.36,84.96 277.36,83.95 277.11,83.69 275.71,83.69 275.59,83.82 275.59,85.09
GND on TOP: 166.36,273.3 166.36,272.92 166.87,272.41 167.38,272.41 167.76,272.03 167.76,269.62 167.64,269.49 162.43,269.49 162.17,269.75 161.16,269.75 160.33,270.57 160.33,272.41 161.47,273.56 166.11,273.56
GND on TOP: 46.99,66.55 45.59,67.94 45.08,67.94 44.83,67.69 44.83,65.78 44.95,65.66 46.86,65.66 46.99,65.78
GND on TOP: 137.54,105.79 139.82,105.79 139.95,105.92 140.71,105.92 141.35,106.55 142.62,106.55 142.87,106.3 142.87,105.66 142.49,105.28 142.49,104.27 142.36,104.14 141.85,104.14 141.73,104.27 141.73,105.28 141.47,105.54 141.09,105.54 140.97,105.41 140.97,104.14 140.71,103.88 137.79,103.88 137.41,104.27 137.41,105.66
GND on TOP: 299.46,246 300.73,246 301.49,245.24 302.38,245.24 303.14,244.47 303.14,224.28 302.76,223.9 300.99,223.9 300.73,224.15 300.73,230.63 299.46,231.9 299.46,239.77 300.22,240.54 300.22,243.97 299.46,244.73
GND on TOP: 159.63,202.44 163.19,202.44 163.32,202.31 163.32,201.67 163.19,201.55 159.76,201.55 159.63,201.67
GND on TOP: 51.43,99.19 51.81,98.8 51.81,96.77 51.68,96.65 50.54,96.65 50.29,96.9 50.29,98.8 49.78,99.31 49.78,102.49 50.03,102.74 50.03,103.38 50.29,103.63 51.05,103.63 51.43,103.25
GND on TOP: 61.84,98.42 63.11,98.42 63.24,98.3 63.24,96.77 63.11,96.65 61.84,96.65 61.72,96.77 61.72,98.3
GND on TOP: 79.88,23.24 79.88,24.51 79.62,24.76 77.85,24.76 77.59,24.51 77.59,23.24 77.72,23.11 79.75,23.11
GND on TOP: 47.9,134.97 48.79,134.97 48.92,134.84 48.92,134.33 49.04,134.21 52.34,134.21 52.47,134.08 52.47,132.3 52.46,132.29 52.46,132.06 52.32,131.92 48.66,131.92 48.28,132.3 48.28,133.44 47.9,133.82
GND on TOP: 90.42,158.62 90.42,158.24 90.93,157.73 90.93,157.35 91.31,156.97 91.69,156.97 91.94,157.22 91.94,158.62 91.31,159.26 90.67,159.26 90.42,159 90.42,158.62
GND on TOP: 98.8,184.02 99.69,184.02 99.82,183.89 99.82,183.51 100.07,183.26 100.07,180.85 99.94,180.72 98.8,180.72 98.55,180.97 98.55,183.77
GND on TOP: 217.8,242.92 220.72,242.92 220.85,243.05 220.85,244.35 220.98,244.47 222.12,244.47 222.37,244.22 222.37,242.47 222.35,242.44 222.35,240.89 222.22,240.77 216.38,240.77 216.31,240.83 215.48,240.83 215.26,241.04 215.26,242.44 215.51,242.7 217.57,242.7
GND on TOP: 294.76,251.2 297.56,251.2 299.33,252.98 302.64,252.98 303.78,254.13 303.78,244.98 302.89,245.87 301.75,245.87 301.11,246.51 301.11,249.17 300.6,249.68 299.46,249.68 298.32,248.54 296.67,248.54 295.27,249.93 294.51,249.93 294.38,250.06 294.38,250.82
GND on TOP: 166.11,218.95 168.4,218.95 169.16,218.18 172.21,218.18 172.33,218.06 172.33,216.66 172.08,216.41 167.89,216.41 167.76,216.53 167.76,217.17 167.38,217.55 166.24,217.55 165.98,217.8 165.98,218.82
GND on TOP: 174.37,238.76 171.83,238.76 171.7,238.63 171.7,236.09 171.95,235.84 174.37,235.84 174.49,235.96 174.49,238.63
GND on TOP: 269.74,81.02 272.79,81.02 273.05,80.77 273.05,79.37 272.79,79.12 269.74,79.12 269.49,79.37 269.49,80.77
GND on TOP: 197.71,242.92 197.86,243.08 197.86,244.22 197.99,244.35 199.26,244.35 199.36,244.25 199.36,240.89 199.23,240.77 193.7,240.77 193.29,241.17 192.53,241.17 192.4,241.3 192.4,242.7 192.63,242.92
GND on TOP: 261.49,80.14 261.49,81.79 261.62,81.91 264.92,81.91 265.04,81.79 265.04,80.14 264.92,80.01 261.62,80.01
GND on TOP: 166.11,119 214.88,119 215.51,118.36 215.51,115.31 212.21,112.01 200.66,112.01 198.75,113.92 194.18,113.92 193.04,112.77 183.76,112.77 182.49,114.04 175.64,114.04 174.24,112.65 166.87,112.65 165.86,113.66 165.86,118.74
GND on TOP, BOTTOM, LAY3, LAY5, LAY6, LAY8: 114.93,291.03 163.95,291.03 163.95,291.59 114.93,291.59
GND on BOTTOM: 217.26,187.26 215.38,187.26 214.34,186.22 212.75,186.22 212.75,184.04 212.12,183.41 212.12,175.19 211.66,174.74 211.66,173.52 211.9,173.29 213.74,173.29 214.44,173.99 215.13,173.99 215.25,174.1 215.25,177.43 217.26,179.45
GND on BOTTOM: 195.45,242.95 197.73,242.95 197.86,243.08 197.86,244.22 197.99,244.35 199.26,244.35 199.39,244.22 199.39,240.92 199.26,240.79 193.67,240.79 193.16,241.3 193.16,243.08 193.29,243.2 195.19,243.2
GND on BOTTOM: 241.93,242.95 244.09,242.95 244.34,243.2 244.34,244.35 244.47,244.47 245.49,244.47 245.74,244.22 245.74,240.92 245.61,240.79 239.77,240.79 239.64,240.92 239.64,243.08 239.77,243.2 241.68,243.2
GND on BOTTOM: 217.42,200.91 217.42,194.56 217.55,194.44 217.55,191.26 217.17,190.88 216.4,190.88 216.28,191.01 216.28,191.64 216.07,191.85 211.87,191.85 211.7,191.68 211.7,190.2 211.54,190.03 210.94,190.03 209.39,191.58 209.26,191.58 209.1,191.42 209.1,190.8 211.09,188.81 212.47,188.81 212.62,188.96 212.62,189.96 212.76,190.1 214.48,190.1 215.52,189.06 215.52,186.35 216,185.87 216.6,185.87 218.18,187.45 218.18,201.17 214.4,204.95 214.4,207.64 206.76,215.28 200.89,215.28 189.04,227.13 185.5,227.13 184.48,228.14 181.35,228.14 179.93,229.57 175.89,229.57 174.49,230.96 174.49,236.38 173.75,237.12 172.29,237.12 171.7,236.53 171.7,232.98 176.08,228.6 179.63,228.6 180.75,227.48 183.55,227.48 184.56,226.48 188.93,226.48 189.02,226.39 189.02,226.35 200.82,214.55 206.33,214.55 212.94,207.93 212.94,203.8 212.85,203.71 212.85,203.58 213.23,203.2 215.36,203.2 217.41,201.15 217.41,200.92
GND on BOTTOM: 281.3,175.77 281.55,175.51 281.55,174.5 282.06,173.99 282.06,171.32 282.32,171.07 283.46,171.07 283.59,170.94 283.59,169.67 283.46,169.54 280.16,169.54 279.9,169.8 279.9,174.5 279.78,174.62 279.52,174.62 279.14,175 279.14,175.51 279.4,175.77
GND on BOTTOM: 280.79,188.97 281.68,188.97 281.81,188.85 281.81,187.96 282.06,187.7 282.06,184.78 282.32,184.53 283.46,184.53 283.59,184.4 283.59,183.26 283.33,183.01 280.03,183.01 279.9,183.13 279.9,186.56 280.16,186.82 280.67,186.82 280.92,187.07 280.92,188.85
GND on BOTTOM: 215.77,258.44 224.15,258.44 224.4,258.19 224.4,254.76 224.15,254.51 215.77,254.51 215.64,254.63 215.64,258.32
GND on BOTTOM: 248.92,242.44 250.82,242.44 251.33,242.95 254,242.95 254.25,243.2 254.25,244.35 254.38,244.47 255.52,244.47 255.65,244.35 255.65,240.92 255.52,240.79 249.04,240.79 248.79,241.04 248.79,242.31
GND on BOTTOM: outline of 169 points within 157.79,96.34 218.22,178.92 ; 3 cut-outs
GND on BOTTOM: 225.55,242.7 227.83,242.7 228.09,242.95 230.88,242.95 231.01,243.08 231.01,244.35 231.14,244.47 232.28,244.47 232.41,244.35 232.41,240.92 232.28,240.79 225.67,240.79 225.42,241.04 225.42,242.57
GND on BOTTOM: 267.6,166.13 268.22,165.51 268.22,162.69 277.29,153.62 277.29,141.52 286.25,132.56 286.25,100.73 283.26,97.73 277.82,97.73 277.11,97.03 258.86,97.03 257.97,96.14 244.6,96.14 244.35,96.39 244.35,103.15 243.23,104.27 243.23,109.2 243.57,109.53 243.57,110.66 244.35,111.45 244.35,130.64 243.67,131.31 243.67,132.84 242.73,133.78 242.12,133.78 241.69,134.21 241.69,134.83 238.03,138.49 238.03,149.38 237.71,149.71 230.85,156.57 230.85,157.16 230.83,157.18 230.83,161.52 229.71,162.64 229.71,162.87 229.71,162.88 229.71,166.75 231.4,168.44 231.4,170.49 230.25,171.65 230.25,173.69 230.58,174.02 231.72,174.02 232.04,173.7 233.76,173.7 233.76,174.37 234.44,175.06 235.09,175.06 235.09,176.83 236.53,178.28 236.53,179.25 236.55,179.27 242.38,179.27 243.35,180.23 254.52,180.23 267.6,167.16
GND on BOTTOM: 267.33,242.95 267.46,243.08 267.46,244.22 267.58,244.35 268.85,244.35 268.98,244.22 268.98,240.92 268.73,240.66 263.01,240.66 262.89,240.79 262.89,242.95 263.14,243.2 264.79,243.2 265.04,242.95
GND on BOTTOM: 93.34,263.02 94.74,263.02 95.12,262.63 97.15,262.63 97.4,262.38 97.4,259.08 98.29,258.19 98.29,257.3 98.17,257.17 93.34,257.17 92.58,256.41 91.82,256.41 91.69,256.54 91.69,262.38 92.07,262.76 92.07,264.29 92.2,264.41 92.96,264.41 93.21,264.16 93.21,263.14
GND on BOTTOM: 254.5,268.35 257.17,268.35 258.57,266.95 258.57,263.65 258.44,263.52 255.27,263.52 255.01,263.78 255.01,265.17 254.76,265.43 253.87,265.43 253.61,265.68 253.61,267.46
GND on BOTTOM: 202.94,242.57 204.85,242.57 205.23,242.95 207.26,242.95 207.51,243.2 207.51,244.22 207.77,244.47 208.91,244.47 209.04,244.35 209.04,240.92 208.91,240.79 203.07,240.79 202.81,241.04 202.81,242.44
GND on BOTTOM: 179.19,238.76 180.72,238.76 181.11,238.37 181.11,237.48 180.99,237.36 179.19,237.36 179.07,237.49 179.07,238.63
GND on BOTTOM: 166.36,273.05 173.09,273.05 173.48,272.67 173.48,266.19 172.59,265.3 171.06,265.3 170.94,265.43 170.94,271.4 170.55,271.78 166.49,271.78 166.24,272.03 166.24,272.92
GND on BOTTOM: 171.95,238.89 174.37,238.89 174.49,238.76 174.49,236.09 174.24,235.84 171.95,235.84 171.7,236.09 171.7,238.63
GND on BOTTOM: 179.95,242.57 181.22,242.57 181.61,242.95 184.4,242.95 184.53,243.08 184.53,244.22 184.65,244.35 185.92,244.35 186.05,244.22 186.05,240.92 185.92,240.79 182.37,240.79 181.61,240.03 180.21,240.03 179.95,240.28
GND on BOTTOM: 201.16,258.44 208.15,258.44 208.4,258.19 208.4,254.76 208.15,254.51 199.77,254.51 199.64,254.63 199.64,256.92 ; 1 cut-out
GND on BOTTOM: 231.52,184.15 230.37,184.15 230.12,183.89 230.12,178.05 229.36,177.29 225.93,177.29 225.42,176.78 225.42,173.48 225.67,173.23 227.58,173.23 227.95,173.6 231.77,173.6 231.77,183.89
GND on BOTTOM: 218.56,242.82 220.59,242.82 220.85,243.08 220.85,244.35 220.98,244.47 222.12,244.47 222.37,244.22 222.37,240.92 222.25,240.79 216.28,240.79 216.15,240.92 216.15,243.08 216.4,243.33 218.05,243.33
GND on LAY2: 158.41,79.91 166.7,79.91 167.66,78.95 167.66,73.19 164.74,70.27 164.74,70.27 164.18,69.71 164.18,61.71 162.77,60.3 156.93,60.3 155.15,58.52 150.15,58.52 148.05,60.62 148.05,70.82 152.37,75.14 152.37,77.3 152.69,77.62 157.9,77.62 158.21,77.93 158.21,79.71 ; 9 cut-outs
GND on LAY2: 241.14,132.74 243.54,132.74 243.86,132.42 243.86,131.1 243.57,130.81 243.57,128.52 243.23,128.18 243.23,127.34 243.48,127.08 243.61,125.72 243.74,124.8 243.99,124.43 243.99,123.74 243.35,123.1 243.35,120.99 243.86,120.48 243.86,117.7 235.75,117.7 235.55,117.9 235.55,119.04 234.79,119.8 234.79,121.62 235.05,121.88 235.05,122.85 234.79,123.1 234.79,125.26 234.03,126.02 234.03,126.19 234.92,127.08 234.92,128.37 235.29,129.12 235.42,129.5 236.44,131.67 236.44,132.04 237.02,132.61 238.59,132.61 239.42,131.78 239.42,130.89 239.6,130.71 240.58,130.71 240.89,131.02 240.89,132.04 241.14,132.29
GND on LAY2: 106.08,75.08 113.49,75.08 113.81,74.76 113.81,66.46 113.62,66.27 107.48,66.27 105.76,67.99 105.76,74.76
GND on LAY2: 187.11,114.32 193.12,114.32 193.57,113.88 193.57,112.86 194.01,112.42 194.86,112.42 195.3,112.86 195.3,114 195.49,114.2 198.2,114.2 198.39,114 198.39,112.99 199.16,112.22 199.16,110.78 198.52,110.15 198.52,109.3 199.03,108.8 199.03,106.72 198.14,105.83 198.14,104.99 198.52,104.6 198.52,103.67 197.76,102.91 197.76,101.77 197.12,101.13 197.12,99.52 197.76,98.89 197.76,98.08 197.57,97.89 161.07,97.89 160.75,98.21 160.75,99.35 159.86,100.24 159.86,101.3 160.37,101.81 160.37,103.33 160.88,103.84 160.88,107.1 160.5,107.48 160.5,108.37 159.61,109.26 159.61,110.57 160.5,111.46 160.5,112.35 161.26,113.11 161.26,114.13 161.45,114.32 164.42,114.32 164.61,114.13 164.61,112.86 165.37,112.1 165.37,110.95 165.82,110.51 166.66,110.51 167.36,111.21 167.36,112.22 168.12,112.99 168.12,113.88 168.44,114.2 174.45,114.2 174.77,113.88 174.77,112.86 175.09,112.55 176.31,112.55 176.63,112.86 176.63,114.13 176.82,114.32 183.21,114.32 183.28,114.26 183.28,112.99 184.04,112.22 184.04,111.34 184.61,110.77 185.46,110.77 185.9,111.21 185.9,112.1 186.91,113.11 186.91,114.13
GND on LAY2: 140.63,8.28 148.67,8.28 149.12,7.83 149.12,5.25 148.41,4.54 148.2,4.54 147.18,3.53 144.44,3.53 139.86,3.53 139.54,3.85 139.54,7.2 ; 2 cut-outs
GND on LAY2: 87.54,263.29 88.09,263.29 88.72,262.66 90.5,262.66 90.76,262.4 91.65,262.4 91.71,262.34 91.71,257.47 91.01,256.77 87.67,256.77 87.1,257.34 87.1,262.85
GND on LAY2: 88.43,138.83 92.92,138.83 94,137.75 94,136.57 93.11,135.68 93.11,134.91 86.95,128.75 83.22,128.75 82.66,129.32 82.66,135.22 85.39,137.95 87.45,137.95 87.46,137.95 87.54,137.95
GND on LAY2: 106.72,86.26 112.73,86.26 113.69,85.3 113.69,77.75 113.48,77.44 107.48,77.44 105.76,79.16 105.76,85.3
GND on LAY2: 95.54,137.82 97.3,137.82 97.3,137.45 96.41,136.57 96.41,133.9 93.24,130.72 93.24,126.15 92.66,125.58 89.36,125.58 88.54,124.75 88.54,122.34 86.57,120.37 82.5,120.37 79.07,116.94 77.63,116.94 76.81,117.77 76.81,122.13 77.06,122.38 77.06,123.15 77.38,123.47 78.27,123.47 79.22,124.42 79.22,125.56 79.29,125.63 80.68,125.63 83.28,128.23 83.28,128.55 87.03,128.55 93.32,134.83 93.32,135.59 94.04,136.32 94.06,136.29 94.14,136.29 94.2,136.35 94.2,136.48
GND on LAY2: 32.04,68.73 35.77,68.73 35.96,68.54 35.96,67.01 36.22,66.76 36.22,62.65 35.89,62.33 32.68,62.33 32.1,62.91 32.1,66.84 31.85,67.1 31.85,68.54 ; 1 cut-out
GND on LAY2: 61.44,69.75 63.58,69.75 63.86,69.47 63.86,63.89 64.21,63.53 64.6,63.53 64.79,63.33 64.79,63.03 64.34,62.58 63.79,62.58 63.79,62.58 61.76,62.58 61.44,62.91 ; 1 cut-out
GND on LAY2: 128.05,75.08 131.78,75.08 132.35,74.51 132.35,64.18 131.78,63.6 126,63.6 124.18,65.42 124.17,65.43 124.17,72.73 124.88,73.43 125.05,73.43 125.05,73.43 126.4,73.43
GND on LAY2: 29.37,60.98 30.44,60.98 31.84,59.58 39.46,59.58 40.11,58.93 42.01,58.93 42.26,58.69 42.26,58.33 42.18,58.25 42.18,56.17 43.58,54.76 43.58,52.87 40.85,50.14 29.5,50.14 28.29,51.35 28.29,59.9 ; 9 cut-outs
GND on LAY2: 67.85,291.59 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 ; 230 cut-outs
GND on LAY2: 73.57,264.18 80.72,264.18 81.23,263.67 84.41,263.67 85.36,262.72 85.36,261.03 85.17,260.83 73.83,260.83 73,261.66 73,263.61
GND on LAY2: 101.77,265.45 103.46,265.45 103.53,265.39 103.53,263.48 103.91,263.1 103.91,259.51 103.46,259.06 102.91,259.06 102.4,259.56 98.59,259.56 98.46,259.69 97.32,259.69 97.26,259.76 97.26,262.72 97.57,263.04 98.97,263.04 100.05,264.12 100.05,264.88 100.24,265.07 101.38,265.07 ; 3 cut-outs
GND on LAY3: 256.28,277.79 257.26,276.81 270.82,276.81 272,277.99 273.15,277.99 273.76,277.39 273.76,269.55 273.18,268.97 273.18,267.83 260.53,255.19 233.67,255.19 229.66,251.18 160.76,251.18 160.17,251.77 160.17,260.56 162,262.39 171.9,262.39 174.8,265.29 180.21,265.29 181.42,266.5 194.6,266.5 195.49,267.39 195.49,275.8 196.74,277.05 205.21,277.05 209.95,272.31 209.95,271.88 211.48,270.35 227.02,270.35 233.16,276.49 233.16,283.96 235.71,286.51 252.22,286.51 256.28,282.45 ; 2 cut-outs
GND on LAY3: 147.05,166.96 149.57,166.96 150.75,168.14 150.75,223.63 152.19,225.08 166.17,225.08 167.41,226.31 167.41,232.03 165.25,234.19 160.65,234.19 160.02,233.55 151.89,233.55 151.25,234.19 149.54,234.19 149.36,234.37 147.98,234.37 146.59,232.98 146.59,167.42
GND on LAY3: 33.27,71.37 35.81,71.37 36.44,70.74 36.44,65.91 38.48,63.88 38.48,60.96 39.49,59.94 41.02,59.94 43.56,57.4 43.56,52.2 40.64,49.27 31.36,49.27 30.6,50.04 29.59,50.04 28.7,50.93 28.7,55.37 28.06,56.01 28.06,60.07 30.6,62.61 30.6,65.78 32,67.18 32,69.09 32.89,69.98 32.89,70.99 ; 1 cut-out
GND on LAY3: 65.78,247.45 72.27,247.45 73.51,246.2 73.51,218.25 72.35,217.09 66.32,217.09 65.35,218.05 65.35,247.02
GND on LAY3: 140.71,3.43 146.81,3.43 147.44,4.06 147.44,7.36 147.19,7.62 140.97,7.62 140.2,6.86 140.2,3.94
GND on LAY3: 96.27,266.77 106.94,266.77 108.12,265.59 108.12,257.28 106.13,255.29 96.86,255.29 95.98,256.18 95.98,266.47 ; 1 cut-out
GND on LAY3: 141.43,157.78 146.27,157.78 146.71,157.34 146.71,149.06 145.9,148.25 139.36,148.25 139.15,148.46 139.15,155.5
GND on LAY3: 233.28,175.66 233.28,154.2 237.15,150.33 237.15,143.91 237.96,143.1 237.96,137.82 243.78,132 243.78,129.05 243.34,128.6 243.34,118.81 243.96,118.19 280.84,118.19 283.36,120.71 283.36,137.88 281.66,139.57 281.66,140.86 281.04,141.49 281.04,141.89 280.5,142.43 279.37,142.43 278.87,142.92 278.87,146.97 278.28,147.57 278.28,148.47 275.99,150.76 275.99,152.65 269.19,159.45 269.19,164.93 267.86,166.26 267.86,168.95 265.63,171.18 264.43,171.18 263.89,171.72 263.89,173.61 256.97,180.52 238.13,180.52 ; 2 cut-outs
GND on LAY3: 87.82,225.28 122.8,225.28 134.04,236.52 137.77,236.52 138.56,235.73 138.56,183.07 133.65,178.15 88.22,178.15 85.72,180.65 85.72,193.28 79.62,199.37 79.62,204.98 80.13,205.48 84.7,205.48 84.94,205.72 84.94,222.39 ; 7 cut-outs
GND on LAY3: 165.23,289.13 178.85,289.13 179.47,288.51 179.47,276.99 174.5,272.02 163.42,272.02 162.85,272.59 162.85,279.68 163.79,280.62 163.79,283.37 164.88,284.45 164.88,288.78 ; 2 cut-outs
GND on LAY3: 113.71,66.85 113.28,66.42 105.28,66.42 104.9,66.8 104.9,73.15 106.8,75.06 112.9,75.06 113.71,74.24
GND on LAY3: 183.94,258.72 189.66,258.72 190.16,258.21 190.16,252.12 189.72,251.68 183.66,251.68 183.16,252.19 183.16,257.93
GND on LAY3: 7.74,205.95 26.65,205.95 27.84,204.76 27.84,188.31 27.25,187.72 5.51,187.72 4.64,188.59 4.64,200.73 6.73,202.82 6.73,204.93
GND on LAY3: 113.53,77.98 113.15,77.6 105.28,77.6 104.9,77.98 104.9,84.33 106.93,86.36 112.64,86.36 113.53,85.47
GND on LAY3: 147.09,61.75 155.73,61.75 156.47,61.01 156.47,58.17 155.61,57.32 147.38,57.32 146.41,58.28 146.41,61.07
GND on LAY3: 124.19,73.07 126.54,73.07 127.86,71.76 131.43,71.76 131.9,71.28 131.9,69.19 131.46,68.75 125.06,68.75 123.66,70.15 123.66,72.55
GND on LAY3: 136.76,120.91 146.76,120.91 147.72,119.95 147.72,114.03 146.65,112.95 136.47,112.95 135.51,113.92 135.51,119.65
GND on LAY3: 292.22,244.36 301.33,244.36 302.02,243.67 302.02,229.24 300.55,227.77 294.76,227.77 291.6,230.93 291.6,230.95 291.3,231.25 291.3,243.44
GND on LAY3: 215.67,166.14 215.67,163.36 215.66,163.36 215.66,161.59 212.55,158.48 212.55,158.34 212.54,158.33 212.54,155.82 200.69,143.97 200.69,136.67 200.3,136.28 200.3,134.28 200.11,134.09 199.72,134.09 198.52,132.88 198.52,132.87 198.34,132.69 198.34,131.03 199.01,130.36 199.01,129.74 198.2,128.93 198.2,127.1 198.93,126.37 198.93,126.02 197.88,124.97 197.88,123.22 198.7,122.4 198.7,121.8 198.01,121.11 198.01,119.57 198.82,118.76 198.82,118.26 198.4,117.83 184.57,117.83 184.31,118.08 175.21,118.08 174.96,117.83 165.69,117.83 164.61,116.75 164.61,114.68 161.09,114.68 159.45,116.32 159.45,139.61 164.76,144.92 164.76,148.48 165.26,148.98 165.26,148.98 188.44,172.16 189.97,172.16 196.48,178.67 204.92,178.67 206.97,176.62 206.97,168.3 208.26,167.02 214.79,167.02
GND on LAY4: 67.85,291.59 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 ; 475 cut-outs
GND on LAY7: 67.85,291.59 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 ; 475 cut-outs
GND on LAY8: 145.69,7.23 147.38,7.23 147.72,6.88 147.72,4.38 146.37,3.02 144.17,3.02 143.88,3.32 143.88,5.41
GND on LAY8: 254.84,180.27 265.19,169.92 265.19,161.36 277.03,149.52 277.03,147.75 277.7,147.08 277.7,142.55 283.43,136.82 283.43,98.5 282.66,97.73 277.82,97.73 277.11,97.03 251.06,97.03 250.42,96.39 243.47,96.39 243.47,120.46 244.1,121.08 244.1,122.94 244.88,123.73 244.88,124.72 243.47,126.13 243.47,133.64 241.13,135.98 241.13,143.14 239.83,144.44 239.83,146.97 232.66,154.14 232.64,154.13 231.79,154.98 231.79,157.52 230.51,158.8 230.51,161.87 229.69,162.68 229.69,166.65 231.65,168.6 234.52,168.6 235.27,169.35 235.27,178.11 236.37,179.21 239.26,179.21 240.03,179.98 243.28,179.98 243.57,180.27
GND on LAY8: outline of 189 points within 159.01,96.34 218.22,179.11
GND on LAY8: 116.71,223.77 120.26,223.77 120.65,223.39 120.65,219.2 120.26,218.82 117.22,218.82 116.33,219.71 116.33,223.39
GND on LAY9: 67.85,291.59 299.8,291.59 302.98,290.28 304.29,287.1 304.29,43.1 302.98,39.92 299.8,38.61 177.29,38.61 177.29,5 175.98,1.82 172.8,0.51 5,0.51 1.82,1.82 0.51,5 0.51,287.1 1.82,290.28 5,291.59 67.85,291.59 ; 476 cut-outs
V1P05A_SW on TOP: 144.14,94.99 151.51,94.99 151.76,94.74 151.76,90.3 151.63,90.17 148.33,90.17 147.7,89.53 147.7,85.72 147.44,85.47 144.14,85.47 143.25,86.36 143.25,94.11
V1P05A_VAL_SW on TOP: 47.14,138.27 48.53,138.27 48.66,138.14 48.66,136.11 47.77,135.22 47.77,134.46 47.65,134.33 47.39,134.33 47.39,135.73 47.01,136.11 47.01,138.14
V1P05A_VAL_VIN on TOP: 44.34,136.24 46.38,136.24 47.14,135.48 47.14,134.46 47.01,134.33 46.5,134.33 46.25,134.08 44.34,134.08 44.22,134.21 44.22,136.11
V1P05A_VIN on TOP: 148.71,89.79 157.22,89.79 157.73,90.3 157.73,92.84 157.86,92.96 158.36,92.96 158.49,92.84 158.49,89.91 158.75,89.66 158.75,88.64 158.49,88.39 157.73,88.39 157.35,88.01 157.35,84.71 156.97,84.33 148.59,84.33 148.46,84.45 148.46,89.53
V1P05A_VIN_MIX on TOP: 160.4,88.01 160.4,84.2 160.27,84.07 157.98,84.07 157.86,84.2 157.86,87.88 158.11,88.14 160.27,88.14
V1P8A_LX on TOP: 51.81,100.84 51.68,100.71 51.68,99.44 52.19,98.93 56.13,98.93 56.26,99.06 56.26,102.74 56.13,102.87 53.59,102.87 53.21,102.49 53.21,100.96 53.08,100.84
V1P8A_PCH_VAL_SW on TOP: 47.14,156.71 48.53,156.71 48.66,156.58 48.66,154.55 47.77,153.66 47.77,152.9 47.65,152.77 47.39,152.77 47.39,154.17 47.01,154.55 47.01,156.58
V1P8A_PCH_VAL_VIN on TOP: 44.34,154.68 46.38,154.68 47.14,153.92 47.14,152.9 47.01,152.77 46.5,152.77 46.25,152.52 44.34,152.52 44.22,152.65 44.22,154.55
V3P3_DUAL_R on TOP: 39.24,78.1 38.98,77.85 38.98,69.59 39.37,69.21 42.16,69.21 42.29,69.34 42.29,72.64 42.79,73.15 43.56,73.15 46.6,76.2 46.6,77.85 46.35,78.1
V3P3A_AUX_LS on TOP: 35.17,230.38 34.16,230.38 34.03,230.25 34.03,229.23 33.9,229.11 33.9,227.96 34.03,227.84 35.05,227.84 35.3,228.09 35.3,230.25
V3P3A_PCH_VAL_SW on TOP: 47.16,147.57 48.56,147.57 48.69,147.44 48.69,145.41 47.8,144.52 47.8,143.76 47.67,143.63 47.42,143.63 47.42,145.03 47.04,145.41 47.04,147.44
V3P3A_PCH_VAL_VIN on TOP: 44.37,145.53 46.4,145.53 47.16,144.77 47.16,143.76 47.04,143.63 46.53,143.63 46.27,143.38 44.37,143.38 44.24,143.5 44.24,145.41
V3P3DSW_LX on TOP: 54.73,88.39 56.13,88.39 56.26,88.52 56.26,89.15 56.51,89.41 57.4,89.41 57.53,89.28 57.53,85.85 57.4,85.72 54.73,85.72 54.61,85.85 54.61,88.26
V3P3DSW_PCH_VAL_SW on TOP: 47.37,165.85 48.59,165.85 48.71,165.73 48.71,163.69 47.82,162.81 47.82,162.04 47.7,161.92 47.44,161.92 47.44,163.31 47.24,163.52 47.24,165.73
V3P3DSW_PCH_VAL_VIN on TOP: 44.39,163.82 46.43,163.82 47.19,163.06 47.19,162.04 47.06,161.92 46.55,161.92 46.3,161.66 44.39,161.66 44.27,161.79 44.27,163.69
V3P3DSW_VAL_SW on TOP: 47.11,129.38 48.51,129.38 48.64,129.25 48.64,127.22 47.75,126.33 47.75,125.57 47.62,125.44 47.37,125.44 47.37,126.84 46.99,127.22 46.99,129.25
V3P3DSW_VAL_VIN on TOP: 44.32,127.35 46.35,127.35 47.11,126.59 47.11,125.57 46.99,125.44 46.48,125.44 46.22,125.19 44.32,125.19 44.19,125.32 44.19,127.22
V12S_VCCSA_V10A on TOP: 161.54,246.89 159.13,246.89 158.49,247.52 157.6,247.52 157.35,247.78 157.35,250.32 157.6,250.57 161.03,250.57 161.67,249.93 161.67,247.01
VCCGT_VSWH_PH1 on TOP: 281.05,182.5 281.05,181.48 277.87,178.31 274.06,178.31 273.81,178.56 273.81,180.08 273.93,180.21 275.71,180.21 276.47,180.97 276.47,185.8 277.36,186.69 279.4,186.69 279.52,186.56 279.52,182.88 279.78,182.62 280.92,182.62
VCCGT_VSWH_PH2 on TOP: 281.05,169.06 281.05,168.02 279.4,166.37 273.71,166.37 273.45,166.62 273.45,168.4 273.83,168.78 275.1,168.78 276.47,170.15 276.47,173.12 276.6,173.25 279.4,173.25 279.52,173.12 279.52,169.44 279.78,169.19 280.92,169.19
VCCIO_0_VIN on TOP: 168.78,203.45 173.35,203.45 173.6,203.2 173.6,200.79 173.48,200.66 169.92,200.66 169.79,200.79 169.79,202.06 169.41,202.44 169.03,202.44 168.52,202.94 168.52,203.2
VCCIO_0_VSW on TOP: 169.16,198.12 172.97,198.12 173.22,197.86 173.22,195.83 173.1,195.71 169.16,195.71 169.03,195.83 169.03,197.99
VCCIO_1_2_VIN on TOP: 162.17,172.85 165.22,172.85 165.48,172.59 165.48,171.96 166.37,171.07 166.37,170.31 166.24,170.18 161.67,170.18 161.54,170.31 161.54,172.21
VCCIO_1_2_VSW on TOP: 161.03,167.89 163.32,167.89 163.7,167.51 163.7,164.84 163.57,164.72 160.27,164.72 160.02,164.97 160.02,165.99 160.9,166.88 160.9,167.77
VCCSA_VCC on TOP: 154.68,238.5 154.81,238.38 154.81,237.74 155.19,237.36 155.19,236.09 154.94,235.84 152.9,235.84 152.78,235.96 152.78,236.73 153.41,237.36 153.92,237.36 154.05,237.49 154.05,238.38 154.17,238.5
VCCSA_VIN on TOP: 164.59,244.09 164.59,242.57 164.33,242.31 163.06,242.31 162.3,243.08 162.3,244.73 162.05,244.98 162.05,250.44 162.43,250.82 165.35,250.82 165.6,250.57 165.6,244.98 165.35,244.73 165.22,244.73
VCCSA_VOUT on TOP: 171.7,247.27 178.18,247.27 179.19,246.25 179.19,244.22 179.07,244.09 175.51,244.09 174.87,244.73 171.95,244.73 171.7,244.98
VCCSA_VSW on TOP: 172.97,241.93 175,241.93 175.26,241.68 175.26,239.39 175,239.14 171.57,239.14 171.06,239.65 170.43,239.65 170.05,240.03 170.05,240.66 169.67,241.04 168.78,241.04 168.65,241.17 168.65,243.97 168.78,244.09 172.33,244.09 172.72,243.71 172.72,242.19
VCCSA_VSW on BOTTOM: 170.3,243.58 170.68,243.97 171.83,243.97 172.08,243.71 172.08,241.81 171.83,241.55 170.43,241.55 170.3,241.68
VCCSFR_OC_PVIN on TOP: 164.46,210.69 164.08,210.31 163.7,210.31 162.94,211.07 162.94,216.03 163.06,216.15 164.21,216.15 164.46,215.9
VCCSFR_OC_SW on TOP: 166.11,212.85 166.11,209.55 165.98,209.42 164.59,209.42 164.33,209.68 163.57,209.68 163.57,210.06 164.21,210.06 164.84,210.69 164.84,212.85 164.97,212.98 165.98,212.98
2X4_GND on TOP (solid shape): 299.46,279.65 299.46,279.02 299.33,278.89 298.57,278.89 298.32,279.14 298.32,279.65 298.57,279.91 299.21,279.91
+DRMOS_5V on BOTTOM: 228.21,253.24 230.25,253.24 230.37,253.11 230.37,252.22 230.25,252.09 228.09,252.09 227.96,252.22 227.96,252.98
+DRMOS_5V on BOTTOM: 256.03,250.7 256.79,250.7 256.92,250.57 256.92,249.17 256.79,249.05 255.65,249.05 255.39,249.3 255.39,250.06
+DRMOS_5V on LAY5: 199.89,248.79 207.01,248.79 207.26,249.05 209.04,249.05 209.67,249.68 217.67,249.68 218.18,249.17 222.63,249.17 223.01,248.79 223.77,248.79 224.15,249.17 233.8,249.17 233.93,249.3 233.93,249.55 234.18,249.81 241.8,249.81 242.63,248.98 256.79,248.98 256.92,249.11 256.92,249.43 257.3,249.81 267.58,249.81 268.66,248.73 271.33,248.73 272.16,247.9 272.16,246.25 272.41,246 273.05,246 273.55,246.51 273.55,248.66 270.51,251.71 268.85,251.71 268.73,251.59 234.18,251.59 233.93,251.84 233.93,252.35 232.66,253.62 229.48,253.62 226.82,250.95 223.64,250.95 223.26,251.33 201.29,251.33 199.77,249.81 199.77,248.92
+PW_VCC0V9_LAN on TOP: 91.18,251.97 94.61,251.97 94.74,251.84 94.74,250.57 94.36,250.19 93.85,250.19 93.59,249.93 93.59,249.3 92.83,249.3 91.94,250.19 91.05,250.19 90.93,250.32 90.93,251.71
+PW_VCC0V9_LAN on LAY6: 93.98,264.92 94.23,264.67 94.23,263.14 93.72,262.63 92.71,262.63 92.2,262.13 92.2,258.19 96.52,258.19 96.9,258.57 96.9,261.49 97.66,262.25 98.8,262.25 99.06,262 99.06,261.62 98.29,260.86 98.29,258.19 97.28,257.17 96.77,257.17 95.25,255.65 93.98,255.65 93.72,255.4 93.72,253.24 92.32,251.84 92.32,251.33 92.2,251.2 90.93,251.2 90.8,251.33 90.8,256.41 90.04,257.17 90.04,257.81 90.8,258.57 90.8,258.95 90.04,259.71 90.04,259.97 90.8,260.73 90.8,261.36 90.04,262.13 90.04,262.38 90.29,262.63 90.67,262.63 90.93,262.89 90.93,263.78 92.07,264.92
+PW_VCC0V9_LVR on BOTTOM: 164.08,271.52 165.35,271.52 165.47,271.4 165.47,270.76 165.09,270.38 165.09,268.73 164.97,268.6 164.08,268.6 163.82,268.86 163.82,271.27
+PW_VCC0V9_PCIE on BOTTOM: 169.28,268.86 170.55,268.86 170.68,268.73 170.68,266.32 170.55,266.19 168.65,266.19 168.4,266.44 168.4,266.95 168.78,267.33 168.78,268.35
+PW_VCC0V9_SVR_FOX on TOP: 93.21,257.17 93.98,257.17 94.1,257.05 94.1,255.65 93.85,255.4 93.85,254.38 94.74,253.49 94.74,252.6 94.61,252.47 93.34,252.47 92.83,252.98 92.83,255.9 93.21,256.28
+PW_VCC0V9_SVR_IND on TOP: 161.92,268.1 161.92,267.59 161.41,267.08 157.98,267.08 157.09,267.97 153.03,267.97 152.77,268.22 152.77,269.75 153.09,270.06 157.03,270.06 159,268.1
+U11EV_PIN7 on TOP: 60.96,36.7 63.88,36.7 64,36.57 64,35.94 64.38,35.56 64.38,32.76 64.13,32.51 63.11,32.51 62.99,32.64 62.99,35.69 62.73,35.94 60.96,35.94 60.83,36.07 60.83,36.57
+U12EV_PIN4 on TOP: 54.99,36.96 53.84,36.96 53.72,36.83 53.72,33.53 53.97,33.27 57.15,33.27 57.27,33.4 57.27,33.91 57.15,34.03 55.62,34.03 55.11,34.54 55.11,36.83
+V_3P3_PORT80 on BOTTOM: 35.17,268.86 36.19,268.86 36.57,268.48 39.75,268.48 40,268.22 40,267.59 39.75,267.33 38.1,267.33 37.46,266.7 35.17,266.7 35.05,266.83 35.05,268.73
+V_LDO_3V3_USBC on TOP: 136.27,267.33 137.92,267.33 138.3,266.95 138.3,266.57 138.04,266.32 137.16,266.32 136.14,265.3 134.74,265.3 134.62,265.43 134.62,266.19 134.87,266.44 135.38,266.44
+V_PPHV_TYPEC on TOP: 132.08,262 132.46,261.62 132.46,259.71 132.33,259.59 127.88,259.59 127.76,259.71 127.76,260.98 128.27,261.49 128.9,261.49 129.41,262
+V_PPHV_TYPEC_BP_R on TOP: 119.5,265.17 121.15,265.17 121.41,264.92 121.41,262.89 121.53,262.76 127.5,262.76 127.88,262.38 127.88,261.62 127.12,260.86 127.12,259.08 126.87,258.82 126.74,258.82 126.23,259.33 119.5,259.33 119.38,259.46 119.38,265.05
+V_VDDQ_VR_OUT on TOP: 249.42,94.11 258.19,94.11 259.33,95.25 261.36,95.25 261.49,95.12 261.49,88.52 261.23,88.26 255.77,88.26 255.65,88.14 255.65,87.5 255.52,87.37 254.5,87.37 253.68,88.2 249.49,88.2 249.04,88.64 249.04,93.72
+VHDMI_1P2S_PHASE on TOP: 265.93,259.97 271.14,259.97 271.27,259.84 271.27,259.74 271.22,259.7 270.61,259.7 270.49,259.58 270.49,258.81 269.62,257.94 265.93,257.94 265.81,258.06 265.81,259.84
+VHDMI_1P2S_VR_IN on TOP: 273.4,260.09 273.93,260.09 274.06,260.22 274.95,260.22 275.08,260.09 275.08,257.94 274.95,257.81 274.06,257.81 273.81,258.06 273.81,258.82 273.36,259.27 273.36,259.54 273.22,259.69 272.69,259.69 272.66,259.72 272.66,259.95 272.7,259.98 273.29,259.98
+VPP on TOP: 145.41,105.79 146.81,105.79 147.44,106.42 147.44,123.44 148.08,124.08 152.14,124.08 155.19,121.03 156.97,121.03 158.24,119.76 158.24,118.24 157.98,117.98 155.82,117.98 155.32,118.49 149.35,118.49 148.59,117.73 148.59,114.55 150.87,114.55 153.03,112.39 158.11,112.39 158.36,112.14 158.36,106.81 157.86,106.3 156.84,106.3 156.71,106.17 156.71,105.92 156.59,105.79 155.57,105.79 155.44,105.92 155.44,106.93 155.7,107.19 155.7,107.69 155.06,108.33 151.89,108.33 150.87,107.31 150.87,105.15 151.25,104.77 153.79,104.77 155.7,102.87 158.11,102.87 158.36,102.61 158.36,98.42 156.71,96.77 148.46,96.77 147.7,97.53 147.7,102.61 147.06,103.25 144.78,103.25 144.65,103.38 144.65,103.88 145.28,104.52 145.28,105.66
+VPP on TOP: 155.91,125.75 154.41,127.25 154.41,131.44 154.94,131.97 154.94,133.22 155.32,133.6 156.97,133.6 157.33,133.24 157.33,131.57 158.85,130.05 158.85,129.28 157.97,128.4 157.97,127.51 158.6,126.87 158.6,125.98 158.37,125.75
