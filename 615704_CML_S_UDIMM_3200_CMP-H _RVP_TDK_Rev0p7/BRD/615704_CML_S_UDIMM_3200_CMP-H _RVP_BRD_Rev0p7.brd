# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+V3P3_SLOTE_R on TOP: 72.89,251.46 74.04,251.46 75.18,250.32 76.07,250.32 76.2,250.19 76.2,247.78 75.94,247.52 74.8,247.52 72.89,249.43
+V3P3_SLOTM on TOP: 23.36,65.91 25.52,65.91 25.65,65.78 25.65,65.15 25.4,64.9 25.4,62.74 25.52,62.61 37.97,62.61 38.1,62.74 38.1,64.64 38.6,65.15 42.41,65.15 44.19,63.37 44.19,62.86 44.57,62.48 45.46,62.48 45.84,62.1 45.84,61.85 45.33,61.34 45.33,60.45 44.7,59.82 32.51,59.82 32.13,60.2 30.98,60.2 30.6,60.58 23.74,60.58 23.24,61.09 23.24,65.78
+V3P3_SLOTM on TOP: 47.37,64.13 48.64,64.13 48.89,63.88 48.89,61.72 48.64,61.47 45.08,61.47 43.81,62.74 42.54,62.74 42.54,65.15 42.67,65.15 43.18,64.64 44.19,64.64 44.83,65.28 46.73,65.28 46.86,65.15 46.86,64.64
+V3P3_SLOTM on TOP: 42.03,66.29 39.62,66.29 39.24,65.91 38.6,65.91 38.1,65.4 38.1,62.99 38.35,62.74 39.75,62.74 39.87,62.86 39.87,64.39 40,64.51 41.52,64.51 41.65,64.39 41.65,62.86 41.78,62.74 42.54,62.74 42.67,62.86 42.67,65.66
+V3P3_SLOTM_LS on TOP: 48.51,67.31 47.87,67.31 47.37,66.8 47.37,64.9 47.75,64.51 48.64,64.51 48.89,64.77 48.89,65.53 48.64,65.78 48.64,67.18
+V3P3A on TOP (solid shape): 215.41,42.95 215.41,42.51 214.85,41.95 213.74,41.95 213.64,42.05 213.64,42.96 213.91,43.24 215.12,43.24
+V3P3A on TOP: 66.67,81.02 66.67,78.99 66.8,78.87 67.43,78.87 67.69,79.12 67.69,81.02 67.56,81.15 66.8,81.15
+V3P3A on TOP: 71.37,250.06 72.39,250.06 72.77,249.68 72.77,248.54 72.51,248.28 71.24,248.28 70.99,248.54 70.99,249.68
+V3P3A on TOP: 105.15,282.95 106.17,282.95 106.42,282.7 106.42,281.18 106.29,281.05 105.15,281.05 105.02,281.18 105.02,282.83
+V3P3A on TOP: 52.07,65.28 53.46,65.28 53.59,65.4 53.59,66.17 53.08,66.67 51.3,66.67 51.18,66.55 51.18,66.42 50.92,66.17 50.92,65.15 51.18,64.9 51.68,64.9
+V3P3A on TOP: 35.94,87.12 34.41,87.12 34.29,86.99 34.29,85.22 34.54,84.96 35.94,84.96 36.06,85.09 36.06,86.99
+V3P3A on TOP: 34.03,227.58 33.9,227.46 33.9,226.44 34.03,226.31 34.03,223.39 34.16,223.26 34.29,223.26 34.67,222.88 35.56,222.88 35.81,223.14 35.81,227.2 35.43,227.58
+V3P3A on TOP: 29.59,284.73 30.98,284.73 32.25,283.46 32.25,282.19 32.13,282.07 29.59,282.07 29.46,282.19 29.46,284.61
+V3P3A on TOP: 132.96,281.05 134.74,281.05 138.93,276.86 143.51,276.86 143.89,276.48 143.89,274.83 143.63,274.57 138.81,274.57 133.6,279.78 132.96,279.78 132.84,279.91 132.84,280.92
+V3P3A on TOP: 65.02,92.96 64.89,92.84 61.46,92.84 61.21,93.09 61.21,95.88 61.59,96.26 64.89,96.26 65.02,96.14
+V3P3A on TOP: 41.78,169.42 40,169.42 39.87,169.29 39.87,168.15 40.13,167.89 41.78,167.89 41.91,168.02 41.91,169.29
+V3P3A on BOTTOM: 34.41,87.25 34.41,85.98 34.67,85.72 42.16,85.72 49.27,92.84 64.51,92.84 64.89,93.22 64.89,94.74 64.64,94.99 48.51,94.99 42.41,88.9 37.46,88.9 36.95,88.39 35.56,88.39
+V3P3A on BOTTOM: 53.21,67.05 53.34,66.93 53.34,65.02 53.21,64.9 51.3,64.9 50.92,65.28 50.92,66.55 51.43,67.05
+V3P3A on BOTTOM: 31.24,227.2 31.24,223.14 31.87,222.5 35.68,222.5 35.94,222.76 35.94,236.09 37.97,238.12 42.67,238.12 43.56,237.23 44.57,237.23 46.35,239.01 47.11,239.01 47.62,239.52 47.62,251.33 47.11,251.84 45.08,251.84 44.7,251.46 44.7,244.22 42.92,242.44 38.35,242.44 35.56,239.65 35.56,238.76 33.52,236.73 33.52,229.49
+V3P3A on BOTTOM: 76.96,75.82 75.43,75.82 74.73,75.12 71.69,75.12 71.62,75.18 70.35,75.18 69.46,76.07 66.42,76.07 63.24,72.9 63.24,72.39 63.32,72.31 75.2,72.31 77.21,74.32 77.21,75.56
+V3P3A on BOTTOM: 58.42,278 59.81,278 60.07,278.26 60.07,280.03 59.94,280.16 58.8,280.16 58.29,279.65 58.29,278.13
+V3P3A on BOTTOM: 76.7,167.77 76.58,167.64 74.04,167.64 73.66,168.02 73.66,169.8 73.91,170.05 76.45,170.05 76.7,169.8
+V3P3A on LAY2: outline of 197 points within 50.13,72.49 108.99,206.93 ; 3 cut-outs
+V3P3A on LAY5: 32.89,225.3 33.9,226.31 35.05,226.31 35.17,226.19 35.17,223.14 34.29,222.25 34.29,213.99 36.19,212.09 54.35,212.09 56.38,214.12 62.48,214.12 64.83,211.77 64.83,207.58 65.27,207.14 65.27,191.13 62.86,188.72 52.7,188.72 49.14,185.16 44.45,185.16 42.79,183.51 42.79,168.27 40.89,166.37 40.89,159.76 40.51,159.38 36.32,159.38 31.49,164.21 31.49,178.69 40.25,187.45 40.25,189.99 41.52,191.26 48.64,191.26 49.78,192.4 54.99,192.4 55.75,193.17 58.29,193.17 58.42,193.29 58.42,194.31 58.16,194.56 57.4,194.56 57.02,194.94 57.02,196.21 57.78,196.98 57.78,197.86 57.65,197.99 49.4,197.99 48.76,198.63 48.76,199.77 49.27,200.28 56.38,200.28 56.89,199.77 57.78,199.77 58.16,200.15 58.16,205.1 55.11,208.15 43.94,208.15 42.54,206.75 39.75,206.75 38.22,208.28 36.44,208.28 34.92,209.8 27.05,209.8 26.67,210.18 26.67,210.95 29.21,213.49 29.21,224.66 29.84,225.3
+V3P3A on LAY5: 45.46,251.33 47.37,251.33 47.62,251.08 47.62,250.19 47.37,249.93 45.33,249.93 44.95,250.32 44.95,250.82
+V3P3A on LAY5: 70.73,249.43 72.64,249.43 73.02,249.05 73.02,248.41 72.77,248.16 71.24,248.16 70.61,248.79 70.61,249.3
+V3P3A on LAY6: 31.36,285.88 34.67,285.88 35.05,285.49 35.05,283.72 34.54,283.21 30.73,283.21 30.6,283.34 30.6,285.11
+V3P3A on LAY6: 109.22,283.72 111.37,283.72 112.77,282.32 112.77,278.76 112.52,278.51 112.52,273.3 113.79,272.03 119.25,272.03 119.76,272.54 119.76,273.3 120.14,273.68 125.22,273.68 125.85,274.32 125.85,276.1 126.61,276.86 127.76,276.86 128.77,275.84 128.77,275.72 129.28,275.21 132.2,275.21 132.71,275.72 132.71,280.8 132.96,281.05 134.23,281.05 134.62,280.67 134.62,274.57 132.71,272.67 129.66,272.67 128.27,274.06 128.01,274.06 127.76,273.81 127.76,273.05 126.87,272.16 123.95,272.16 122.17,270.38 112.9,270.38 110.49,272.79 110.49,280.41 110.1,280.8 105.28,280.8 104.9,281.18 104.9,281.62 104.17,282.35 104.14,282.32 103.5,282.32 103.25,282.57 103.25,284.48 103.5,284.73 108.2,284.73
+V3P3A on LAY6: 59.18,280.67 60.57,280.67 60.83,280.41 60.83,279.02 60.19,278.38 58.92,278.38 58.8,278.51 58.8,280.29
+V3P3A_1P8A_R_SNSR_HDR on TOP: 53.72,51.81 53.84,51.94 55.11,51.94 55.37,51.69 55.37,50.42 55.24,50.29 53.97,50.29 53.72,50.54
+V3P3A_1P8A_R_SNSR_HDR on TOP: 105.02,280.54 107.56,280.54 107.69,280.41 107.69,279.65 106.55,278.51 104.9,278.51 104.77,278.64 104.77,280.29
+V3P3A_1P8A_R_SNSR_HDR on LAY5: 105.91,279.14 99.82,279.14 99.44,278.76 99.44,277.49 99.82,277.11 105.91,277.11 106.17,277.37 106.17,278.89
+V3P3A_1P8A_R_SNSR_HDR on LAY6: 54.99,19.43 54.35,19.43 54.22,19.56 54.22,20.83 53.84,21.21 53.84,21.59 54.1,21.84 54.35,21.84 55.11,21.08 55.11,19.56
+V3P3A_1P8A_R_SNSR_HDR on LAY6: 55.11,51.69 53.97,51.69 53.34,51.05 53.34,45.46 53.72,45.08 55.37,45.08 55.75,45.46 55.75,50.29 55.37,50.67 55.37,51.43
+V3P3A_1P8A_SNSR_HDR on TOP: 53.97,56.77 54.1,56.64 54.1,54.23 53.59,53.72 53.59,52.07 53.34,51.81 53.34,51.05 53.21,50.93 51.68,50.93 51.3,51.31 51.3,56.13 51.94,56.77
+V3P3A_1P8A_SNSR_HDR on LAY5: 51.81,52.58 51.81,49.27 52.32,48.77 55.49,48.77 56.26,49.53 56.26,51.69 56,51.94 54.48,51.94 53.72,52.7 51.94,52.7
+V3P3A_PCH_VAL on TOP: 133.47,120.01 135.12,120.01 135.38,119.76 135.38,119.12 135,118.74 133.47,118.74 133.22,119 133.22,119.76
+V3P3A_PCH_VAL on TOP: 161.16,192.28 159.89,192.28 159.76,192.15 159.76,189.61 160.14,189.23 160.65,189.23 160.78,189.1 162.68,189.1 163.06,189.48 163.06,189.86 162.17,190.75 162.17,191.26 162.05,191.39 161.54,191.39 161.29,191.64 161.29,192.15
+V3P3A_PCH_VAL on TOP: 76.83,105.54 79.75,105.54 79.88,105.41 79.88,103.88 79.37,103.38 76.96,103.38 76.7,103.63 76.7,105.41
+V3P3A_PCH_VAL on TOP: 75.18,171.96 77.85,169.29 77.85,168.91 77.47,168.53 76.83,168.53 75.05,170.31 74.04,170.31 73.66,170.69 73.66,171.7 73.91,171.96
+V3P3A_PCH_VAL on TOP: 103.63,94.36 101.21,94.36 100.71,93.85 100.71,92.33 101.21,91.82 103.63,91.82 103.88,92.07 103.88,94.11
+V3P3A_PCH_VAL on TOP: 56.51,165.86 57.02,165.35 58.92,165.35 59.3,165.73 61.08,165.73 61.21,165.86 61.21,167.51 60.7,168.02 57.65,168.02 56.51,166.88
+V3P3A_PCH_VAL on TOP: 52.75,147.44 54.53,147.44 54.56,147.4 55.54,147.4 55.88,147.06 55.88,144.78 55.37,144.27 53.51,144.27 52.62,145.15 52.62,147.31
+V3P3A_PCH_VAL on BOTTOM: 78.1,105.54 81.28,105.54 81.53,105.28 81.53,99.82 82.67,98.68 83.18,98.68 83.43,98.42 83.43,97.41 83.31,97.28 81.78,97.28 79.37,99.69 78.74,99.69 77.85,100.58 77.85,105.28
+V3P3A_PCH_VAL on BOTTOM: 102.99,93.72 102.99,92.33 102.48,91.82 100.58,91.82 98.93,93.47 98.93,93.98 100.33,95.38 101.34,95.38
+V3P3A_PCH_VAL on LAY5: 74.93,149.73 74.8,149.86 74.8,151.38 75.05,151.64 75.05,152.4 75.18,152.53 75.81,152.53 76.07,152.27 76.07,151 75.81,150.75 75.81,149.99 75.56,149.73
+V3P3A_PCH_VAL on LAY5: 76.7,170.05 77.72,170.05 77.85,169.92 77.85,166.24 77.21,165.61 77.21,163.32 76.7,162.81 75.31,162.81 74.93,163.19 74.93,165.23 76.45,166.75 76.45,169.8
+V3P3A_PCH_VAL on LAY6: 57.65,166.75 56.38,166.75 56,166.37 56,165.48 56.38,165.1 57.78,165.1 57.91,165.23 57.91,166.5
+V3P3A_PCH_VAL on LAY6: 53.46,149.6 53.46,146.43 53.97,145.92 54.86,145.92 55.37,146.43 55.37,149.73 55.11,149.99 53.84,149.99
+V3P3A_PCH_VAL on LAY8: 159.25,190.12 162.94,190.12 163.19,189.86 163.19,189.1 162.81,188.72 160.65,188.72 157.35,185.42 157.35,180.97 155.44,179.07 155.44,176.66 152.78,173.99 152.78,163.32 151.63,162.18 150.87,162.18 145.28,156.59 143.51,156.59 142.36,155.45 142.36,146.94 134.74,139.32 134.74,123.44 135.12,123.06 135.12,119.25 134.87,119 132.96,119 132.46,119.51 132.46,139.32 140.33,147.19 140.33,155.83 142.87,158.37 144.9,158.37 149.35,162.81 149.35,164.72 151.25,166.62 151.25,177.54 155.7,181.99 155.7,186.56
+V3P3A_PCH_VAL_OUT on TOP: 49.45,147.44 51.99,147.44 52.12,147.31 52.12,145.15 52.5,144.77 52.5,143.88 52.37,143.76 49.32,143.76 49.19,143.88 49.19,147.19
+V3P3A_PCIEAUX on TOP: 57.02,238.12 58.29,238.12 58.54,237.87 58.54,236.47 58.16,236.09 53.34,236.09 53.21,236.22 53.21,237.11 53.34,237.23 56.13,237.23
+V3P3A_PCIEAUX on TOP: 32.38,235.08 35.3,235.08 36.06,235.84 38.73,235.84 38.98,235.58 38.98,234.69 38.73,234.44 36.95,234.44 36.06,233.55 33.78,233.55 33.65,233.68 32.51,233.68 32.25,233.93 32.25,234.95
+V3P3A_PCIEAUX on TOP: 139.57,238.25 134.36,238.25 134.11,238 134.11,237.11 134.23,236.98 139.57,236.98 139.82,237.23 139.82,238
+V3P3A_PCIEAUX on LAY5: 76.83,239.39 72.64,239.39 72.26,239.01 72.26,238 72.51,237.74 76.2,237.74 76.83,237.11 77.34,237.11 77.97,237.74 77.97,238.25
+V3P3A_PCIEAUX on LAY5: 135.5,237.87 135,238.38 133.73,238.38 132.33,236.98 129.41,236.98 127,234.57 117.22,234.57 116.58,233.93 116.58,232.28 116.84,232.03 119.76,232.03 120.77,231.01 131.06,231.01 135.5,235.46
+V3P3A_PCIEAUX on LAY5: 36.83,234.44 37.97,234.44 40.76,237.23 42.54,237.23 43.94,235.84 57.65,235.84 58.54,236.73 58.54,238 55.49,241.04 36.95,241.04 36.19,240.28 36.19,235.08
+V3P3A_PCIEAUX on LAY6: 53.08,235.84 58.42,235.84 59.3,236.73 62.61,236.73 63.11,236.22 71.5,236.22 73.78,238.5 73.78,239.01 73.53,239.27 72.77,239.27 72.26,239.77 69.97,239.77 69.46,239.27 66.42,239.27 64.38,241.3 55.49,241.3 52.32,238.12 52.32,236.6
+V3P3A_PCIEAUX_LAN on TOP: 31.36,236.73 34.92,236.73 36.32,238.12 38.1,238.12 38.22,238 38.22,237.11 37.21,236.09 36.06,236.09 35.3,235.33 32.25,235.33 31.62,234.69 31.62,232.66 31.49,232.54 30.48,232.54 30.35,232.66 30.35,235.71
+V3P3A_SNSR_HDR on TOP: 54.35,64.39 52.32,64.39 51.94,64.01 51.94,60.32 52.19,60.07 54.48,60.07 54.61,60.2 54.61,64.13
+V3P3A_TCH_PNL on TOP: 62.73,198.63 61.84,198.63 60.96,197.74 60.96,197.23 61.08,197.1 61.34,197.1 61.72,197.48 62.48,197.48 62.86,197.86 62.86,198.5
+V3P3A_USBC on TOP: 135.76,173.86 138.04,173.86 138.17,173.99 138.17,187.07 137.79,187.45 134.36,187.45 133.71,186.8 133.71,186.3 133.38,185.98 133.38,185.82 133.46,185.75 134.82,185.75 134.9,185.67 135.44,185.67 135.5,185.73 135.5,186.43 135.58,186.52 136.78,186.52 136.94,186.36 136.94,185.71 136.21,184.97 135.96,184.97 135.89,184.9 135.89,174.88 135.63,174.62 135.63,173.99 ; 1 cut-out
+V3P3A_USBC on LAY5: 134.11,192.02 134.62,192.02 134.74,191.9 135.38,191.9 135.76,191.51 135.76,187.2 134.62,186.05 133.85,186.05 133.6,186.31 133.6,191.64 134.11,192.15
+V3P3A_VAL on TOP: 87.24,38.23 89.53,38.23 89.66,38.1 89.66,37.46 89.02,36.83 87.37,36.83 87.12,37.08 87.12,38.1
+V3P3A_VAL on BOTTOM: 118.87,38.86 119.76,38.86 120.01,39.11 120.01,55.5 119.76,55.75 119.25,55.75 118.61,55.12 118.61,39.11
+V3P3A_VAL on LAY5: 91.94,46.1 91.94,44.7 92.2,44.45 94.23,44.45 94.48,44.7 94.48,45.97 94.23,46.23 92.07,46.23
+V3P3A_VAL on LAY5: 119.88,47.37 118.74,47.37 118.49,47.12 118.49,45.34 118.74,45.08 119.88,45.08 120.14,45.34 120.14,47.12
+V3P3A_VAL on LAY6: 89.53,37.97 88.26,37.97 88.01,37.72 88.01,36.32 88.26,36.07 91.94,36.07 92.45,36.57 92.45,43.81 92.83,44.19 92.83,45.97 92.71,46.1 90.29,46.1 89.91,45.72 89.91,38.35
+V3P3A_VR on TOP: 57.91,94.87 60.57,94.87 60.7,94.74 60.7,91.06 60.57,90.93 58.42,90.93 57.02,92.33 57.02,93.98
+V3P3DSW on TOP: 123.82,251.97 118.99,251.97 118.74,251.71 118.74,249.68 118.99,249.43 123.95,249.43 124.2,249.68 124.2,251.59
+V3P3DSW on TOP: 172.46,255.9 173.99,255.9 174.11,255.78 174.11,252.73 173.86,252.47 171.83,252.47 171.57,252.73 171.57,255.01
+V3P3DSW on TOP: 62.61,92.45 64.89,92.45 65.02,92.33 65.02,89.15 64.77,88.9 62.73,88.9 62.48,89.15 62.48,92.33
+V3P3DSW on TOP: 107.18,277.24 106.93,277.49 106.93,278.64 107.31,279.02 109.6,279.02 109.72,278.89 109.72,277.37 109.6,277.24
+V3P3DSW on TOP: 48.89,94.36 48,93.47 48,89.03 44.83,85.85 36.57,85.85 36.44,85.98 36.44,86.99 36.57,87.12 44.19,87.12 46.35,89.28 46.35,96.01 46.48,96.14 56.26,96.14 56.76,95.63 56.76,95.12 56,94.36
+V3P3DSW on TOP: 211.83,264.16 213.74,264.16 213.99,263.9 213.99,262.51 213.86,262.38 211.7,262.38 211.58,262.51 211.58,263.9
+V3P3DSW on TOP: 28.06,196.34 28.06,200.15 28.19,200.28 29.46,200.28 29.71,200.02 29.71,196.47 29.46,196.21 28.19,196.21
+V3P3DSW on TOP: 149.22,272.67 149.98,272.67 150.49,272.16 150.49,271.27 150.24,271.02 149.22,271.02 148.97,271.27 148.97,272.41
+V3P3DSW on TOP: 155.82,212.34 155.19,212.34 154.68,211.83 154.68,209.17 155.19,208.66 156.21,208.66 156.97,209.42 156.97,211.83 156.71,212.09 156.08,212.09
+V3P3DSW on TOP: 73.78,254.63 73.78,253.24 72.51,251.97 72.51,250.95 72.26,250.7 71.5,250.7 71.24,250.95 71.24,254.51 71.5,254.76 73.66,254.76
+V3P3DSW on BOTTOM: 118.11,252.35 121.03,252.35 121.79,251.59 121.79,251.33 119.25,248.79 113.53,248.79 112.52,249.81 108.58,249.81 106.93,251.46 106.93,253.24 107.31,253.62 109.34,253.62 109.85,253.11 117.34,253.11
+V3P3DSW on BOTTOM: 110.49,279.02 103.75,279.02 102.36,277.62 102.36,267.46 103.12,266.7 105.66,266.7 106.17,267.21 106.17,274.7 107.69,276.22 110.49,276.22 110.74,276.48 110.74,278.76
+V3P3DSW on BOTTOM: 66.92,92.71 70.86,96.65 71.62,96.65 71.88,96.39 71.88,93.85 66.54,88.52 61.59,88.52 60.45,89.66 56.13,89.66 55.62,89.15 55.62,85.85 54.61,84.83 53.72,84.83 52.7,83.82 43.43,83.82 43.3,83.95 43.3,86.36 49.65,92.71 ; 2 cut-outs
+V3P3DSW on BOTTOM: 148.2,270.89 150.24,270.89 150.49,271.14 150.49,272.41 149.98,272.92 147.32,272.92 147.06,272.67 147.06,272.03
+V3P3DSW on LAY2: outline of 212 points within 24.23,83.16 74.06,254.79 ; 4 cut-outs
+V3P3DSW on LAY5: 211.7,264.16 213.23,264.16 213.86,263.52 213.86,262.13 210.94,259.21 208.15,259.21 207.89,259.46 207.89,260.35
+V3P3DSW on LAY5: 151.89,171.45 155.19,171.45 155.44,171.19 155.44,169.16 154.55,168.27 153.54,168.27 151.76,170.05 151.76,171.32
+V3P3DSW on LAY5: 121.41,116.2 122.8,116.2 123.19,115.82 123.19,114.3 122.93,114.04 121.53,114.04 121.15,114.43 121.15,115.95
+V3P3DSW on LAY5: 157.35,211.58 155.82,211.58 155.06,210.82 155.06,205.99 155.44,205.61 155.44,201.67 154.55,200.79 154.55,198.25 155.19,197.61 155.19,194.69 155.95,193.93 157.35,193.93 157.48,194.05 157.48,198.12 157.73,198.37 157.73,206.75 157.6,206.88 157.6,211.33
+V3P3DSW on LAY5: 172.59,254.25 174.11,254.25 175.51,255.65 181.22,255.65 182.24,256.67 191.77,256.67 192.65,255.78 194.81,255.78 196.59,257.55 196.59,258.7 196.34,258.95 194.43,258.95 193.54,258.06 192.53,258.06 192.15,258.44 188.84,258.44 188.34,257.94 179.95,257.94 179.19,257.17 174.24,257.17 172.33,255.27 172.33,254.51
+V3P3DSW on LAY5: 70.23,45.72 70.23,44.7 70.35,44.58 82.16,44.58 83.56,45.97 86.36,45.97 86.61,45.72 89.15,45.72 89.91,46.48 89.91,46.99 89.53,47.37 87.75,47.37 86.99,48.13 81.91,48.13 80.26,46.48 76.07,46.48 75.43,45.85 70.35,45.85
+V3P3DSW on LAY6: 123.31,83.69 125.73,83.69 126.11,83.31 126.11,78.36 125.85,78.1 124.33,78.1 122.8,79.63 122.8,83.18
+V3P3DSW on LAY6: 133.35,48.39 135.12,48.39 135.76,49.02 135.76,59.43 135.25,59.94 135.25,67.82 134.87,68.2 132.58,68.2 131.95,67.56 131.95,62.74 132.01,62.67 132.01,49.72
+V3P3DSW on LAY6: 70.1,53.21 72.39,53.21 73.53,54.35 73.53,60.45 72.39,61.59 72.39,64.01 72.89,64.51 72.89,67.56 72.64,67.82 70.86,67.82 70.1,67.05 70.1,64.51 69.34,63.75 69.34,53.97
+V3P3DSW on LAY6: 70.48,46.61 71.62,46.61 71.88,46.35 71.88,44.7 71.75,44.58 70.35,44.58 70.23,44.7 70.23,46.35
+V3P3DSW on LAY6: 104.52,279.65 108.83,279.65 109.85,278.64 109.85,278.13 106.42,274.7 88.39,274.7 82.55,268.86 75.31,268.86 68.58,262.13 68.58,257.17 71.12,254.63 72.89,254.63 73.27,254.25 73.27,250.7 73.02,250.44 67.56,250.44 65.53,252.47 65.53,252.6 63.37,254.76 63.37,261.87 68.45,266.95 68.45,274.95 70.23,276.73 85.47,276.73 86.86,278.13 99.56,278.13 100.83,279.4 104.26,279.4 ; 1 cut-out
+V3P3DSW on LAY6: 121.41,116.33 122.04,116.33 122.3,116.08 122.3,113.28 122.04,113.03 121.28,113.03 121.03,113.28 121.03,115.95
+V3P3DSW_OUT on TOP: 58.92,89.53 59.18,89.79 59.69,89.79 59.88,89.98 60,89.98 60.19,90.17 61.59,90.17 61.72,90.04 61.72,83.69 61.97,83.44 61.97,81.91 61.84,81.79 59.3,81.79 58.92,82.17
+V3P3DSW_PCH_VAL on TOP: 72.89,122.93 71.37,122.93 71.24,122.81 71.24,121.66 71.88,121.03 72.89,121.03 73.02,121.16 73.02,122.81
+V3P3DSW_PCH_VAL on TOP: 52.78,165.73 54.22,165.73 54.61,165.35 54.61,163.32 54.48,163.19 54.48,163.19 52.9,163.19 52.65,163.44 52.65,165.6
+V3P3DSW_PCH_VAL on LAY6: 61.21,134.62 60.7,134.62 60.32,134.24 60.32,133.6 61.34,132.59 61.59,132.59 62.23,133.22 62.23,133.6
+V3P3DSW_PCH_VAL on LAY6: 70.1,123.06 71.62,123.06 71.88,122.81 71.88,121.66 71.62,121.41 70.23,121.41 69.97,121.66 69.97,122.93
+V3P3DSW_PCH_VAL_OUT on TOP: 49.47,165.73 52.01,165.73 52.14,165.6 52.14,163.44 52.52,163.06 52.52,162.17 52.4,162.04 49.35,162.04 49.22,162.17 49.22,165.47
+V3P3DSW_USBRD_1 on TOP: 211.45,261.87 213.86,261.87 214.24,261.49 214.24,259.71 214.63,259.33 216.66,259.33 217.17,258.82 217.17,258.57 216.78,258.19 214.12,258.19 213.61,257.68 213.61,255.01 213.23,254.63 212.59,254.63 211.96,254 210.69,254 210.56,254.13 210.56,257.05 210.31,257.3 209.29,257.3 208.78,256.79 208.4,256.79 208.15,257.05 208.15,257.55 209.67,259.08 210.94,259.08 211.2,259.33 211.2,261.62 ; 2 cut-outs
+V3P3DSW_USBRD_1 on LAY6: 199.77,259.21 224.15,259.21 227.96,255.4 227.96,255.01 227.71,254.76 224.28,254.76 223.13,253.62 216.91,253.62 216.28,254.25 211.2,254.25 210.56,253.62 196.72,253.62 196.08,254.25 196.08,255.52 ; 2 cut-outs
+V3P3DSW_VAL on TOP: 99.69,88.14 100.45,88.14 100.71,87.88 100.71,85.22 100.58,85.09 99.44,85.09 99.31,85.22 99.31,87.76
+V3P3DSW_VAL on TOP: 93.34,48.64 94.61,48.64 94.86,48.39 94.86,46.73 94.61,46.48 93.34,46.48 93.09,46.73 93.09,48.39
+V3P3DSW_VAL on TOP: 53.84,176.53 54.48,176.53 54.61,176.4 54.61,175.64 54.48,175.51 52.7,175.51 52.57,175.64 52.57,176.91 52.7,177.04 53.34,177.04
+V3P3DSW_VAL on TOP: 69.21,103 70.86,103 71.24,102.61 71.24,101.85 71.12,101.73 69.21,101.73 68.83,102.11 68.83,102.61
+V3P3DSW_VAL on TOP: 53.59,181.86 54.48,181.86 54.61,181.74 54.61,181.1 54.48,180.97 53.72,180.97 53.46,180.72 53.08,180.72 52.95,180.85 52.95,181.86 53.08,181.99 53.46,181.99
+V3P3DSW_VAL on TOP: 52.7,129.25 54.76,129.25 55.24,128.78 55.24,126.97 54.99,126.71 52.83,126.71 52.57,126.97 52.57,129.13
+V3P3DSW_VAL on BOTTOM: 96.52,85.6 96.26,85.85 96.26,86.99 97.28,88.01 99.44,88.01 99.56,88.14 99.82,88.14 100.07,87.88 100.07,86.74 98.93,85.6
+V3P3DSW_VAL on BOTTOM: 87.12,46.48 86.36,45.72 86.36,37.84 74.99,26.48 73.72,26.48 69.46,22.22 65.78,22.22 61.84,18.29 61.84,14.98 59.3,12.44 35.68,12.44 35.05,13.08 35.05,13.59 35.43,13.97 57.53,13.97 59.18,15.62 59.18,18.92 68.19,27.94 72.39,27.94 83.56,39.11 83.56,46.48 85.21,48.13 94.48,48.13 94.74,47.88 94.74,46.73 94.48,46.48
+V3P3DSW_VAL on BOTTOM: 69.21,103.12 71.12,103.12 71.62,102.61 71.62,101.85 71.37,101.6 69.46,101.6 68.96,102.11 68.96,102.87
+V3P3DSW_VAL on LAY5: 56,182.24 53.08,182.24 52.7,181.86 52.7,175.64 54.1,174.24 54.1,169.8 54.35,169.54 56,169.54 56.13,169.67 56.13,182.12
+V3P3DSW_VAL on LAY5: 52.95,126.87 55.49,126.87 57.53,128.9 57.53,170.05 56.13,171.45 54.99,171.45 54.1,170.56 54.1,129.16 52.7,127.76 52.7,127.13
+V3P3DSW_VAL_OUT on TOP: 49.4,129.25 51.18,129.25 52.07,128.36 52.07,126.97 52.45,126.59 52.45,125.7 52.32,125.57 49.27,125.57 49.14,125.7 49.14,129
+V3P3DX_CPU_SSD2 on TOP: 156.21,219.71 156.21,222.76 156.71,223.26 165.6,223.26 165.98,222.88 165.98,220.34 166.24,220.09 169.54,220.09 170.05,220.6 170.05,222.25 166.49,225.8 152.14,225.8 150.49,224.15 150.49,219.58 150.74,219.33 155.82,219.33
+V3P3DX_CPU_SSD2 on TOP: 151.51,215.14 151.76,215.39 151.76,216.15 155.44,219.84 155.44,221.11 154.43,222.12 150.49,222.12 149.98,221.61 149.98,218.18 149.09,217.3 149.09,215.39 149.35,215.14
+V3P3DX_CPU_SSD2 on TOP: 168.91,222.5 168.91,220.85 168.78,220.72 166.37,220.72 166.11,220.47 166.11,219.45 166.24,219.33 168.52,219.33 169.03,218.82 172.21,218.82 172.33,218.95 172.33,222.12 171.83,222.63 169.03,222.63
+V3P3DX_CPU_SSD2 on LAY5: 150.36,221.36 153.54,221.36 153.92,220.98 153.92,216.41 153.28,215.77 150.24,215.77 149.98,216.03 149.98,220.98
+V3P3DX_CPU_SSD2_LS on TOP: 154.17,216.66 154.17,209.93 153.92,209.68 151.76,209.68 151.63,209.8 151.63,211.58 151.38,211.83 150.74,211.83 150.49,212.09 150.49,214.5 150.62,214.63 151.76,214.63 152.14,215.01 152.14,216.28 152.65,216.79 154.05,216.79
+V3P3DX_SDCARD on TOP: 24.51,197.23 21.71,197.23 21.33,196.85 19.17,196.85 19.05,196.72 19.05,196.21 19.17,196.09 24.51,196.09 24.63,196.21 24.63,197.1
+V3P3DX_SDCARD_LS on TOP: 25.4,197.1 27.55,197.1 27.81,196.85 27.81,196.34 27.68,196.21 27.17,196.21 27.05,196.09 25.27,196.09 25.14,196.21 25.14,196.85
+V3P3DX_V1P8DX_TCH_PNL on TOP: 12.57,178.81 11.55,178.81 11.43,178.94 11.43,179.45 11.02,179.85 9.94,179.85 9.9,179.89 9.9,180.06 9.98,180.14 11.5,180.14 11.55,180.08 11.93,180.08 12.57,179.45
+V3P3DX_V1P8DX_TCH_PNL_R on TOP: 60.96,196.85 61.34,196.85 61.72,197.23 62.61,197.23 62.86,196.98 62.86,196.21 62.61,195.96 61.97,195.96 61.34,196.59 60.96,196.59
+V3P3S on TOP: 69.34,260.73 71.24,260.73 71.5,260.48 71.5,256.03 71.37,255.9 69.34,255.9 69.08,256.16 69.08,260.48
+V3P3S on TOP: 122.17,237.87 124.33,237.87 124.58,237.62 124.58,236.22 124.46,236.09 122.17,236.09 122.04,236.22 122.04,237.74
+V3P3S on TOP: 51.3,230.12 52.19,230.12 52.45,229.87 52.45,227.71 52.19,227.46 50.29,227.46 50.16,227.58 50.16,228.22 51.18,229.23 51.18,230
+V3P3S on TOP: 43.68,78.87 43.81,78.99 43.81,80.77 43.43,81.15 40.51,81.15 40.25,80.9 40.25,79.12 40.51,78.87
+V3P3S on TOP: 274.06,275.97 277.24,275.97 277.49,275.72 277.49,274.45 277.36,274.32 274.06,274.32 273.93,274.45 273.93,275.84
+V3P3S on TOP: 247.9,272.03 248.92,272.03 249.04,271.91 249.04,270.25 248.92,270.13 247.77,270.13 247.65,270.25 247.65,271.78
+V3P3S on TOP: 177.41,77.34 178.05,76.71 179.95,76.71 180.08,76.58 180.08,71.75 180.02,71.69 180.02,71.5 179.38,70.86 173.1,70.86 171.32,69.09 171.32,67.18 171.06,66.93 170.68,66.93 170.05,66.29 170.05,42.42 167.76,40.13 163.19,40.13 160.52,42.8 160.52,58.16 164.21,61.85 164.21,69.21 167.64,72.64 167.64,75.31 170.68,78.36 177.29,78.36 177.41,78.23
+V3P3S on TOP: 157.86,217.68 159.51,217.68 159.76,217.42 159.76,213.74 159.63,213.61 159.25,213.61 158.62,212.98 157.22,212.98 156.97,213.23 156.97,214.25 157.6,214.88 157.6,217.42
+V3P3S on TOP: 30.48,230.38 31.11,230.38 31.36,230.12 31.36,228.34 31.11,228.09 30.6,228.09 29.71,228.98 28.95,228.98 28.7,229.23 28.7,230 28.82,230.12 30.22,230.12
+V3P3S on TOP: 163.57,277.87 164.84,277.87 164.97,277.75 164.97,276.6 164.21,275.84 163.57,275.84 163.44,275.97 163.44,277.75
+V3P3S on BOTTOM: 174.75,72.13 174.37,71.75 170.43,71.75 169.79,72.39 169.79,78.87 169.54,79.12 169.16,79.12 168.14,80.14 159.13,80.14 158.62,79.63 145.28,79.63 143.25,81.66 135.89,81.66 135.63,81.91 135.63,83.56 136.01,83.95 145.92,83.95 147.57,82.29 152.01,82.29 154.17,84.45 169.03,84.45 174.75,78.74
+V3P3S on BOTTOM: 276.86,278.38 284.09,278.38 284.86,277.62 284.86,273.56 285.75,272.67 288.16,272.67 293.3,267.52 293.3,265.11 293.37,265.05 293.37,257.81 294.43,256.74 294.38,256.74 294.34,256.7 296.92,254.12 296.86,254.14 296.82,254.1 299.52,251.39 299.56,251.38 299.59,251.42 299.59,251.51 299.55,251.51 299.52,251.52 299.56,251.51 299.59,251.55 299.59,241.43 303.46,237.55 303.46,222.82 303.53,222.76 303.53,130.68 303.4,130.55 302.38,130.55 300.6,132.33 296.16,132.33 293.11,129.28 293.11,124.97 296.41,121.66 300.6,121.66 301.87,122.93 303.14,122.93 303.53,122.55 303.53,108.58 301.75,106.81 301.75,92.58 301.11,91.95 293.11,91.95 291.84,93.22 291.84,95.12 292.48,95.76 297.3,95.76 299.21,97.66 299.21,115.19 297.43,116.97 297.43,118.87 291.46,124.84 291.46,132.33 294.51,135.38 294.51,160.15 297.05,162.69 297.05,193.42 301.37,197.74 301.37,202.31 300.6,203.07 300.6,205.99 301.37,206.75 301.37,212.34 298.57,215.14 298.57,220.6 296.79,222.38 296.79,245.87 285.75,256.92 285.75,264.16 275.97,273.94 275.97,277.49 ; 1 cut-out
+V3P3S on BOTTOM: 23.87,212.09 23.87,203.83 22.98,202.94 20.44,202.94 15.49,207.9 15.49,216.03 16.31,216.85 19.11,216.85
+V3P3S on BOTTOM: 246.88,272.03 249.55,272.03 249.93,271.65 249.93,267.08 249.42,266.57 247.65,266.57 247.39,266.83 247.39,268.73 246.76,269.37 246.76,271.91
+V3P3S on LAY2: outline of 381 points within 12.17,21.31 170.2,261.89 ; 13 cut-outs
+V3P3S on LAY5: 122.68,236.09 124.46,236.09 124.71,236.35 124.71,237.36 123.57,238.5 121.53,238.5 121.41,238.38 121.41,237.36
+V3P3S on LAY5: 94.36,240.41 97.28,240.41 97.66,240.03 97.66,239.27 97.4,239.01 94.61,239.01 94.1,239.52 94.1,240.16
+V3P3S on LAY5: 29.84,229.49 31.11,229.49 31.62,228.98 36.44,228.98 37.08,228.34 37.08,217.04 37.33,216.79 44.57,216.79 45.59,217.8 45.59,227.2 46.86,228.47 48.76,228.47 49.27,228.98 51.56,228.98 51.81,228.73 51.81,216.28 48.13,212.6 36.19,212.6 34.67,214.12 34.67,222.38 35.43,223.14 35.43,226.19 35.05,226.57 33.65,226.57 32.76,225.68 29.84,225.68 29.33,226.19 29.33,228.98
+V3P3S on LAY6: 155.32,215.26 158.62,215.26 159.89,213.99 159.89,212.34 158.87,211.33 158.87,209.17 157.22,207.52 157.22,202.18 158.87,200.53 158.87,195.58 156.59,193.29 156.59,180.08 156.84,179.83 156.84,175.89 157.48,175.26 157.48,173.99 157.6,173.86 157.6,169.29 157.35,169.04 157.35,168.91 156.59,168.15 156.59,165.1 157.6,164.08 157.6,162.43 155.19,160.02 155.19,153.92 154.55,153.29 154.55,152.4 152.27,150.11 151.25,150.11 150.93,150.43 150.93,151.57 150.87,151.64 150.87,155.32 151.76,156.21 151.76,162.18 152.59,163 152.59,164.65 152.9,164.97 152.9,167.77 153.79,168.65 153.79,169.29 153.41,169.67 153.41,170.69 153.79,171.07 153.79,171.24 154.56,172.01 154.58,172.01 154.58,172.37 153.79,173.16 153.79,173.61 153.47,173.93 153.47,182.82 152.78,183.51 152.78,186.18 153.79,187.2 153.79,194.56 156.08,196.85 156.08,197.86 155.06,198.88 155.06,208.79 153.28,210.56 153.28,213.23
+V3P3S on LAY6: 75.56,257.68 76.32,258.44 76.32,260.73 75.81,261.24 70.86,261.24 70.23,260.6 70.23,258.06 70.61,257.68
+V3P3S on LAY6: 287.78,95.38 293.24,95.38 293.62,94.99 293.62,91.06 282.44,79.88 282.44,78.48 281.81,77.85 280.28,77.85 279.01,79.12 270.51,79.12 265.93,74.55 247.9,74.55 243.33,79.12 216.53,79.12 203.7,91.95 192.4,91.95 191.26,90.8 182.62,90.8 176.78,84.96 176.78,73.53 174.75,71.5 170.43,71.5 168.65,73.28 168.65,87.37 177.54,96.26 201.16,96.26 201.29,96.39 205.1,96.39 213.48,88.01 249.3,88.01 258.19,79.12 264.54,79.12 271.52,86.1 278.51,86.1
+V3P3S on LAY6: 96.01,269.49 97.15,269.49 97.28,269.37 97.28,268.35 97.15,268.22 93.98,268.22 93.47,268.73 93.47,270.13 93.09,270.51 90.29,270.51 90.17,270.64 90.17,271.52 90.29,271.65 93.85,271.65 94.36,271.14 95.12,271.14 95.75,270.51 95.75,269.75
+V3P3S on LAY6: 163.7,278 164.84,278 164.97,277.87 164.97,276.22 164.84,276.1 163.83,276.1 163.57,276.35 163.57,277.87
+V3P3S on LAY6: 135.89,83.82 137.28,83.82 137.79,83.31 137.79,80.9 137.6,80.71 135.31,80.71 134.11,81.91 134.11,82.42 134.36,82.68 135.25,82.68 135.63,83.06 135.63,83.56
+V3P3S on LAY6: 247.77,272.41 250.82,272.41 251.96,273.56 267.84,273.56 268.98,274.7 271.9,274.7 273.17,275.97 277.36,275.97 278.25,275.08 278.25,270.76 277.55,270.06 276.28,270.06 276.22,270 268.6,270 268.09,270.51 268.09,270.89 267.71,271.27 254.76,271.27 254.25,270.76 247.9,270.76 247.52,271.14 247.52,272.16 ; 1 cut-out
+V3P3S on LAY6: 129.15,32.51 130.42,32.51 130.93,32 130.93,28.7 121.66,19.43 119.25,19.43 118.87,19.81 118.87,23.24 122.68,27.05 127.12,27.05 128.9,28.83 128.9,32.26
+V3P3S on LAY6: 298.95,133.73 303.27,133.73 303.53,133.48 303.53,120.65 303.14,120.27 302.38,120.27 298.06,124.59 298.06,132.84
+V3P3S on LAY6: 145.16,134.24 143.51,134.24 141.98,132.71 141.98,129.67 143.19,128.46 143.19,125.67 139.63,122.11 138.23,122.11 135.12,119 133.09,119 132.71,118.62 132.71,114.81 132.96,114.55 134.23,114.55 136.27,116.58 138.68,116.58 146.68,124.59 146.68,130.68 146.11,131.25 146.11,133.29
+V3P3S_ALS on TOP: 250.31,271.02 250.82,270.51 253.11,270.51 254.12,269.49 254.12,268.6 254,268.48 252.98,268.48 252.09,269.37 249.93,269.37 249.68,269.11 248.92,269.11 248.66,268.86 248.66,265.68 248.53,265.56 248.03,265.56 247.9,265.68 247.9,266.57 247.14,267.33 247.14,268.98 248.15,270 249.3,270 249.42,270.13 249.42,271.02
+V3P3S_DDI1_DP_OB_FUSE on TOP: 277.11,283.21 279.52,283.21 279.78,282.95 279.78,278.13 279.52,277.87 279.52,277.24 279.4,277.11 277.87,277.11 276.86,278.13 276.86,282.95
+V3P3S_DDIA_OB_DP on TOP: 270.25,283.34 275.33,283.34 275.59,283.08 275.59,280.29 275.33,280.03 273.43,280.03 271.78,278.38 270.12,278.38 269.87,278.64 269.87,282.95
+V3P3S_DP1_PWR on TOP: 274.82,277.87 276.86,277.87 277.36,277.37 277.36,276.86 277.24,276.73 274.82,276.73 274.7,276.86 274.7,277.75
+V3P3S_DP_EMB on TOP: 298.95,228.85 299.08,228.73 299.08,226.57 298.83,226.31 296.29,226.31 292.48,222.5 292.48,221.74 291.97,221.23 289.68,221.23 289.36,221.55 289.36,226.5 290.44,227.58 290.44,228.47 290.83,228.85
+V3P3S_DP_EMB_AUXPWR on TOP: 291.97,242.06 291.97,243.33 292.1,243.46 292.6,243.46 292.73,243.33 292.73,242.31 293.11,241.93 295.4,241.93 296.41,240.92 298.83,240.92 298.95,240.79 298.95,240.54 298.7,240.28 295.91,240.28 295.14,241.04 292.98,241.04
+V3P3S_PCIE_SLOT2 on TOP: 59.43,242.19 64.26,242.19 65.02,241.43 65.02,237.36 64.77,237.11 64.13,237.11 63.5,237.74 58.92,237.74 58.29,238.38 53.21,238.38 52.95,238.12 52.95,233.93 52.7,233.68 50.54,233.68 48,236.22 48,240.03 48.38,240.41 56.76,240.41 57.53,241.17 58.42,241.17
+V3P3S_PCIE_SLOT2_R on TOP: 52.32,230.63 52.07,230.38 51.3,230.38 51.18,230.5 51.18,231.52 50.8,231.9 50.8,232.79 50.92,232.92 52.19,232.92 52.32,232.79
+V3P3S_PCIE_SLOT3 on TOP: 30.09,235.84 33.65,239.39 35.05,239.39 35.68,238.76 38.1,238.76 39.87,236.98 44.57,236.98 44.83,237.23 44.83,238.5 42.29,241.04 35.81,241.04 35.56,240.79 33.02,240.79 32.76,241.04 28.06,241.04 27.17,240.16 27.17,235.71 27.94,234.95 27.94,233.68 28.19,233.42 29.84,233.42 30.09,233.68 ; 1 cut-out
+V3P3S_PCIE_SLOT3_R on TOP: 28.57,232.92 28.44,232.79 28.44,231.65 28.82,231.27 28.82,230.5 28.95,230.38 29.84,230.38 29.97,230.5 29.97,232.79 29.84,232.92
+V3P3S_PCON on BOTTOM: 241.04,267.97 245.23,267.97 245.87,268.6 246.76,268.6 247.14,268.22 247.14,266.7 246.63,266.19 245.23,266.19 245.11,266.32 245.11,266.95 244.98,267.08 242.31,267.08 241.8,266.57 241.04,266.57 240.91,266.7 240.91,267.84
+V3P3S_PCON_AVDD on BOTTOM: 243.84,268.35 245.11,268.35 245.49,268.73 245.49,270.64 243.33,272.79 241.3,272.79 240.91,272.41 240.91,269.87 241.17,269.62 242.57,269.62
+V3P3S_PCON_AVDD on LAY6: 242.69,265.56 243.71,265.56 244.22,266.06 244.22,270.25 243.96,270.51 241.3,270.51 240.91,270.13 240.91,269.62 241.3,269.24 242.69,269.24 242.95,268.98 242.95,266.7 242.44,266.19 242.44,265.81
+V3P3S_PEG_SLOT on TOP: 125.22,238 125.73,237.49 127.88,237.49 129.28,236.09 132.46,236.09 133.73,237.36 133.73,238.63 134.36,239.27 136.65,239.27 137.28,238.63 139.57,238.63 140.2,238 144.52,238 146.81,235.71 148.97,235.71 149.22,235.96 149.22,236.73 148.97,236.98 147.95,236.98 146.05,238.89 145.41,238.89 144.71,239.58 143.82,239.58 143.12,240.28 133.73,240.28 132.84,241.17 125.6,241.17 125.22,240.79
+V3P3S_PEG_SLOT_R on TOP: 122.04,239.01 122.04,238.25 122.17,238.12 124.46,238.12 124.71,238.38 124.71,239.77 124.58,239.9 122.93,239.9
+V3P3S_R on TOP: 181.61,75.31 185.67,75.31 186.05,74.93 186.05,73.66 188.21,71.5 188.21,67.44 188.84,66.8 223.77,66.8 225.93,68.96 228.34,68.96 228.72,68.58 228.72,64.13 228.34,63.75 185.03,63.75 182.88,61.59 178.94,61.59 178.56,61.97 178.56,68.45 181.35,71.25 181.35,75.06
+V3P3S_VAL on TOP: 204.85,80.9 206.5,80.9 206.75,80.64 206.75,79.12 206.24,78.61 206.24,73.66 206.12,73.53 204.85,73.53 204.59,73.79 204.59,80.64
+V3P3S_VAL on BOTTOM: 205.48,87.25 235.07,87.25 237.87,84.45 237.87,82.68 235.2,80.01 204.85,80.01 204.59,80.26 204.59,86.36
+V5.0DX_SSD on TOP: 107.69,8.51 107.69,6.73 107.82,6.6 108.58,6.6 109.09,7.11 110.99,7.11 111.25,7.36 111.25,8.51 110.99,8.76 107.95,8.76
+V5.0DX_SSD on TOP: 123.31,7.62 123.31,4.82 123.44,4.7 125.22,4.7 125.34,4.82 125.34,7.62 125.09,7.87 123.57,7.87
+V5.0DX_SSD on BOTTOM: 125.6,6.48 125.6,8.13 123.69,10.03 110.74,10.03 110.68,9.97 109.79,9.97 109.22,9.4 109.22,7.24 109.47,6.98 118.49,6.98 119.25,7.75 120.52,7.75 120.65,7.62 120.65,6.09 121.03,5.71 124.96,5.71 125.34,5.33 125.34,4.7 125.6,4.44 127,4.44 127.12,4.57 127.12,5.59 127,5.71 126.36,5.71
+V5_AUDIO on TOP: 111.25,285.88 113.66,285.88 113.91,286.13 113.91,289.18 113.79,289.3 100.83,289.3 99.56,288.03 99.56,287.15 100.45,286.26 102.48,286.26 104.01,287.78 110.49,287.78 111.12,287.15 111.12,286
+V5_AUDIO on LAY5: 21.59,274.95 24.13,274.95 24.51,274.57 24.51,273.56 28.06,270 28.06,269.24 27.81,268.98 24.38,268.98 24.32,269.05 23.68,269.05 23.17,269.56 23.17,270.19 20.32,273.05 20.32,273.68
+V5_AUDIO on LAY5: 99.69,288.16 100.07,288.16 101.47,286.76 101.47,286.51 101.21,286.26 100.45,286.26 99.56,287.15 99.56,288.03
+V5_AUDIO_R on TOP: 107.06,285.88 110.49,285.88 110.61,286 110.61,287.02 110.23,287.4 107.06,287.4 106.93,287.27 106.93,286
+V5A on TOP: 186.18,205.1 186.18,203.96 186.43,203.71 186.43,202.69 187.07,202.69 187.19,202.82 187.19,204.98 187.07,205.1
+V5A on TOP: 57.02,85.09 54.99,85.09 54.73,84.83 54.73,83.56 55.11,83.18 57.02,83.18 57.27,83.44 57.27,84.83
+V5A on TOP: 181.1,202.82 181.22,202.69 181.99,202.69 182.11,202.82 182.11,204.6 181.86,204.85 181.86,205.61 181.73,205.74 181.22,205.74 181.1,205.61
+V5A on BOTTOM: 257.55,250.7 258.44,250.7 258.95,250.19 258.95,249.17 258.82,249.05 257.55,249.05 257.42,249.17 257.42,250.57
+V5A on BOTTOM: 30.35,187.07 31.87,187.07 35.94,183.01 45.84,183.01 50.16,178.69 50.16,176.27 49.91,176.02 47.75,176.02 47.62,176.15 47.62,177.8 46.99,178.43 45.72,178.43 43.18,180.97 34.54,180.97 30.22,185.29 30.22,186.94
+V5A on BOTTOM: 32.63,246.63 34.03,246.63 34.41,246.25 34.41,243.97 32.51,242.06 32.51,238.63 30.22,236.35 30.22,230.63 28.19,228.6 27.05,228.6 26.41,229.23 26.41,233.93 28.57,236.09 28.57,240.28 31.24,242.95 31.24,245.11 32.63,246.51
+V5A on LAY5: 107.56,237.23 121.03,237.23 121.53,236.73 121.53,235.58 121.15,235.2 107.06,235.2 106.17,236.09 106.17,238.38 106.29,238.5
+V5A on LAY5: 137.16,245.36 139.7,247.9 146.3,247.9 148.59,245.62 148.97,245.62 149.6,244.98 153.54,244.98 154.05,244.47 155.32,244.47 156.21,243.58 156.21,234.44 156.97,233.68 156.97,231.01 156.71,230.76 153.92,230.76 152.97,231.71 152.97,232.92 152.52,233.36 152.52,234.19 153.16,234.82 153.16,237.23 152.52,237.87 152.14,237.87 151,239.01 151,239.65 151.51,240.16 151.51,241.04 151,241.55 147.95,241.55 146.43,243.08 146.43,243.71 146.3,243.84 140.33,243.84 139.7,243.2 137.66,243.2 137.16,243.71
+V5A on LAY5: 209.8,249.43 209.93,249.55 217.42,249.55 218.05,248.92 222.63,248.92 223.01,248.54 223.9,248.54 224.28,248.92 233.8,248.92 234.18,249.3 234.18,249.55 234.31,249.68 240.41,249.68 241.3,248.79 256.66,248.79 257.55,249.68 267.2,249.68 268.35,248.54 271.01,248.54 272.03,247.52 272.03,239.65 264.66,232.28 264.66,231.27 263.65,230.25 263.65,217.04 260.85,214.25 251.07,214.25 249.68,212.85 249.68,211.45 248.41,210.18 248.03,210.18 247.77,210.44 247.77,214.76 249.3,216.28 250.69,216.28 257.42,223.01 257.42,227.58 270.25,240.41 270.25,246.63 269.87,247.01 264.79,247.01 264.54,247.27 264.41,247.14 263.77,247.14 262.25,248.66 259.71,248.66 258.44,247.39 236.6,247.39 236.34,247.65 214.37,247.65 213.99,248.03 213.61,248.03 213.1,247.52 210.43,247.52 209.8,248.16
+V5A on LAY5: 57.4,101.22 57.34,101.28 57.34,104.84 52.83,109.35 52.83,122.43 50.41,124.84 50.41,171.96 49.91,172.46 49.91,177.04 48.64,178.31 47.75,178.31 45.46,176.02 45.46,119.63 48.26,116.84 48.26,90.8 51.94,87.12 51.94,84.07 52.95,83.06 57.02,83.06 57.4,83.44
+V5A on LAY5: 33.65,247.27 44.57,247.27 45.46,246.38 52.07,246.38 53.97,248.28 67.56,248.28 70.73,245.11 70.73,244.09 73.27,241.55 73.27,240.41 72.77,239.9 69.97,239.9 67.69,242.19 67.69,244.98 66.29,246.38 63.88,246.38 62.99,245.49 59.56,245.49 58.42,246.63 55.24,246.63 52.19,243.58 43.68,243.58 42.79,242.7 38.86,242.7 37.97,243.58 33.14,243.58 32.51,244.22 32.51,246.12
+V5A on LAY5: 187.7,207.9 190.5,207.9 190.75,207.64 190.75,203.58 189.99,202.82 186.05,202.82 185.8,203.07 185.8,204.34 186.05,204.6 187.19,204.6 187.45,204.85 187.45,207.64
+V5A on LAY5: 27.17,230.88 28.44,230.88 28.7,230.63 28.7,213.99 24.51,209.8 24.51,199.77 26.54,197.74 26.54,193.29 28.44,191.39 28.44,188.09 29.08,187.45 32.25,187.45 32.51,187.2 32.51,185.55 31.87,184.91 26.67,184.91 22.98,188.59 22.98,226.69
+V5A on LAY6: 195.96,209.93 192.78,206.75 190.11,206.75 186.94,203.58 186.05,203.58 185.8,203.83 185.8,205.1 189.1,208.41 191.26,208.41 194.43,211.58 249.17,211.58 249.3,211.45 249.3,211.07 248.15,209.93
+V5A_R on TOP: 51.56,84.83 53.84,84.83 54.1,84.58 54.1,81.53 53.97,81.41 51.56,81.41 51.43,81.53 51.43,84.71
+V5DSW on TOP: 49.65,86.23 49.65,83.06 49.53,82.93 47.49,82.93 47.37,83.06 47.11,83.06 46.48,83.69 46.48,86.49 46.6,86.61 49.27,86.61
+V5DSW on TOP: 178.18,83.56 180.84,83.56 181.1,83.31 181.1,82.93 181.61,82.41 181.61,80.45 181.17,80.01 178.3,80.01 178.05,80.26 178.05,83.44
+V5DSW on TOP: 214.75,78.99 216.53,78.99 216.78,78.74 216.78,78.36 216.28,77.85 216.28,77.09 216.02,76.83 215.26,76.83 215.01,76.58 215.01,75.56 214.12,74.67 211.7,74.67 210.56,73.53 207.13,73.53 206.62,74.04 206.62,78.48 207.26,79.12 214.63,79.12
+V5DSW on TOP: 46.73,98.8 46.48,99.06 44.19,99.06 44.06,98.93 44.06,97.03 44.45,96.65 46.48,96.65 46.73,96.9
+V5DSW on LAY2: outline of 151 points within 43.66,53.18 212.62,101.68 ; 13 cut-outs
+V5DSW on LAY6: 31.62,193.42 32.76,193.42 33.14,193.04 33.14,186.05 32.76,185.67 31.62,185.67 31.11,186.18 31.11,192.91
+V5DSW_R on TOP: 45.28,165.98 45.28,164.46 45.16,164.33 44.19,164.33 43.56,163.7 43.3,163.7 42.92,164.08 42.92,165.86 43.43,166.37 44.9,166.37
+V5DSW_R on TOP: 43.61,147.95 44.7,147.95 45.26,147.39 45.26,146.17 45.13,146.04 43.61,146.04 43.48,146.17 43.48,147.82
+V5DSW_R on TOP: 43.56,129.76 44.95,129.76 45.21,129.51 45.21,127.98 45.08,127.86 43.56,127.86 43.43,127.98 43.43,129.63
+V5DSW_R on TOP: 214.37,73.79 216.53,73.79 216.78,73.53 216.78,67.31 216.66,67.18 212.97,67.18 211.45,68.71 211.45,74.04 211.58,74.17 212.09,74.17 212.34,73.91 214.24,73.91 ; 1 cut-out
+V5DSW_R on TOP: 45.23,136.87 45.11,136.75 43.08,136.75 42.67,137.16 42.67,139.06 43.05,139.44 44.7,139.44 45.23,138.91
+V5DSW_R on TOP: 45.23,155.31 45.11,155.19 43.58,155.19 43.45,155.31 43.45,157.76 43.56,157.86 44.95,157.86 45.23,157.58
+V5DSW_R on LAY2: outline of 250 points within 29.81,36.58 220.24,170.58 ; 2 cut-outs
+V5DSW_R on LAY5: 44.83,165.99 44.45,166.37 42.54,166.37 41.91,165.73 41.91,148.46 42.29,148.08 42.29,138.05 43.56,136.78 44.32,136.78 44.83,137.29
+V5DSW_R1 on TOP: 50.54,88.52 52.32,88.52 52.45,88.39 52.45,85.47 52.32,85.34 50.41,85.34 50.29,85.47 50.29,88.26
+V5DSW_R2 on TOP: 49.53,99.31 49.53,100.71 49.4,100.84 47.62,100.84 47.11,100.33 47.11,97.92 47.24,97.79 48,97.79 49.02,96.77 49.91,96.77 50.03,96.9 50.03,97.79 50.16,97.92 50.16,98.68
+V5DUAL on TOP: 134.74,276.86 135,276.86 135.38,277.24 135.76,277.24 136.65,276.35 136.65,273.43 136.39,273.18 135.25,273.18 135.19,273.24 134.68,273.24 134.49,273.43 134.49,276.6
+V5DUAL on TOP: 108.96,239.77 111.25,239.77 111.63,240.16 111.63,243.08 111.25,243.46 108.07,243.46 105.15,240.54 99.94,240.54 97.4,238 97.4,231.27 98.17,230.5 101.34,230.5 101.98,229.87 101.98,219.2 101.47,218.69 99.06,218.69 96.39,216.03 96.39,215.01 95.12,213.74 91.82,213.74 88.26,210.18 88.26,207.9 88.51,207.64 94.23,207.64 104.52,217.93 104.52,229.61 108.2,233.3 108.2,239.01
+V5DUAL on TOP: 187.57,88.64 194.05,88.64 194.43,88.26 194.43,85.34 193.29,84.2 193.29,82.42 193.04,82.17 188.59,82.17 187.45,83.31 187.45,88.52
+V5DUAL on TOP: 275.46,258.95 276.73,258.95 276.86,258.82 276.86,257.3 276.73,257.17 275.46,257.17 275.33,257.3 275.33,258.82
+V5DUAL on TOP: 230.25,279.65 232.53,279.65 232.66,279.53 232.66,276.86 232.41,276.6 230.12,276.6 229.99,276.73 229.99,279.4
+V5DUAL on TOP: 199.64,276.48 201.04,276.48 201.29,276.22 201.29,274.06 201.16,273.94 199.51,273.94 199.39,274.06 199.39,276.22
+V5DUAL on TOP: 129.92,208.28 134.36,208.28 134.74,207.9 137.28,207.9 137.41,207.77 137.41,205.48 137.16,205.23 134.74,205.23 134.11,205.87 130.17,205.87 129.66,206.37 129.66,208.02
+V5DUAL on TOP: 162.17,214.88 160.4,214.88 160.14,215.14 160.14,217.42 160.27,217.55 162.05,217.55 162.43,217.17 162.43,215.14
+V5DUAL on TOP: 104.77,6.35 106.8,6.35 106.93,6.22 106.93,4.82 107.95,3.81 110.61,3.81 112.64,5.84 114.68,5.84 116.33,4.19 139.06,4.19 139.7,3.55 147.06,3.55 150.62,7.11 168.52,7.11 170.05,5.59 170.05,1.27 169.29,0.51 106.55,0.51 105.66,1.4 105.66,4.32 105.41,4.57 104.9,4.57 104.64,4.82 104.64,6.22
+V5DUAL on TOP: 137.54,109.47 138.81,109.47 138.93,109.6 138.93,111.76 138.68,112.01 137.54,112.01 137.41,111.89 137.41,109.6
+V5DUAL on TOP: 190.62,87.12 190.62,86.87 189.86,86.1 188.34,86.1 186.81,87.63 172.46,87.63 171.45,86.61 161.41,86.61 161.29,86.74 161.29,88.77 162.81,90.3 164.84,90.3 165.35,90.8 168.65,90.8 169.54,91.69 187.45,91.69 187.51,91.63 188.27,91.63 191.38,88.52 191.38,87.88
+V5DUAL on TOP: 106.93,285.49 110.49,285.49 110.61,285.37 110.61,283.97 110.49,283.84 107.18,283.84 106.93,284.1
+V5DUAL on TOP: 81.91,21.97 81.91,19.81 82.16,19.56 85.21,19.56 85.59,19.94 85.59,22.22 85.21,22.6 82.55,22.6
+V5DUAL on TOP: 68.32,39.88 68.45,39.75 68.45,37.46 68.32,37.34 66.8,37.34 66.67,37.46 66.67,39.75 66.8,39.88
+V5DUAL on TOP: 275.59,83.18 278.76,83.18 279.01,82.93 279.01,81.79 280.03,80.77 280.03,77.34 278.89,76.2 278.89,74.17 278.63,73.91 273.81,73.91 273.17,74.55 273.17,79.37 275.46,81.66 275.46,83.06
+V5DUAL on TOP: 0.51,287.1 1.29,289.63 3.35,291.28 3.42,291.21 8.5,291.21 9.01,290.7 9.01,281.68 8.5,281.18 4.82,281.18 3.68,280.03 3.68,13.84 13.71,3.81 65.78,3.81 66.16,3.43 66.16,1.52 65.15,0.51 5,0.51 1.82,1.82 0.51,5
+V5DUAL on BOTTOM: 0.51,287.1 1.24,289.55 3.19,291.21 111.63,291.21 114.3,288.54 114.3,280.54 113.41,279.65 109.6,279.65 106.29,282.95 101.85,282.95 97.91,286.89 15.62,286.89 2.54,273.81 2.54,11.68 10.41,3.81 64.51,3.81 66.54,5.84 66.54,7.75 67.43,8.63 67.43,10.92 66.42,11.94 66.42,17.02 68.19,18.79 74.67,18.79 76.2,20.32 83.18,20.32 85.59,17.91 105.53,17.91 108.58,14.86 108.58,7.24 109.22,6.6 117.09,6.6 120.01,3.68 147.06,3.68 153.92,10.54 170.56,10.54 171.7,9.4 171.7,1.78 171.19,1.27 67.31,1.27 67.31,0.51 5,0.51 1.82,1.82 0.51,5
+V5DUAL on LAY2: outline of 203 points within 127.22,82.65 194.58,219.6 ; 9 cut-outs
+V5DUAL on LAY2: outline of 149 points within 1.24,1.24 170.58,290.85 ; 11 cut-outs
+V5DUAL on LAY5: 149.47,6.09 170.18,6.09 171.57,4.7 171.57,0.89 171.19,0.51 103.88,0.51 103.5,0.89 103.5,3.94 104.77,5.21 111.63,5.21 112.14,5.71 116.71,5.71 117.72,4.7 126.49,4.7 127.63,3.55 146.93,3.55 ; 1 cut-out
+V5DUAL on LAY6: 146.43,6.98 170.68,6.98 171.83,5.84 171.83,0.51 108.83,0.51 108.83,4.44 109.6,5.21 109.6,5.33 111.5,5.33 112.52,6.35 126.23,6.35 127,5.59 145.03,5.59
+V5DUAL on LAY6: 176.78,290.83 227.33,290.83 228.21,289.94 228.21,287.27 231.2,284.29 231.2,282.89 232.79,281.3 232.79,276.22 233.99,275.02 243.39,275.02 247.77,270.64 252.85,270.64 254,269.49 257.3,269.49 258.57,270.76 266.95,270.76 268.22,269.49 277.49,269.49 278.51,268.48 278.51,258.06 277.62,257.17 275.71,257.17 275.46,257.43 275.46,263.27 271.78,266.95 268.22,266.95 266.31,268.86 260.35,268.86 259.46,267.97 249.3,267.97 248.03,269.24 245.49,269.24 242.69,272.03 232.02,272.03 227.96,276.1 227.96,282.32 227.2,283.08 211.45,283.08 204.53,276.16 201.99,276.16 200.78,274.95 198.5,274.95 197.61,274.06 192.53,274.06 192.4,273.94 181.73,273.94 179.89,275.78 177.35,275.78 174.62,273.05 164.59,273.05 164.33,273.3 164.33,273.81 165.22,274.7 165.22,277.62 165.6,278 169.67,278 172.84,281.18 172.84,282.32 175.38,284.86 175.38,289.43 ; 2 cut-outs
+V5DUAL on LAY6: 0.51,287.1 1.82,290.28 5,291.59 12.69,291.59 13.33,290.96 13.33,286 7.87,280.54 5.08,280.54 3.17,278.64 3.17,9.02 5.96,6.22 21.2,6.22 24.63,2.79 39.62,2.79 42.16,5.33 64,5.33 64.77,4.57 64.77,0.51 5,0.51 1.82,1.82 0.51,5
+V5DUAL on LAY6: 205.61,88.9 184.78,88.9 183.51,87.63 183.51,81.66 182.37,80.52 182.37,78.23 183.38,77.21 192.91,77.21 193.42,76.71 193.42,72.9 189.99,69.47 181.73,69.47 174.24,61.97 174.24,54.86 169.92,50.54 161.79,50.54 160.4,49.15 160.4,16.13 150.11,5.84 157.22,5.84 161.29,1.78 169.67,1.78 171.95,4.06 171.95,36.96 192.15,57.15 194.94,57.15 197.48,59.69 210.94,59.69 213.23,61.97 247.01,61.97 253.17,68.13 280.73,68.13 282.32,69.72 282.32,77.09 281.94,77.47 280.28,77.47 279.01,78.74 270.76,78.74 266.06,74.04 247.39,74.04 242.82,78.61 215.9,78.61 ; 12 cut-outs
+V5DUAL on LAY8: 3.17,290.57 8.12,290.57 8.5,290.19 8.5,236.47 5.33,233.3 5.33,231.77 7.23,229.87 7.23,16.64 12.31,11.56 12.31,2.03 11.43,1.14 3.81,1.14 1.14,3.81 1.14,288.54 ; 8 cut-outs
+V5DUAL_USB2_BP1 on TOP: 228.85,276.22 232.91,276.22 233.55,275.59 233.55,272.67 233.42,272.54 225.67,272.54 223.13,275.08 223.13,276.35 223.39,276.6 228.47,276.6
+V5DUAL_USB2_BP1 on LAY6: 217.8,276.1 227.2,276.1 227.71,275.59 227.71,274.06 227.2,273.56 220.72,273.56 218.56,271.4 217.67,271.4 217.42,271.65 217.42,275.72
+V5DUAL_USB2_FP on TOP: 77.97,213.74 77.97,212.09 77.85,211.96 77.85,209.8 78.1,209.55 83.56,209.55 85.09,208.02 86.48,208.02 86.74,208.28 86.74,213.87 85.72,214.88 85.72,216.79 85.09,217.42 82.55,217.42 79.12,213.99 78.23,213.99
+V5DUAL_USB31_BP0 on TOP: 227.58,285.37 231.64,285.37 232.02,284.99 232.02,283.08 232.66,282.45 232.66,281.18 232.41,280.92 223.9,280.92 223.39,281.43 223.39,283.72 222.63,284.48 222.63,286 222.75,286.13 225.93,286.13 226.31,285.75 227.2,285.75
+V5DUAL_USB31_BP0 on LAY6: 217.8,282.57 227.2,282.57 227.58,282.19 227.58,280.8 224.66,277.87 217.8,277.87 217.42,278.26 217.42,282.19
+V5DUAL_USB31_BP2 on TOP: 202.43,286.26 202.81,286.64 203.58,286.64 203.7,286.51 203.7,284.86 205.74,282.83 205.74,277.37 205.1,276.73 199.51,276.73 199.13,277.11 199.13,286 199.39,286.26
+V5DUAL_USB31_BP2 on LAY5: 193.16,282.45 195.58,282.45 198.88,285.75 202.69,285.75 203.32,285.11 203.32,280.54 200.53,277.75 190.88,277.75 190.37,278.26 190.37,282.83 190.88,283.34 192.27,283.34
+V5DUAL_USB31_FP1 on TOP: 129.66,205.61 133.73,205.61 133.98,205.36 133.98,200.79 133.35,200.15 129.54,200.15 128.65,201.04 128.65,201.67 125.85,204.47 123.82,204.47 123.44,204.85 123.44,206.37 123.82,206.75 128.52,206.75
+V5DUAL_USB31_FP1 on TOP: 106.42,194.25 107.69,194.25 107.82,194.13 107.82,191.59 107.56,191.33 106.68,191.33 106.42,191.59
+V5DUAL_USB31_FP1 on TOP: 99.44,187.65 100.07,187.65 100.2,187.52 100.2,186.13 100.71,185.62 100.71,184.6 100.58,184.47 99.18,184.47 99.06,184.6 99.06,187.27
+V5DUAL_USB31_FP1 on LAY5: 112.01,203.33 114.17,203.33 114.3,203.45 114.3,207.14 113.53,207.9 107.18,207.9 98.36,199.07 98.36,185.86 99.18,185.04 100.71,185.04 101.09,185.42 101.09,187.7 103.25,189.86 105.28,189.86 108.33,192.91 108.33,199.64
+V5DUAL_USB31_FP1 on LAY6: 122.93,206.63 125.34,206.63 125.73,206.25 125.73,203.96 124.33,202.56 113.03,202.56 112.01,203.58 112.01,205.74 112.26,205.99 116.58,205.99 116.96,205.61 121.92,205.61
+V5DUAL_USB31_FP2 on TOP: 111.12,235.08 111.25,235.2 111.25,235.58 111.63,235.96 115.44,235.96 115.44,233.3 114.8,232.66 109.6,232.66 108.83,233.42 108.83,234.95 108.96,235.08
+V5DUAL_USB31_FP2 on TOP: 109.22,239.14 115.18,239.14 115.44,238.89 115.44,235.58 114.93,235.08 111.25,235.08 111.25,236.73 110.74,237.23 109.09,237.23 108.96,237.36 108.96,238.89
+V5DUAL_USB31_FP2 on LAY5: 112.26,233.04 109.98,233.04 109.34,232.41 107.95,232.41 107.31,231.77 107.31,227.46 108.71,226.06 111.63,226.06 112.64,227.07 112.64,232.66
+V5DUAL_USBC on TOP: 137.16,266.06 139.19,266.06 139.31,265.94 139.31,265.56 139.19,265.43 138.43,265.43 137.73,264.73 137.09,264.73 136.9,264.92 136.9,265.81
+V5DUAL_USBC on TOP: 139.95,274.45 140.2,274.19 140.2,272.54 139.31,271.65 139.31,269.62 139.19,269.49 138.68,269.49 137.54,270.64 137.54,274.45
+V5DUAL_USBC on BOTTOM: 137.79,272.79 139.19,272.79 140.08,271.91 144.01,271.91 144.14,271.78 144.14,262.63 144.01,262.51 140.71,262.51 138.68,264.54 137.16,264.54 136.9,264.79 136.9,267.46 137.66,268.22 137.66,272.67
+V5DX_AUDIO_FIL on TOP: 116.2,287.78 119.25,287.78 119.38,287.65 119.38,286.26 119.12,286 116.2,286 115.95,286.26 115.95,287.53
+V5DX_AUDIO_FIL on BOTTOM: 116.84,275.59 116.84,273.43 116.96,273.3 117.98,273.3 120.14,275.46 120.14,276.48 119.25,277.37 119.25,282.45 119.88,283.08 119.88,285.37 121.53,287.02 122.3,287.02 122.55,287.27 122.55,288.54 122.3,288.8 118.36,288.8 117.85,288.29 117.85,276.22 117.47,275.84 117.09,275.84
+V5DX_SSD_LS on TOP: 104.64,8 104.64,6.73 104.77,6.6 106.68,6.6 106.8,6.73 106.8,8.51 106.68,8.63 105.28,8.63
