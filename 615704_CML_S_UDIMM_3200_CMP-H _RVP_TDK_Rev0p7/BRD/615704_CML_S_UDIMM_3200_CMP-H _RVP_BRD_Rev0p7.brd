# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DATA_B<5>: length 112.5
  TOP w0.088: J1F2.148 280.22,105.78 280.37,105.64 280.37,105.48 280.28,105.39 280.06,105.39 279.97,105.3 279.97,105.17 280.05,105.1 280.33,105.1 280.4,105.02 280.4,104.89 280.31,104.8 280.19,104.8 280.1,104.71 v1(280.1,103.93) 279.55,103.23 279.55,102.76 280,100.97 J1F3.148
  TOP w0.165: v3(237.24,176.69) J3D1.AD35
  LAY9 w0.088: 244.32,177.95 241.69,177.95 241.48,178.15 241.19,178.15 241.06,178.02 240.73,178.02 240.6,178.15 240.28,178.15 240.15,178.02 239.82,178.02 239.69,178.15 239.4,178.15 239.23,177.99 237.93,177.99 237.72,177.78 237.72,177.08 237.32,176.69 v3(237.24,176.69)
  LAY9 w0.089: 244.32,177.95 244.71,177.56 249.82,177.56 260.02,167.37 260.02,162.73 275.11,147.64 275.11,136.55 276.61,135.05 276.61,132.04 276.65,132 276.65,131.87 276.61,131.83 276.61,131.17 277.46,130.32 277.46,128.97 278.31,128.12 278.31,127.55 277.88,127.12 277.88,125.99 278.3,125.57 278.3,123.12 277.86,122.68 277.86,121.82 278.3,121.38 278.3,119.82 277.7,119.22 277.7,115.03 278.31,114.42 278.31,112.98 279.16,112.13 279.16,110.78 280.01,109.93 280.01,109.39 279.55,108.93 279.55,107.77 280.1,107.21 v1(280.1,103.93)
M_DATA_B<6>: length 110.5
  TOP w0.088: J1F2.10 274.9,109.41 274.48,108.32 274.48,107.8 v1(275.03,107.13) 274.93,106.79 274.93,106.12 275.09,105.96 275.09,105.82 275,105.73 274.7,105.73 274.61,105.64 274.61,105.47 274.7,105.38 274.86,105.38 274.95,105.29 274.95,105.16 274.89,105.1 274.89,104.27 274.73,104.1 274.73,103.92 J1F3.10
  TOP w0.165: v3(238.15,174.73) J3D1.AF36
  LAY9 w0.088: v3(238.15,174.73) 238.38,174.73 238.88,175.23 241.4,175.23 241.79,174.84 242.12,174.84 242.24,174.96 243,174.96
  LAY9 w0.089: 243,174.96 243.37,174.58 248.82,174.58 257.2,166.2 257.2,161.57 271.84,146.92 271.84,146.47 271.93,146.38 272.21,146.38 272.3,146.29 272.3,145.83 272.21,145.74 271.93,145.74 271.84,145.66 271.84,145.2 271.93,145.11 272.21,145.11 272.3,145.02 272.3,144.57 272.21,144.48 271.93,144.48 271.84,144.39 271.84,143.93 271.93,143.84 272.21,143.84 272.3,143.75 272.3,143.3 272.21,143.21 271.93,143.21 271.84,143.12 271.84,142.66 271.93,142.57 272.21,142.57 272.3,142.49 272.3,142.03 272.21,141.94 271.93,141.94 271.84,141.85 271.84,141.4 271.93,141.31 272.21,141.31 272.3,141.22 272.3,140.76 272.21,140.67 271.93,140.67 271.84,140.58 271.84,140.13 271.93,140.04 272.21,140.04 272.3,139.95 272.3,139.49 272.21,139.41 271.93,139.41 271.84,139.32 271.84,138.86 271.93,138.77 272.21,138.77 272.3,138.68 272.3,138.23 272.21,138.14 271.93,138.14 271.84,138.05 271.84,137.59 271.93,137.5 272.21,137.5 272.3,137.41 272.3,136.96 272.21,136.87 271.93,136.87 271.84,136.78 271.84,136.32 271.93,136.24 272.21,136.24 272.3,136.15 272.3,135.69 272.21,135.6 271.82,135.6 271.69,135.47 271.69,133.6 271.78,133.51 272.21,133.51 272.3,133.42 272.3,132.96 272.21,132.87 271.84,132.87 271.75,132.78 271.75,132.44 271.93,132.27 271.93,131.39 272.78,130.54 272.78,129.79 273.63,128.94 273.63,127.37 272.78,126.52 272.78,125.99 273.61,125.16 273.61,123.4 272.76,122.55 272.76,122.02 273.61,121.17 273.61,119.6 273.14,119.13 273.14,119.13 272.76,118.75 272.76,118.47 272.76,118.47 272.76,118.22 273.4,117.58 273.4,114.52 273.63,114.3 273.63,113.19 274.48,112.34 274.48,111.59 275.33,110.75 275.33,109.18 274.48,108.33 274.48,107.68 v1(275.03,107.13)
M_DATA_B<7>: length 110.6
  TOP w0.088: J1F3.155 274.04,103.22 273.61,104.3 273.61,104.83 v1(274.16,105.5) 274.06,105.84 274.06,106.58 273.87,106.78 273.87,106.91 273.96,106.99 274.29,106.99 274.37,107.08 274.37,107.24 274.29,107.33 274.15,107.33 274.06,107.42 274.06,108.33 273.89,108.5 273.89,108.77 J1F2.155
  TOP w0.165: v3(236.33,173.86) J3D1.AG34
  LAY9 w0.088: 242.66,174.37 242.4,174.37 242.25,174.52 242.12,174.65 241.79,174.65 241.65,174.51 241.34,174.51 241.18,174.67 240.38,174.67 240.15,174.43 239.82,174.43 239.69,174.56 239.37,174.56 239.23,174.43 238.9,174.43 238.81,174.52 238.67,174.52 238.42,174.27 236.73,174.27 v3(236.33,173.86)
  LAY9 w0.089: v1(274.16,105.5) 274.16,105.88 274.06,105.99 274.06,108.55 274.91,109.39 274.91,109.93 274.06,110.78 274.06,112.13 273.21,112.98 273.21,113.73 272.97,113.97 272.97,113.97 272.77,114.17 272.77,114.49 272.35,114.91 272.35,118.97 273.19,119.82 273.19,120.28 272.35,121.74 272.35,122.77 273.19,123.62 273.19,124.12 272.36,125.88 272.36,126.74 273.21,127.59 273.21,128.09 272.37,129.58 272.36,129.59 272.36,130.32 271.51,131.17 271.51,131.92 271.06,132.38 271.06,133.38 269.94,134.49 269.94,138.81 270.03,138.9 270.47,138.9 270.57,138.8 270.57,137.13 270.66,137.04 271.11,137.04 271.21,137.14 271.21,146.66 256.56,161.3 256.56,165.94 248.56,173.95 243.09,173.95 242.66,174.37
M_DATA_B<8>: length 99.1
  TOP w0.088: J1F3.16 269.63,103.92 269.63,104.1 269.79,104.27 269.79,105.1 269.85,105.16 269.85,105.29 269.76,105.38 269.6,105.38 269.51,105.47 269.51,105.64 269.6,105.73 269.9,105.73 269.99,105.82 269.99,105.96 269.83,106.12 269.83,106.79 v1(269.93,107.13) 269.38,107.8 269.38,108.32 269.8,109.41 J1F2.16
  TOP w0.165: v3(237.24,172.03) J3D1.AJ35
  LAY9 w0.088: 243.53,170.66 242.45,170.66 242.12,170.33 241.79,170.33 241.34,170.79 241.13,170.79 241.06,170.72 240.73,170.72 240.44,171.01 240.44,171.25 240.15,171.54 239.43,171.54 239.39,171.58 237.69,171.58 v3(237.24,172.03)
  LAY9 w0.089: 243.53,170.66 245.45,168.74 248.77,168.74 248.85,168.65 248.85,168.19 248.77,168.1 248.37,168.1 248.28,168.02 248.28,167.58 248.39,167.47 250.55,167.47 253.32,164.7 253.32,159.58 266.56,146.35 266.56,133.14 267.12,132.57 267.12,132.22 266.83,131.92 266.83,131.39 267.68,130.54 267.68,129.79 268.53,128.94 268.53,127.37 267.68,126.52 267.68,125.99 268.51,125.16 268.51,123.4 267.66,122.55 267.66,122.02 268.48,121.2 268.48,121.18 268.51,121.15 268.51,119.6 267.66,118.75 267.66,118.21 268.14,117.73 268.14,115.04 268.53,114.65 268.53,112.56 268.96,112.13 268.96,110.78 269.81,109.93 269.81,109.39 269.38,108.96 269.38,107.68 v1(269.93,107.13)
M_DATA_B<9>: length 98.8
  TOP w0.088: J1F2.161 268.79,108.77 268.79,108.5 268.96,108.33 268.96,107.42 269.05,107.33 269.19,107.33 269.27,107.24 269.27,107.08 269.19,106.99 268.86,106.99 268.77,106.91 268.77,106.78 268.96,106.58 268.96,105.84 v1(269.06,105.5) 268.51,104.83 268.51,104.3 268.94,103.22 J1F3.161
  TOP w0.165: v3(238.15,171.17) 238.15,171.17 J3D1.AK36
  LAY9 w0.088: v3(238.15,171.17) 238.16,171.17 238.45,171.17 238.93,170.69 240.15,170.69 240.55,170.29 241.32,170.29 241.58,170.02 241.68,170.02 241.79,170.14 242.12,170.14 242.24,170.02 243.28,170.02
  LAY9 w0.089: v1(269.06,105.5) 269.06,105.89 268.96,106 268.96,108.33 268.48,108.81 268.48,110.1 267.68,110.9 267.68,112.76 268.11,113.19 268.11,113.73 267.37,114.47 267.37,116.77 267.25,116.89 267.25,118.97 268.09,119.82 268.09,120.28 267.25,121.74 267.25,122.77 268.09,123.62 268.09,124.12 267.26,125.88 267.26,126.74 268.11,127.59 268.11,128.09 267.27,129.58 267.26,129.59 267.26,130.32 266.41,131.17 266.41,131.92 265.92,132.41 265.92,146.08 252.69,159.32 252.69,164.44 250.3,166.82 246.45,166.82 246.36,166.91 246.36,167.34 246.49,167.46 247.47,167.46 247.56,167.55 247.56,167.99 247.45,168.09 245.22,168.09 243.28,170.02
M_DATA_B<10>: length 98.6
  TOP w0.088: J1F3.23 264.05,107.58 263.97,107.66 263.97,107.86 264.08,107.96 264.08,108.15 263.99,108.25 263.99,108.42 264.11,108.54 264.11,108.77 263.95,108.92 v1(263.52,108.92) 263.12,109.33 263.12,109.92 264.07,110.86 J1F2.23
  TOP w0.165: v3(237.24,169.29) J3D1.AM35
  LAY9 w0.088: 242.64,166.45 242.55,166.54 241.86,166.54 241.56,166.84 241.56,167.14 241.3,167.4 241.3,167.64 241.06,167.88 240.73,167.88 240.73,167.87 240.59,167.73 240.29,167.73 240.15,167.88 239.64,167.88 239.31,168.21 238.73,168.21 238.55,168.39 238.55,168.54 238.32,168.78 237.75,168.78 v3(237.24,169.29)
  LAY9 w0.089: 242.64,166.45 245.07,164.03 245.07,161.17 250.96,155.27 251.09,155.27 251.41,155.59 251.41,155.72 248.7,158.43 248.7,158.61 248.99,158.91 249.12,158.91 252.03,156 252.03,154.21 259.16,147.07 260.82,147.07 263.11,144.78 263.11,134.32 262.38,133.59 262.38,132.57 261.73,131.92 261.73,131.39 261.73,131.39 262.58,130.54 262.58,129.79 263.43,128.94 263.43,127.37 262.58,126.52 262.58,125.99 263.41,125.16 263.41,123.4 262.56,122.55 262.56,122.02 263.41,121.17 263.41,119.6 262.56,118.75 262.56,118.1 263.12,117.54 263.12,114.37 263.43,114.06 263.43,112.98 262.58,112.13 262.58,111.59 263.43,110.74 263.43,109.28 v1(263.52,108.92)
M_DATA_B<11>: length 99
  TOP w0.088: J1F3.168 263,100.97 262.55,102.76 262.55,103.23 v1(263.1,103.93) 263.1,104.71 263.19,104.8 263.31,104.8 263.4,104.89 263.4,105.02 263.33,105.1 263.05,105.1 262.97,105.17 262.97,105.3 263.06,105.39 263.28,105.39 263.37,105.48 263.37,105.64 263.22,105.78 J1F2.168
  TOP w0.165: v3(236.33,169.34) J3D1.AM34
  LAY9 w0.088: 242.51,165.69 241.79,165.69 241.56,165.92 241.56,166.23 241.3,166.49 241.3,166.8 241.02,167.08 239.82,167.08 239.52,167.38 239.52,167.64 239.26,167.9 237.03,167.9 236.77,168.15 236.77,168.84 236.33,169.29 v3(236.33,169.34)
  LAY9 w0.089: v1(263.1,103.93) 263.1,107.17 262.5,107.78 262.5,108.88 263.01,109.4 263.01,109.93 262.16,110.78 262.16,112.34 263.01,113.19 263.01,113.74 262.48,114.27 262.48,116.45 261.93,117 261.93,117.99 262.15,118.21 262.15,118.97 262.99,119.82 262.99,120.28 262.15,121.74 262.15,122.77 262.99,123.62 262.99,124.12 262.16,125.88 262.16,126.7 263.01,127.55 263.01,128.09 262.17,129.58 262.16,129.59 262.16,130.32 261.31,131.17 261.31,133.43 262.35,134.47 262.35,139.48 262.26,139.57 260.58,139.57 260.41,139.73 260.41,140.04 260.58,140.2 262.26,140.2 262.46,140.4 262.46,144.52 260.54,146.44 257.28,146.44 256.72,147 256.72,148.62 244.43,160.9 244.43,163.77 242.51,165.69
M_DATA_B<12>: length 99.4
  TOP w0.088: J1F2.14 271.5,109.41 271.08,108.32 271.08,107.8 v1(271.63,107.13) 271.53,106.79 271.53,106.12 271.69,105.96 271.69,105.82 271.6,105.73 271.3,105.73 271.21,105.64 271.21,105.47 271.3,105.38 271.46,105.38 271.55,105.29 271.55,105.16 271.49,105.1 271.49,104.27 271.33,104.1 271.33,103.92 J1F3.14
  TOP w0.165: v3(236.33,172.03) J3D1.AJ34
  LAY9 w0.088: v3(236.33,172.03) 237.13,172.48 237.47,172.48 237.55,172.55 238.32,172.55 238.36,172.59 240.58,172.59 241.76,172.04 242.12,172.04 242.24,171.93 244.05,171.93
  LAY9 w0.089: 244.05,171.93 245.97,170.01 249.81,170.01 254.59,165.22 254.59,160.11 267.83,146.87 267.83,133.66 268.63,132.86 268.63,132.02 268.53,131.92 268.53,131.39 269.38,130.54 269.38,129.79 270.23,128.94 270.23,127.42 270.22,127.41 270.22,127.36 269.38,126.52 269.38,125.99 270.21,125.16 270.21,123.4 269.36,122.55 269.36,122.02 270.21,121.17 270.21,119.62 270.2,119.61 270.2,119.59 269.36,118.75 269.36,118.22 269.84,117.74 269.84,114.48 270.23,114.09 270.23,113.19 270.74,112.08 270.74,111.67 271.52,109.86 271.52,109.38 271.08,108.33 271.08,107.68 v1(271.63,107.13)
M_DATA_B<13>: length 98.6
  TOP w0.088: J1F3.159 270.64,103.22 270.21,104.3 270.21,104.83 v1(270.76,105.5) 270.66,105.84 270.66,106.58 270.47,106.78 270.47,106.91 270.56,106.99 270.89,106.99 270.97,107.08 270.97,107.24 270.89,107.33 270.75,107.33 270.66,107.42 270.66,108.33 270.49,108.5 270.49,108.77 J1F2.159
  TOP w0.165: v3(238.15,172.03) J3D1.AJ36
  LAY9 w0.088: 243.79,171.29 242.17,171.29 242.12,171.25 241.79,171.25 241.59,171.45 241.55,171.45 241.42,171.59 240.73,171.59 240.35,171.97 239.65,171.97 239.23,172.38 238.9,172.38 238.56,172.03 v3(238.15,172.03)
  LAY9 w0.089: v1(270.76,105.5) 270.76,106.02 270.68,106.11 270.42,106.11 270.3,106.23 270.3,106.44 270.41,106.55 270.49,106.55 270.66,106.72 270.66,108.32 270.23,109.53 270.23,110.74 269.38,111.59 269.38,112.76 269.81,113.19 269.81,113.73 269.2,114.33 269.2,117.25 268.95,117.51 268.95,118.97 269.79,119.82 269.79,120.28 268.95,121.74 268.95,122.77 269.79,123.62 269.79,124.12 268.96,125.88 268.96,126.74 269.81,127.59 269.81,128.09 268.97,129.58 268.96,129.59 268.96,130.32 268.11,131.17 268.11,131.93 267.76,132.28 267.76,132.83 267.19,133.4 267.19,146.61 253.96,159.84 253.96,164.96 249.55,169.37 245.71,169.37 243.79,171.29
M_DATA_B<14>: length 98.6
  TOP w0.088: J1F3.21 265.75,107.58 265.67,107.66 265.67,107.86 265.78,107.96 265.78,108.15 265.69,108.25 265.69,108.42 265.81,108.54 265.81,108.77 265.65,108.92 v1(265.22,108.92) 264.82,109.33 264.82,109.92 265.77,110.87 265.77,113.46 J1F2.21
  TOP w0.165: v3(238.1,170.15) J3D1.AL36
  LAY9 w0.088: 241.78,168.32 241.23,168.87 240.73,168.87 240.67,168.93 240.21,168.93 240.15,168.87 239.82,168.87 239.75,168.93 239.3,168.93 239.23,168.87 238.9,168.87 238.84,168.93 238.84,168.93 238.67,169.1 238.67,169.38 238.15,169.89 238.15,170.1 v3(238.1,170.15)
  LAY9 w0.089: v1(265.22,108.92) 265.13,109.28 265.13,110.74 264.28,111.59 264.28,112.13 265.11,112.96 265.11,114.08 264.91,114.28 264.91,117.56 264.26,118.21 264.26,118.75 265.11,119.6 265.11,121.17 264.26,122.02 264.26,122.55 265.11,123.4 265.11,125.16 264.28,125.99 264.28,126.52 264.29,126.54 264.29,126.55 265.13,127.38 265.13,128.94 264.28,129.79 264.28,130.54 263.43,131.39 263.43,131.92 264.38,132.87 264.38,145.44 261.43,148.39 259.64,148.39 255.05,152.98 255.05,153.11 255.37,153.43 255.49,153.43 257.48,151.44 257.61,151.44 257.9,151.74 257.9,151.92 251.14,158.68 251.14,163.8 249.66,165.28 245.74,165.28 242.7,168.32 241.78,168.32
M_DATA_B<15>: length 98.7
  TOP w0.088: J1F2.166 264.92,105.78 265.07,105.64 265.07,105.48 264.98,105.39 264.76,105.39 264.67,105.3 264.67,105.17 264.75,105.1 265.03,105.1 265.1,105.02 265.1,104.89 265.01,104.8 264.89,104.8 264.8,104.71 v1(264.8,103.93) 264.25,103.23 264.25,102.76 264.7,100.97 J1F3.166
  TOP w0.165: v3(238.15,169.29) J3D1.AM36
  LAY9 w0.088: v3(238.15,169.29) 238.92,168.53 239.36,168.53 239.82,168.07 240.15,168.07 240.29,168.21 240.59,168.21 240.73,168.07 241.06,168.07 241.14,168.15 241.35,168.15 241.56,167.94 241.56,167.75 241.87,167.44 242.55,167.44 242.64,167.35
  LAY9 w0.089: v1(264.8,103.93) 264.8,107.17 264.18,107.79 264.18,108.86 264.71,109.39 264.71,109.93 263.86,110.78 263.86,112.34 264.71,113.19 264.71,113.73 263.97,114.46 263.97,117.33 263.85,117.63 263.85,117.63 263.85,118.97 264.69,119.82 264.69,120.28 263.85,121.74 263.85,122.77 264.69,123.62 264.69,124.12 263.86,125.88 263.86,126.7 264.71,127.55 264.71,128.09 263.87,129.58 263.86,129.59 263.86,130.32 263.01,131.17 263.01,132.37 263.22,132.58 263.22,133.39 263.74,133.91 263.74,145.18 261.22,147.7 259.43,147.7 252.66,154.47 252.66,154.59 252.98,154.92 253.11,154.92 254.3,153.72 254.43,153.72 254.75,154.04 254.75,154.17 249.14,159.78 247.35,159.78 245.7,161.43 245.7,164.29 242.64,167.35
M_DATA_B<16>: length 89.1
  TOP w0.088: J1F2.27 260.67,110.86 259.84,110.03 259.84,109.21 v1(260.12,108.92) 260.55,108.92 260.71,108.77 260.71,108.54 260.59,108.42 260.59,108.25 260.68,108.15 260.68,107.96 260.57,107.86 260.57,107.66 260.65,107.58 J1F3.27
  TOP w0.165: v3(238.15,166.55) J3D1.AR36
  LAY9 w0.088: v3(238.15,166.55) 238.15,166.46 238.7,165.92 238.82,165.92 238.9,166 239.23,166 239.47,165.77 239.47,165.52 239.9,165.09 240.19,165.09 241.38,163.9
  LAY9 w0.089: v1(260.12,108.92) 260.03,109.29 260.03,110.74 259.18,111.59 259.18,112.13 260.02,112.97 260.02,112.98 260.03,112.98 260.03,114.15 259.61,114.57 259.61,117.73 259.16,118.19 259.16,118.75 260.01,119.6 260.01,121.15 259.98,121.18 259.98,121.2 259.16,122.02 259.16,122.55 260.01,123.4 260.01,125.16 259.18,125.99 259.18,126.52 260.03,127.37 260.03,128.94 259.18,129.79 259.18,130.54 258.33,131.39 258.33,131.92 258.58,132.18 258.58,137.72 255.95,140.36 255.82,140.36 255.5,140.03 255.5,139.91 257.65,137.76 257.65,137.63 257.33,137.31 257.2,137.31 254.82,139.69 254.82,147.83 248.56,154.08 248.56,154.08 247.92,154.73 242.53,160.11 242.53,162.83 241.46,163.9 241.38,163.9
M_DATA_B<17>: length 87.3
  TOP w0.088: J1F3.172 259.6,100.97 259.15,102.76 259.15,103.23 v1(259.7,103.93) 259.7,104.71 259.79,104.8 259.91,104.8 260,104.89 260,105.02 259.93,105.1 259.65,105.1 259.57,105.17 259.57,105.3 259.66,105.39 259.88,105.39 259.97,105.48 259.97,105.64 259.82,105.78 J1F2.172
  TOP w0.165: v3(238.23,165.66) 238.22,165.67 J3D1.AT36
  LAY9 w0.088: v3(238.23,165.66) 238.43,165.66 238.92,165.17 239.27,165.17 239.5,164.94 239.5,164.82 239.58,164.74 239.58,164.5 239.82,164.27 240.01,164.27 240.07,164.21 240.3,164.21 240.5,164.01 240.5,163.64 240.73,163.41 240.99,163.41
  LAY9 w0.089: 240.99,163.41 241.9,162.5 241.9,159.85 254.18,147.56 254.18,138.77 254.32,138.63 254.44,138.63 254.65,138.84 254.77,138.84 255.1,138.52 255.1,138.39 254.89,138.18 254.89,138.06 255.21,137.74 255.34,137.74 255.55,137.94 255.67,137.94 255.99,137.62 255.99,137.49 255.79,137.29 255.79,137.16 256.11,136.84 256.24,136.84 256.44,137.04 256.57,137.04 256.89,136.72 256.89,136.6 256.68,136.39 256.68,136.27 257.01,135.94 257.17,135.94 257.36,135.76 257.36,135.59 257.91,135.04 257.91,131.17 258.76,130.32 258.76,129.59 258.77,129.58 259.61,128.09 259.61,127.59 258.76,126.74 258.76,125.88 259.59,124.12 259.59,123.62 258.75,122.77 258.75,121.74 259.59,120.28 259.59,119.82 258.75,118.97 258.75,118.18 258.69,118.12 258.69,114.65 259.61,113.73 259.61,113.19 258.76,112.34 258.76,110.78 259.61,109.93 259.61,109.39 259,108.78 259,107.87 259.7,107.17 v1(259.7,103.93)
M_DATA_B<18>: length 89.3
  TOP w0.088: 254.49,104.27 254.49,105.1 254.55,105.16 254.55,105.29 254.46,105.38 254.3,105.38 254.21,105.47 254.21,105.64 254.3,105.73 254.6,105.73 254.69,105.82 254.69,105.96 254.53,106.12 254.53,106.79 v1(254.63,107.13) 254.08,107.8 254.08,108.32 254.5,109.41 J1F2.34
  TOP w0.089: 254.49,104.27 254.33,104.1 254.33,103.92 J1F3.34
  TOP w0.165: v3(235.41,165.63) J3D1.AT33
  LAY9 w0.088: v3(235.41,165.63) 235.41,165.3 235.72,164.99 235.72,164.27 235.83,164.16 235.83,163.63 236.08,163.38 236.48,163.38 236.89,162.97 236.89,162.72 237.12,162.49 237.42,162.49 237.69,162.23 237.94,162.23 238.29,161.88
  LAY9 w0.089: v1(254.63,107.13) 254.08,107.68 254.08,108.36 254.93,109.21 254.93,110.74 254.08,111.59 254.08,112.13 254.93,112.98 254.93,114.34 254.61,114.66 254.61,117.65 254.06,118.19 254.06,118.75 254.91,119.6 254.91,121.17 254.06,122.02 254.06,122.55 254.91,123.4 254.91,125.16 254.08,125.99 254.08,126.52 254.93,127.37 254.93,128.94 254.08,129.79 254.08,130.54 253.23,131.39 253.23,131.92 253.45,132.14 253.45,133.73 249.59,137.58 249.59,142.25 249.68,142.34 250.14,142.34 250.23,142.25 250.23,139.32 250.32,139.23 250.77,139.23 250.86,139.32 250.86,146.9 239.05,158.71 239.05,161.3 238.47,161.88 238.29,161.88
M_DATA_B<19>: length 90.1
  TOP w0.088: 253.66,108.33 253.66,107.42 253.75,107.33 253.89,107.33 253.97,107.24 253.97,107.08 253.89,106.99 253.56,106.99 253.47,106.91 253.47,106.78 253.66,106.58 253.66,105.84 v1(253.76,105.5) 253.21,104.83 253.21,104.3 253.64,103.22 J1F3.179
  TOP w0.089: J1F2.179 253.49,108.77 253.49,108.5 253.66,108.33
  TOP w0.165: v3(235.41,167.46) J3D1.AP33
  LAY9 w0.088: v3(235.41,167.46) 234.91,166.96 234.91,163.74 235.25,163.39 235.58,163.39 235.81,163.16 235.81,163.08 236.66,162.23 237.02,162.23 237.37,161.88 237.37,161.66 237.61,161.43 237.78,161.43
  LAY9 w0.089: 237.78,161.43 238.02,161.43 238.42,161.04 238.42,158.44 248.96,147.9 248.96,144.73 249.07,144.62 249.49,144.62 249.59,144.72 249.59,146.15 249.68,146.24 250.14,146.24 250.23,146.15 250.23,144.13 250.05,143.95 249.05,143.95 248.96,143.86 248.96,137.32 252.81,133.47 252.81,131.17 253.66,130.32 253.66,129.59 253.67,129.58 254.51,128.09 254.51,127.59 253.66,126.74 253.66,125.88 254.49,124.12 254.49,123.62 253.65,122.77 253.65,121.74 254.49,120.28 254.49,119.82 253.65,118.97 253.65,118.21 253.45,118.02 253.45,117.47 253.86,117.06 253.86,114.5 254.51,113.85 254.51,113.19 253.66,112.34 253.66,110.78 254.51,109.93 254.51,109.39 253.66,108.55 253.66,108.54 253.66,108.53 253.66,106.68 253.5,106.51 253.5,106.19 253.76,105.92 v1(253.76,105.5)
M_DATA_B<20>: length 90
  TOP w0.088: J1F2.25 262.37,110.86 261.42,109.92 261.42,109.33 v1(261.82,108.92) 262.25,108.92 262.41,108.77 262.41,108.54 262.29,108.42 262.29,108.25 262.38,108.15 262.38,107.96 262.27,107.86 262.27,107.66 262.35,107.58 J1F3.25
  TOP w0.165: v3(238.15,167.46) J3D1.AP36
  LAY9 w0.088: 242.16,164.78 241.79,164.78 241.56,165.01 241.56,165.13 241.3,165.39 241.3,165.8 241.06,166.03 240.8,166.03 240.51,166.33 240.24,166.33 240.15,166.24 239.82,166.24 239.47,166.59 239.47,166.8 239.23,167.04 238.85,167.04 238.42,167.46 v3(238.15,167.46)
  LAY9 w0.089: v1(261.82,108.92) 261.73,109.31 261.73,110.74 260.88,111.59 260.88,112.13 261.73,112.98 261.73,114.71 261.09,115.35 261.09,117.99 260.86,118.22 260.86,118.75 261.7,119.59 261.7,119.61 261.71,119.62 261.71,121.17 260.86,122.02 260.86,122.55 261.71,123.4 261.71,125.16 260.88,125.99 260.88,126.52 261.72,127.36 261.72,127.41 261.73,127.42 261.73,128.94 260.88,129.79 260.88,130.54 260.03,131.39 260.03,131.39 260.03,131.92 260.38,132.28 260.38,132.79 260.22,132.96 260.22,133.4 261.12,134.3 261.12,136.88 261.03,136.97 260.57,136.97 260.49,136.88 260.49,134.61 260.4,134.52 259.94,134.52 259.85,134.61 259.85,138.27 256.08,142.04 256.08,148.36 243.8,160.64 243.8,163.5 242.4,164.9 242.28,164.9 242.16,164.78
M_DATA_B<21>: length 88.3
  TOP w0.088: J1F3.170 261.3,100.97 260.85,102.76 260.85,103.23 v1(261.4,103.93) 261.4,104.71 261.49,104.8 261.61,104.8 261.7,104.89 261.7,105.02 261.63,105.1 261.35,105.1 261.27,105.17 261.27,105.3 261.36,105.39 261.58,105.39 261.67,105.48 261.67,105.64 261.52,105.78 J1F2.170
  TOP w0.165: v3(237.29,166.55) J3D1.AT35
  LAY9 w0.088: v3(237.29,166.55) 237.75,167.01 238.37,167.01 238.67,166.71 238.67,166.47 238.9,166.24 239.38,166.24 239.63,165.99 239.76,165.99 239.82,166.05 240.15,166.05 240.44,165.75 240.44,165.44 240.68,165.2 240.75,165.2 241.6,164.35
  LAY9 w0.089: 241.6,164.35 241.97,164.35 243.16,163.15 243.16,160.38 255.45,148.09 255.45,141.78 259.22,138.01 259.22,132.32 259.61,131.92 259.61,131.52 259.61,131.52 259.61,131.17 260.46,130.32 260.46,129.59 260.47,129.58 261.31,128.09 261.31,127.59 260.46,126.74 260.46,125.88 261.29,124.12 261.29,123.62 260.45,122.77 260.45,121.74 261.29,120.28 261.29,119.82 260.45,118.97 260.45,114.63 261.31,113.77 261.31,113.19 260.46,112.34 260.46,110.78 261.31,109.93 261.31,109.39 260.79,108.17 260.79,107.83 261.4,107.22 v1(261.4,103.93)
M_DATA_B<22>: length 88.8
  TOP w0.088: J1F2.32 256.2,109.41 255.78,108.32 255.78,107.8 v1(256.33,107.13) 256.23,106.79 256.23,106.12 256.39,105.96 256.39,105.82 256.3,105.73 256,105.73 255.91,105.64 255.91,105.47 256,105.38 256.16,105.38 256.25,105.29 256.25,105.16 256.19,105.1 256.19,104.27
  TOP w0.089: J1F3.32 256.03,103.92 256.03,104.1 256.19,104.27
  TOP w0.165: v3(236.28,165.63) J3D1.AT34
  LAY9 w0.088: v3(236.28,165.63) 236.31,165.63 236.89,165.06 236.89,164.55 237.12,164.32 237.34,164.32 237.71,163.96 237.71,163.63 237.98,163.36 238.55,163.36 238.75,163.16 239.13,163.16 239.37,162.93 239.37,162.78 239.81,162.33
  LAY9 w0.089: 239.81,162.33 240.32,161.83 240.32,159.24 246.67,152.88 252.13,147.43 252.13,146.74 252.22,146.65 252.55,146.65 252.64,146.56 252.64,146.11 252.55,146.02 252.22,146.02 252.13,145.93 252.13,145.47 252.22,145.39 252.55,145.39 252.64,145.3 252.64,144.84 252.55,144.75 252.22,144.75 252.13,144.66 252.13,144.21 252.22,144.12 252.55,144.12 252.64,144.03 252.64,143.57 252.55,143.48 252.22,143.48 252.13,143.39 252.13,142.94 252.22,142.85 252.43,142.85 252.52,142.76 252.52,142.3 252.43,142.22 252.22,142.22 252.13,142.13 252.13,138.63 255.16,135.6 255.16,135.47 254.84,135.15 254.71,135.15 253.65,136.21 253.53,136.21 253.2,135.89 253.2,135.76 255.17,133.8 255.17,132.17 254.93,131.92 254.93,131.39 255.78,130.54 255.78,129.79 256.63,128.94 256.63,127.37 255.78,126.52 255.78,125.99 256.61,125.16 256.61,123.4 255.76,122.55 255.76,122.02 256.61,121.17 256.61,119.6 255.76,118.75 255.76,118.21 256.19,117.78 256.19,114.9 256.63,114.47 256.63,112.98 255.78,112.13 255.78,111.59 256.63,110.74 256.63,109.18 256.6,109.15 255.78,108.33 255.78,107.68 v1(256.33,107.13)
M_DATA_B<23>: length 89.7
  TOP w0.088: 255.36,108.33 255.36,107.42 255.45,107.33 255.59,107.33 255.67,107.24 255.67,107.08 255.59,106.99 255.26,106.99 255.17,106.91 255.17,106.78 255.36,106.58 255.36,105.84 v1(255.46,105.5) 254.91,104.83 254.91,104.3 255.34,103.22 J1F3.177
  TOP w0.089: J1F2.177 255.19,108.77 255.19,108.5 255.36,108.33
  TOP w0.165: v3(235.41,166.55) J3D1.AR33
  LAY9 w0.088: v3(235.41,166.55) 235.84,166.12 235.84,165.56 235.88,165.53 235.88,165.47 235.97,165.38 235.97,164.46 236.22,164.21 236.6,164.21 236.71,164.1 236.71,163.82 237.19,163.34 237.4,163.34 237.69,163.05 237.69,162.79 237.99,162.49 238.63,162.49 238.78,162.34
  LAY9 w0.089: v1(255.46,105.5) 255.46,105.92 255.36,106.03 255.36,108.54 256.21,109.39 256.21,109.93 255.36,110.78 255.36,112.34 256.21,113.19 256.21,113.95 255.35,114.82 255.35,118.97 256.19,119.82 256.19,120.28 255.35,121.74 255.35,122.77 256.19,123.62 256.19,124.12 255.36,125.88 255.36,126.74 256.21,127.59 256.21,128.09 255.37,129.58 255.36,129.59 255.36,130.32 254.51,131.17 254.51,132.49 254.42,132.58 254.27,132.58 254.18,132.67 254.18,133.13 254.27,133.22 254.42,133.22 254.51,133.31 254.51,133.56 251.3,136.77 251.3,136.89 251.63,137.22 251.75,137.22 252.32,136.65 252.45,136.65 252.77,136.97 252.77,137.09 252,137.87 251.17,137.87 250.99,137.69 250.52,137.69 250.23,137.98 250.23,138.42 250.32,138.5 251.41,138.5 251.5,138.59 251.5,147.16 239.68,158.97 239.68,161.56 238.91,162.34 238.78,162.34
M_DATA_B<24>: length 83.9
  TOP w0.088: J1F2.38 251.1,109.41 250.68,108.32 250.68,107.8 v1(251.23,107.13) 251.13,106.79 251.13,106.12 251.29,105.96 251.29,105.82 251.2,105.73 250.9,105.73 250.81,105.64 250.81,105.47 250.9,105.38 251.06,105.38 251.15,105.29 251.15,105.16 251.09,105.1 251.09,104.27
  TOP w0.089: J1F3.38 250.93,103.92 250.93,104.1 251.09,104.27
  TOP w0.1: v3(233.53,166.55) J3D1.AR31
  LAY9 w0.088: v3(233.53,166.55) 233.13,166.15 233.13,165.41 233.44,165.1 233.44,163.3 233.83,162.91 233.83,162.41 234.01,162.23 234.2,162.23 234.44,162 234.44,161.69 234.71,161.42 234.95,161.42 236.51,159.85
  LAY9 w0.089: v1(251.23,107.13) 250.68,107.68 250.68,108.33 251.53,109.18 251.53,110.74 250.68,111.59 250.68,112.13 251.53,112.98 251.53,114.23 250.97,114.8 250.97,117.91 250.66,118.22 250.66,118.75 251.51,119.6 251.51,121.15 251.48,121.18 251.48,121.2 250.66,122.02 250.66,122.55 251.51,123.4 251.51,125.16 250.68,125.99 250.68,126.52 251.53,127.37 251.53,128.94 250.68,129.79 250.68,130.54 249.83,131.39 249.83,131.92 249.85,131.95 249.85,132.67 249.42,133.11 249.42,134.17 247.06,136.53 247.06,140.21 247.02,140.25 247.02,140.46 247.06,140.5 247.06,140.96 246.97,141.05 246.53,141.05 246.44,141.14 246.44,141.59 246.53,141.68 246.97,141.68 247.06,141.77 247.06,142.23 246.97,142.31 246.53,142.31 246.44,142.4 246.44,142.86 246.53,142.95 246.97,142.95 247.06,143.04 247.06,143.49 246.97,143.58 246.53,143.58 246.44,143.67 246.44,147.73 236.51,157.66 236.51,159.85
M_DATA_B<25>: length 83.8
  TOP w0.088: J1F3.183 250.24,103.22 249.81,104.3 249.81,104.83 v1(250.36,105.5) 250.26,105.84 250.26,106.58 250.07,106.78 250.07,106.91 250.16,106.99 250.49,106.99 250.57,107.08 250.57,107.24 250.49,107.33 250.35,107.33 250.26,107.42 250.26,108.33
  TOP w0.089: J1F2.183 250.09,108.77 250.09,108.5 250.26,108.33
  TOP w0.1: v3(232.72,165.63) 232.67,165.63 J3D1.AT30
  LAY9 w0.088: v3(232.72,165.63) 232.72,165.28 233.12,164.88 233.12,164.55 233,164.43 233,164.09 233.12,163.97 233.12,163.64 233.01,163.53 233.01,163.35 233.54,162.82 233.54,161.73 233.92,161.34 234.12,161.34 235.88,159.58
  LAY9 w0.089: 235.88,159.58 235.88,157.39 245.81,147.46 245.81,139.15 245.9,139.07 246.34,139.07 246.42,138.98 246.42,138.52 246.34,138.43 245.9,138.43 245.81,138.34 245.81,137.89 245.9,137.8 246.34,137.8 246.42,137.71 246.42,137.25 246.34,137.16 245.9,137.16 245.81,137.07 245.81,136.88 248.69,134 248.69,132.93 249.41,132.21 249.41,131.17 250.26,130.32 250.26,129.59 250.27,129.58 251.11,128.09 251.11,127.59 250.26,126.74 250.26,125.88 251.09,124.12 251.09,123.62 250.25,122.77 250.25,121.74 251.09,120.28 251.09,119.82 250.25,118.97 250.25,118.17 250.13,118.05 250.13,114.73 251.11,113.74 251.11,113.19 250.26,112.35 250.26,110.78 251.11,109.93 251.11,109.39 250.26,108.54 250.26,106.31 250.21,106.25 250.21,106.09 250.36,105.93 v1(250.36,105.5)
M_DATA_B<26>: length 84
  TOP w0.088: J1F3.45 245.35,107.58 245.27,107.66 245.27,107.86 245.38,107.96 245.38,108.15 245.29,108.25 245.29,108.42 245.41,108.54 245.41,108.77 245.25,108.92 v1(244.82,108.92) 244.42,109.33 244.42,109.92 245.37,110.86 J1F2.45
  TOP w0.1: v3(230.84,165.63) J3D1.AT28
  LAY9 w0.088: 231.7,159.79 231.7,160.74 231.99,161.04 231.99,161.46 230.69,162.76 230.69,163.39 230.44,163.64 230.44,163.97 230.56,164.08 230.56,164.44 230.39,164.6 230.39,164.93 230.84,165.38 v3(230.84,165.63)
  LAY9 w0.089: 231.7,159.79 233.07,158.42 233.07,156.23 241.45,147.84 241.45,147.61 241.15,147.3 241.15,145.5 241.24,145.41 241.69,145.41 241.78,145.5 241.78,146.87 241.88,146.97 242.32,146.97 242.42,146.88 242.42,144.6 242.08,144.26 242.08,144.1 242.4,143.78 242.4,143.64 242.08,143.32 242.08,143.19 242.37,142.9 242.37,142.78 242.08,142.49 242.08,142.34 242.42,142 242.42,141.86 242.08,141.52 242.08,141.39 242.42,141.05 242.42,140.91 242.08,140.57 242.08,140.4 242.4,140.08 242.4,139.94 242.08,139.63 242.08,139.5 242.37,139.21 242.37,139.08 242.08,138.79 242.08,138.65 242.42,138.31 242.42,138.16 242.08,137.83 242.08,137.7 242.42,137.36 242.42,137.21 242.08,136.87 242.08,136.44 244.95,133.57 244.95,132.15 244.73,131.92 244.73,131.92 244.73,131.39 245.58,130.54 245.58,129.79 246.43,128.94 246.43,127.37 245.58,126.52 245.58,125.99 246.41,125.16 246.41,124.36 246.41,124.36 246.41,123.4 245.56,122.55 245.56,122.02 246.41,121.17 246.41,119.6 245.56,118.75 245.56,115.3 246.43,114.43 246.43,112.98 245.58,112.13 245.58,111.67 245.58,110.78 244.73,109.93 244.73,109.39 v1(244.82,108.92)
M_DATA_B<27>: length 84
  TOP w0.088: J1F3.190 244.3,100.97 243.85,102.76 243.85,103.23 v1(244.4,103.93) 244.4,104.71 244.49,104.8 244.61,104.8 244.7,104.89 244.7,105.02 244.63,105.1 244.35,105.1 244.27,105.17 244.27,105.3 244.36,105.39 244.58,105.39 244.67,105.48 244.67,105.64 244.52,105.78 J1F2.190
  TOP w0.1: v3(230.84,167.46) J3D1.AP28
  LAY9 w0.088: v3(230.84,167.46) 230.84,167.13 230.41,166.7 230.41,165.52 230.35,165.46 230.35,165.46 230.1,165.21 230.1,162.7
  LAY9 w0.089: v1(244.4,103.93) 244.4,104.96 243.88,107.87 243.88,108.33 244.31,109.36 244.31,110.74 245.16,111.59 245.16,112.34 246.01,113.19 246.01,113.73 244.76,114.97 244.76,117.82 245.15,118.21 245.15,118.97 245.99,119.82 245.99,120.28 245.15,121.74 245.15,122.77 245.99,123.62 245.99,124.12 245.16,125.88 245.16,126.74 246.01,127.59 246.01,128.09 245.17,129.58 245.16,129.59 245.16,130.32 244.31,131.17 244.31,132.1 244.12,132.3 244.12,133.5 241.44,136.17 241.44,143.84 240.51,144.76 240.51,147.88 232.43,155.96 232.43,158.16 231.1,159.49 231.1,161.71 230.1,162.7
M_DATA_B<28>: length 84.2
  TOP w0.088: 252.79,104.27 252.79,105.1 252.85,105.16 252.85,105.29 252.76,105.38 252.6,105.38 252.51,105.47 252.51,105.64 252.6,105.73 252.9,105.73 252.99,105.82 252.99,105.96 252.83,106.12 252.83,106.79 v1(252.93,107.13) 252.38,107.8 252.38,108.32 252.8,109.41 J1F2.36
  TOP w0.089: 252.79,104.27 252.63,104.1 252.63,103.92 J1F3.36
  TOP w0.1: v3(233.53,167.46) J3D1.AP31
  LAY9 w0.088: 236.79,161.33 236.27,161.86 236.27,161.99 236.03,162.23 235.78,162.23 235.41,162.6 235.25,162.6 235.01,162.83 235.01,163 234.69,163.32 234.42,163.32 234.1,163.64 234.1,163.97 234.25,164.12 234.25,164.41 234.1,164.55 234.1,164.88 234.25,165.03 234.25,165.32 234.1,165.47 234.1,166.89 v3(233.53,167.46)
  LAY9 w0.089: v1(252.93,107.13) 252.38,107.68 252.38,108.33 253.23,109.18 253.23,110.74 252.38,111.59 252.38,112.13 253.23,112.98 253.23,114.34 252.63,114.94 252.63,117.95 252.36,118.22 252.36,118.75 253.2,119.59 253.2,119.61 253.21,119.62 253.21,121.17 252.36,122.02 252.36,122.55 253.21,123.4 253.21,125.16 252.38,125.99 252.38,126.52 253.22,127.36 253.22,127.41 253.23,127.42 253.23,128.94 252.38,129.79 252.38,130.54 251.53,131.39 251.53,133.18 251.72,133.37 251.72,133.5 251.48,133.73 251.36,133.73 251.16,133.53 251.03,133.53 250.71,133.85 250.71,133.98 250.98,134.25 250.98,134.4 248.33,137.06 248.33,145.74 247.72,146.35 247.72,148.25 237.78,158.18 237.78,160.45 236.9,161.33 236.79,161.33
M_DATA_B<29>: length 83.7
  TOP w0.088: 251.96,108.33 251.96,107.42 252.05,107.33 252.19,107.33 252.27,107.24 252.27,107.08 252.19,106.99 251.86,106.99 251.77,106.91 251.77,106.78 251.96,106.58 251.96,105.84 v1(252.06,105.5) 251.51,104.83 251.51,104.3 251.94,103.22 J1F3.181
  TOP w0.089: J1F2.181 251.79,108.77 251.79,108.5 251.96,108.33
  TOP w0.1: v3(233.53,165.63) J3D1.AT31
  LAY9 w0.088: v3(233.53,165.63) 233.58,165.63 233.78,165.44 233.78,163.47 234.1,163.15 234.1,162.72 234.33,162.49 234.63,162.49 234.9,162.23 235.12,162.23 235.47,161.88 235.47,161.66 235.7,161.43 235.8,161.43
  LAY9 w0.089: 235.8,161.43 235.9,161.43 237.15,160.19 237.15,157.92 247.08,147.99 247.08,145.65 247.17,145.56 247.6,145.56 247.69,145.47 247.69,145.02 247.6,144.93 247.17,144.93 247.08,144.84 247.08,144.38 247.17,144.3 247.6,144.3 247.69,144.21 247.69,136.79 250.05,134.44 250.05,133.37 251.11,132.31 251.11,131.17 251.96,130.32 251.96,129.59 251.97,129.58 252.81,128.09 252.81,127.59 251.96,126.74 251.96,125.88 252.79,124.12 252.79,123.62 251.95,122.77 251.95,121.74 252.79,120.28 252.79,119.82 251.95,118.97 251.95,118.15 251.86,118.06 251.86,114.83 252.1,114.59 252.1,114.47 252.42,114.15 252.55,114.15 252.81,113.89 252.81,113.19 251.96,112.34 251.96,110.78 252.81,109.93 252.81,109.39 251.96,108.54 251.96,106.89 251.64,106.57 251.64,106.35 252.06,105.92 v1(252.06,105.5)
M_DATA_B<30>: length 83.8
  TOP w0.088: J1F3.43 247.05,107.58 246.97,107.66 246.97,107.86 247.08,107.96 247.08,108.15 246.99,108.25 246.99,108.42 247.11,108.54 247.11,108.77 246.95,108.92 v1(246.52,108.92) 246.12,109.33 246.12,109.92 247.07,110.87 247.07,113.46 J1F2.43
  TOP w0.1: J3D1.AT29 231.7,165.69 v3(231.7,165.63)
  LAY9 w0.088: v3(231.7,165.63) 231.7,163.08 232.67,162.11 232.67,160.6
  LAY9 w0.089: 232.67,160.6 234.33,158.94 234.33,156.75 243.68,147.4 243.68,147.12 243.95,146.86 244.16,146.86 244.25,146.77 244.25,146.31 244.16,146.22 243.76,146.22 243.68,146.15 243.68,145.66 243.76,145.59 244.16,145.59 244.25,145.5 244.25,145.04 244.16,144.95 243.77,144.95 243.68,144.87 243.68,144.39 243.77,144.31 244.17,144.31 244.26,144.22 244.26,143.76 244.17,143.67 243.77,143.67 243.68,143.58 243.68,143.13 243.77,143.04 244.17,143.04 244.26,142.95 244.26,142.49 244.17,142.4 243.77,142.4 243.68,142.31 243.68,141.86 243.77,141.77 244.17,141.77 244.26,141.68 244.26,141.22 244.17,141.14 243.77,141.14 243.68,141.05 243.68,140.59 243.77,140.5 244.17,140.5 244.26,140.41 244.26,139.96 244.17,139.87 243.77,139.87 243.68,139.78 243.68,139.32 243.77,139.23 244.11,139.23 244.2,139.15 244.2,138.69 244.11,138.6 243.77,138.6 243.68,138.51 243.68,136.82 246.66,133.85 246.66,132.15 246.43,131.92 246.43,131.39 247.28,130.54 247.28,129.79 248.13,128.94 248.13,127.37 247.28,126.52 247.28,125.99 248.11,125.16 248.11,123.4 247.26,122.55 247.26,122.02 248.11,121.17 248.11,119.6 247.26,118.75 247.26,118.21 247.77,117.7 247.77,115.37 248.13,115.01 248.13,112.86 247.77,112.5 247.65,112.5 247.28,112.13 247.28,112.01 247.28,111.34 247.41,111.2 247.41,110.91 246.43,109.93 246.43,109.39 v1(246.52,108.92)
M_DATA_B<31>: length 83.9
  TOP w0.088: J1F3.188 246,100.97 245.55,102.76 245.55,103.23 v1(246.1,103.93) 246.1,104.71 246.19,104.8 246.31,104.8 246.4,104.89 246.4,105.02 246.33,105.1 246.05,105.1 245.97,105.17 245.97,105.3 246.06,105.39 246.28,105.39 246.37,105.48 246.37,105.64 246.22,105.78 J1F2.188
  TOP w0.1: v3(230.84,166.55) J3D1.AR28
  LAY9 w0.088: 232.33,161.03 232.33,161.8 231.26,162.87 231.26,165.7 v3(230.84,166.55)
  LAY9 w0.089: v1(246.1,103.93) 246.1,105.08 246,105.19 245.85,105.19 245.76,105.28 245.76,105.56 245.85,105.65 246,105.65 246.09,105.74 246.09,107.17 245.38,107.88 245.38,108.76 246.01,109.39 246.01,110.74 246.86,111.59 246.86,112.34 247.71,113.19 247.71,113.73 247.36,114.08 247.36,114.55 246.85,115.06 246.85,118.97 247.69,119.82 247.69,120.28 246.85,121.74 246.85,122.77 247.69,123.62 247.69,124.12 246.86,125.88 246.86,126.74 247.71,127.59 247.71,128.09 246.87,129.58 246.86,129.59 246.86,130.32 246.01,131.17 246.01,131.92 246.01,131.92 245.58,132.35 245.58,133.9 243.05,136.43 243.05,147.14 242.59,147.6 242.18,147.6 242.09,147.69 242.09,148.1 233.7,156.49 233.7,158.68 232.33,160.05 232.33,161.03
M_DATA_B<32>: length 89.1
  TOP w0.088: J1F3.97 196.05,107.58 195.97,107.66 195.97,107.86 196.08,107.96 196.08,108.15 195.99,108.25 195.99,108.42 196.11,108.54 196.11,108.77 195.95,108.92 v1(195.52,108.92) 195.24,109.21 195.24,110.03 196.07,110.86 J1F2.97
  TOP w0.165: J3D1.AT11 v3(214.38,165.63)
  LAY9 w0.088: 214.47,161.35 214.47,161.68 214.35,161.8 214.35,162.36 214.71,162.72 214.71,163.05 214.53,163.23 214.53,163.46 214.71,163.64 214.71,163.97 214.53,164.15 214.53,164.37 214.71,164.55 214.71,164.88 214.38,165.21 v3(214.38,165.63)
  LAY9 w0.089: 214.47,161.35 201.11,148 201.11,147.38 201.11,147.38 201.11,147.32 200.97,147.18 200.37,147.18 199.84,146.65 199.84,143.72 199.93,143.63 200.39,143.63 200.48,143.72 200.48,146.4 200.62,146.54 200.97,146.54 201.11,146.4 201.11,142.48 201.02,142.39 200.58,142.39 200.49,142.3 200.49,141.85 200.59,141.75 201.02,141.75 201.11,141.67 201.11,141.02 197.77,137.68 197.77,134.47 197.68,134.39 197.11,134.39 197.02,134.3 197.02,133.84 197.11,133.75 197.76,133.75 197.86,133.64 197.86,133.53 197.39,133.06 197.39,132.75 197.56,132.58 197.56,132.37 197.13,131.94 197.13,131.39 197.98,130.54 197.98,129.79 198.83,128.94 198.83,127.37 197.98,126.52 197.98,125.99 198.81,125.16 198.81,123.4 197.96,122.55 197.96,122.02 198.78,121.2 198.78,121.18 198.81,121.15 198.81,119.6 197.96,118.75 197.96,118.09 198.07,117.99 198.07,117.35 197.45,116.74 197.45,114.51 197.13,114.18 197.13,112.98 196.28,112.12 196.28,110.77 195.43,109.93 195.43,109.42 195.52,109.33 v1(195.52,108.92)
M_DATA_B<33>: length 89.2
  TOP w0.088: J1F3.242 195,100.97 194.55,102.76 194.55,103.23 v1(195.1,103.93) 195.1,104.71 195.19,104.8 195.31,104.8 195.4,104.89 195.4,105.02 195.33,105.1 195.05,105.1 194.97,105.17 194.97,105.3 195.06,105.39 195.28,105.39 195.37,105.48 195.37,105.64 195.22,105.78 J1F2.242
  TOP w0.165: J3D1.AR12 v3(215.29,166.55)
  LAY9 w0.088: v3(215.29,166.55) 214.82,166.08 214.21,166.08 213.91,165.78 213.91,161.69
  LAY9 w0.089: v1(195.1,103.93) 195.1,107.27 194.58,107.79 194.58,108.96 195.01,109.4 195.01,110.75 195.86,111.6 195.86,112.35 196.71,113.19 196.71,113.73 196.16,114.28 196.16,116.77 197.55,118.16 197.55,118.97 198.39,119.82 198.39,120.28 197.55,121.74 197.55,122.77 198.39,123.62 198.39,124.12 197.56,125.88 197.56,126.74 198.41,127.59 198.41,128.09 197.57,129.58 197.56,129.59 197.56,130.32 196.71,131.17 196.71,131.99 195.99,132.71 195.99,133.23 195.99,133.24 195.99,133.58 195.99,134.56 196.45,135.02 196.7,135.02 196.79,135.11 196.79,135.39 196.7,135.48 196.51,135.48 196.42,135.57 196.42,136.03 196.51,136.12 197.05,136.12 197.14,136.2 197.14,136.63 197.02,136.75 196.51,136.75 196.42,136.84 196.42,137.23 196.57,137.38 197.05,137.38 197.14,137.47 197.14,137.95 198.7,139.51 198.7,139.51 198.95,139.76 199.21,140.02 199.21,140.9 199.35,141.04 199.74,141.04 199.88,141.18 199.88,141.53 199.74,141.67 199.35,141.67 199.21,141.81 199.21,146.99 200.03,147.81 200.39,147.81 200.48,147.9 200.48,148.26 213.91,161.69
M_DATA_B<34>: length 88.8
  TOP w0.088: J1F2.104 189.9,109.41 189.48,108.32 189.48,107.8 v1(190.03,107.13) 189.93,106.79 189.93,106.12 190.09,105.96 190.09,105.82 190,105.73 189.7,105.73 189.61,105.64 189.61,105.47 189.7,105.38 189.86,105.38 189.95,105.29 189.95,105.16 189.89,105.1 189.89,104.27 189.73,104.1 189.73,103.92 J1F3.104
  TOP w0.165: v3(212.19,167.46) J3D1.AT10
  LAY9 w0.088: 208.03,159.79 208.12,159.88 208.43,159.88 210.81,162.25 211.16,162.25 212.07,163.17 212.07,167.34 v3(212.19,167.46)
  LAY9 w0.089: 208.03,159.79 201.72,153.48 201.59,153.48 201.52,153.55 201.4,153.55 201.08,153.23 201.08,153.1 201.15,153.03 201.15,152.91 200.82,152.58 200.7,152.58 200.47,152.82 200.34,152.82 200.02,152.49 200.02,152.37 200.25,152.14 200.25,152.01 199.93,151.69 199.8,151.69 199.57,151.92 199.44,151.92 199.12,151.6 199.12,151.47 199.35,151.24 199.35,151.11 199.03,150.79 198.9,150.79 198.67,151.02 198.55,151.02 198.22,150.7 198.22,150.57 198.46,150.34 198.46,150.22 198.13,149.89 198.01,149.89 197.78,150.13 197.65,150.13 197.33,149.8 197.33,149.68 197.56,149.45 197.56,149.32 197.24,149 197.11,149 196.88,149.23 196.75,149.23 196.43,148.91 196.43,148.78 196.66,148.55 196.66,148.42 196.07,147.83 196.07,141.01 191.72,136.66 191.72,132.55 192.02,132.25 192.02,131.16 191.18,130.32 191.18,129.79 192.03,128.94 192.03,127.37 191.18,126.52 191.18,125.99 192.01,125.16 192.01,124.36 192.01,124.36 192.01,123.4 191.16,122.55 191.16,122.02 192.01,121.17 192.01,119.6 191.16,118.75 191.16,118.22 191.56,117.82 191.56,115.31 190.33,114.08 190.33,112.98 189.48,112.13 189.48,111.59 190.33,110.74 190.33,109.21 189.48,108.36 189.48,107.68 v1(190.03,107.13)
M_DATA_B<35>: length 89.1
  TOP w0.088: J1F2.249 188.89,108.77 188.89,108.5 189.06,108.33 189.06,107.42 189.15,107.33 189.29,107.33 189.37,107.24 189.37,107.08 189.29,106.99 188.96,106.99 188.87,106.91 188.87,106.78 189.06,106.58 189.06,105.84 v1(189.16,105.5) 188.61,104.83 188.61,104.3 189.04,103.22 J1F3.249
  TOP w0.165: v3(212.19,170.2) J3D1.AN10
  LAY9 w0.088: 207.65,160.31 208.17,160.31 210.57,162.71 211.18,162.71 211.41,162.94 211.41,163.38 211.66,163.63 211.66,169.67 v3(212.19,170.2)
  LAY9 w0.089: 207.65,160.31 202.49,155.15 201.77,155.15 195.44,148.82 195.44,141.28 190.94,136.78 190.94,132.6 191.61,131.92 191.61,131.71 191.61,131.71 191.61,131.39 190.76,130.54 190.76,129.59 190.77,129.58 191.61,128.09 191.61,127.59 190.76,126.74 190.76,125.88 191.59,124.12 191.59,123.62 190.75,122.77 190.75,121.74 191.59,120.28 191.59,119.82 190.75,118.97 190.75,117.26 190.49,117 190.49,115.42 189.91,114.84 189.91,113.19 189.06,112.34 189.06,110.78 189.91,109.93 189.91,109.39 189.06,108.55 189.06,108.54 189.06,108.53 189.06,106.44 189.02,106.41 189.02,106.06 189.16,105.92 189.16,105.92 v1(189.16,105.5)
M_DATA_B<36>: length 88.6
  TOP w0.088: J1F3.95 197.75,107.58 197.67,107.66 197.67,107.86 197.78,107.96 197.78,108.15 197.69,108.25 197.69,108.42 197.81,108.54 197.81,108.77 197.65,108.92 v1(197.22,108.92) 196.82,109.33 196.82,109.92 197.77,110.86 J1F2.95
  TOP w0.165: J3D1.AP12 v3(215.29,167.46)
  LAY9 w0.088: 212.54,157.63 215.69,160.78 215.69,167.06 v3(215.29,167.46)
  LAY9 w0.089: v1(197.22,108.92) 197.38,108.76 198.26,108.76 198.66,109.17 198.66,110.09 197.98,110.78 197.98,112.13 198.83,112.98 198.83,113.79 200.18,115.14 200.18,117.57 199.66,118.09 199.66,118.75 200.51,119.6 200.51,121.15 200.48,121.18 200.48,121.2 199.66,122.02 199.66,122.55 200.51,123.4 200.51,125.16 199.68,125.99 199.68,126.52 200.53,127.37 200.53,128.94 199.68,129.79 199.68,130.54 198.83,131.39 198.83,132.7 200.66,134.54 200.66,137.76 200.75,137.85 201.2,137.85 201.29,137.76 201.29,135.47 201.38,135.39 201.84,135.39 201.93,135.47 201.93,138.39 201.84,138.48 201.31,138.48 201.22,138.57 201.22,138.99 201.31,139.08 202.19,139.08 202.38,139.27 202.38,147.47 212.54,157.63
M_DATA_B<37>: length 89.3
  TOP w0.088: J1F3.240 196.7,100.97 196.25,102.76 196.25,103.23 v1(196.8,103.93) 196.8,104.71 196.89,104.8 197.01,104.8 197.1,104.89 197.1,105.02 197.03,105.1 196.75,105.1 196.67,105.17 196.67,105.3 196.76,105.39 196.98,105.39 197.07,105.48 197.07,105.64 196.92,105.78 J1F2.240
  TOP w0.165: J3D1.AT12 v3(215.29,165.63)
  LAY9 w0.088: v3(215.29,165.63) 215.29,165.28 214.9,164.88 214.9,164.55 215.08,164.37 215.08,164.15 214.9,163.97 214.9,163.64 215.14,163.4 215.14,162.66 214.77,162.3 214.77,161.97 215.02,161.71 215.02,161.01
  LAY9 w0.089: 215.02,161.01 212.28,158.27 201.75,147.73 201.75,147.11 201.75,147.11 201.75,140.76 199.74,138.75 199.74,135.84 199.65,135.75 199.2,135.75 199.11,135.84 199.11,137.41 199.02,137.5 198.56,137.5 198.47,137.41 198.47,134.88 198.56,134.79 199.65,134.79 199.74,134.7 199.74,134.51 198.19,132.97 198.19,132.18 198.41,131.96 198.41,131.17 199.26,130.32 199.26,129.59 199.27,129.58 200.11,128.09 200.11,127.59 199.26,126.74 199.26,125.88 200.09,124.12 200.09,123.62 199.25,122.77 199.25,121.74 200.09,120.28 200.09,119.82 199.25,118.97 199.25,118.16 198.77,117.69 198.77,116.97 198.41,116.61 198.41,113.19 197.56,112.35 197.56,111.57 196.72,110.74 196.72,108.77 196.28,108.33 196.28,107.79 196.8,107.27 v1(196.8,103.93)
M_DATA_B<38>: length 89.2
  TOP w0.088: J1F3.102 191.43,103.92 191.43,104.1 191.59,104.27 191.59,105.1 191.65,105.16 191.65,105.29 191.56,105.38 191.4,105.38 191.31,105.47 191.31,105.64 191.4,105.73 191.7,105.73 191.79,105.82 191.79,105.96 191.63,106.12 191.63,106.79 v1(191.73,107.13) 191.18,107.8 191.18,108.32 191.6,109.41 J1F2.102
  TOP w0.165: v3(212.19,169.29) J3D1.AP10
  LAY9 w0.088: v3(212.19,169.29) 213.04,168.44 213.04,166.73 212.9,166.58 212.9,162.72 209.08,158.91
  LAY9 w0.089: v1(191.73,107.13) 191.18,107.68 191.18,108.33 192.03,109.18 192.03,110.74 191.18,111.59 191.18,112.13 192.03,112.98 192.03,113.73 193.33,115.03 193.33,117.73 192.86,118.21 192.86,118.75 193.71,119.6 193.71,121.17 192.86,122.02 192.86,122.55 193.71,123.4 193.71,125.16 192.88,125.99 192.88,126.52 193.73,127.37 193.73,128.94 192.88,129.79 192.88,130.33 193.73,131.19 193.73,132.4 193.16,132.97 193.16,134.41 193.25,134.5 193.7,134.5 193.79,134.41 193.79,133.37 193.88,133.28 194.34,133.28 194.42,133.37 194.42,137.42 197.25,140.25 197.25,140.25 197.64,140.64 197.64,147.61 208.94,158.91 209.08,158.91
M_DATA_B<39>: length 89.2
  TOP w0.088: J1F3.247 190.74,103.22 190.31,104.3 190.31,104.83 v1(190.86,105.5) 190.76,105.84 190.76,106.58 190.57,106.78 190.57,106.91 190.66,106.99 190.99,106.99 191.07,107.08 191.07,107.24 190.99,107.33 190.85,107.33 190.76,107.42 190.76,108.33 190.59,108.5 190.59,108.77 J1F2.247
  TOP w0.165: v3(212.19,168.38) J3D1.AR10
  LAY9 w0.088: 208.49,159.36 208.58,159.45 208.74,159.45 211.1,161.82 211.3,161.82 212.49,163 212.49,166.91 212.59,167.01 212.59,167.63 212.19,168.02 v3(212.19,168.38)
  LAY9 w0.089: 208.49,159.36 197.01,147.87 197.01,145.71 196.89,145.59 196.89,145.42 197.01,145.3 197.01,145.11 196.71,144.81 196.71,144.59 197.01,144.29 197.01,144.16 196.71,143.86 196.71,143.68 197.01,143.38 197.01,143.13 196.71,142.83 196.71,142.6 197.01,142.3 197.01,142.07 196.71,141.77 196.71,141.55 197.01,141.25 197.01,140.91 196.57,140.47 196.57,140.47 193.26,137.16 193.26,137.03 193.78,136.52 193.78,136.16 193.64,136.03 193.36,136.03 192.8,136.58 192.68,136.58 192.35,136.25 192.35,136.13 192.7,135.79 192.7,135.67 192.52,135.49 192.52,132.73 193.31,131.94 193.31,131.39 192.46,130.54 192.46,129.59 192.47,129.58 193.31,128.09 193.31,127.59 192.46,126.74 192.46,125.88 193.29,124.12 193.29,123.62 192.45,122.77 192.45,121.74 193.29,120.28 193.29,119.82 192.45,118.97 192.45,115.24 191.61,114.41 191.61,113.19 190.76,112.34 190.76,110.78 191.61,109.93 191.61,109.39 190.76,108.54 190.76,106.03 190.86,105.92 v1(190.86,105.5)
M_DATA_B<40>: length 92.3
  TOP w0.088: J1F3.108 186.33,103.92 186.33,104.1 186.49,104.27 186.49,105.1 186.55,105.16 186.55,105.29 186.46,105.38 186.3,105.38 186.21,105.47 186.21,105.64 186.3,105.73 186.6,105.73 186.69,105.82 186.69,105.96 186.53,106.12 186.53,106.79 v1(186.63,107.13) 186.08,107.8 186.08,108.32 186.5,109.41 J1F2.108
  TOP w0.165: J3D1.AR8 v3(210.37,167.46)
  LAY9 w0.088: 205.68,161.02 206.56,161.9 207.32,161.9 207.75,162.34 207.75,162.49 207.67,162.58 207.67,162.91 207.9,163.14 208.21,163.14 209.27,164.2 209.68,164.2 209.86,164.38 209.86,166.69 210.37,167.19 v3(210.37,167.46)
  LAY9 w0.089: 205.68,161.02 205.31,160.65 205.18,160.65 204.75,161.09 204.62,161.09 204.3,160.77 204.3,160.64 204.73,160.21 204.73,160.08 204.41,159.76 204.29,159.76 203.85,160.19 203.73,160.19 203.4,159.87 203.4,159.74 203.84,159.31 203.84,159.18 203.51,158.86 203.39,158.86 202.95,159.3 202.83,159.3 202.51,158.97 202.51,158.85 202.94,158.41 202.94,158.29 202.62,157.96 202.49,157.96 202.16,158.3 202.03,158.3 201.71,157.98 201.71,157.85 202.04,157.52 202.04,157.39 201.76,157.11 201.03,157.11 193.53,149.61 193.53,142.27 191.77,140.5 186.45,135.19 186.45,132.85 186.93,132.38 186.93,131.39 187.78,130.54 187.78,129.79 188.63,128.94 188.63,127.37 187.78,126.52 187.78,125.99 188.61,125.16 188.61,123.4 187.76,122.55 187.76,122.02 188.58,121.2 188.58,121.18 188.61,121.15 188.61,119.6 187.76,118.75 187.76,118.21 188.24,117.73 188.24,117.19 188.4,117.03 188.4,116.32 187.48,115.39 187.48,114.66 186.93,114.11 186.93,112.98 186.08,112.13 186.08,111.59 186.93,110.74 186.93,109.21 186.08,108.36 186.08,107.68 v1(186.63,107.13)
M_DATA_B<41>: length 91.5
  TOP w0.088: J1F3.253 185.64,103.22 185.21,104.3 185.21,104.83 v1(185.76,105.5) 185.66,105.84 185.66,106.58 185.47,106.78 185.47,106.91 185.56,106.99 185.89,106.99 185.97,107.08 185.97,107.24 185.89,107.33 185.75,107.33 185.66,107.42 185.66,108.33 185.49,108.5 185.49,108.77 J1F2.253
  TOP w0.165: J3D1.AT7 v3(209.44,166.55)
  LAY9 w0.088: v3(209.44,166.55) 209.44,166.22 208.95,165.74 208.95,164.49 207.86,163.41 207.75,163.41 207.37,163.03 207.37,162.57 207.14,162.34 205.38,162.34 205.33,162.29 205.16,162.29 205.11,162.34
  LAY9 w0.089: 205.11,162.34 204.94,162.34 200.93,158.32 200.93,158 191.63,148.71 191.63,147.13 191.76,147 192.13,147 192.27,147.14 192.27,148.52 192.38,148.63 192.8,148.63 192.9,148.53 192.9,142.57 185.81,135.47 185.81,132.63 186.51,131.93 186.51,131.17 187.36,130.32 187.36,129.59 187.37,129.58 188.21,128.09 188.21,127.55 187.36,126.7 187.36,125.88 188.19,124.12 188.19,123.62 187.35,122.77 187.35,121.74 188.19,120.28 188.19,119.82 187.35,118.97 187.35,117.72 186.79,117.16 186.79,115.03 186.51,114.75 186.51,113.19 185.66,112.34 185.66,110.78 186.51,109.93 186.51,109.39 185.66,108.55 185.66,108.54 185.66,108.53 185.66,106.03 185.76,105.92 v1(185.76,105.5)
M_DATA_B<42>: length 90.4
  TOP w0.088: J1F3.115 180.75,107.58 180.67,107.66 180.67,107.86 180.78,107.96 180.78,108.15 180.69,108.25 180.69,108.42 180.81,108.54 180.81,108.77 180.65,108.92 v1(180.22,108.92) 179.82,109.33 179.82,109.92 180.77,110.86 J1F2.115
  TOP w0.165: v3(206.69,166.55) J3D1.AT5
  LAY9 w0.088: v3(206.69,166.55) 206.38,166.55 205.86,166.03 205.61,166.03 205.26,165.68 205.26,165.47 204.95,165.16 203.73,165.16 203.47,164.89 203.47,164.8 203.11,164.44 203.06,164.44 202.98,164.35
  LAY9 w0.089: 202.98,164.35 189.51,150.89 188.73,150.11 188.73,146.24 188.64,146.15 188.18,146.15 188.09,146.24 188.09,148.84 188,148.93 187.57,148.93 187.46,148.82 187.46,145.52 187.55,145.44 188.09,145.44 188.18,145.35 188.18,141.83 187.92,141.57 182.59,136.25 182.59,132.7 181.83,131.93 181.83,131.39 182.68,130.54 182.68,129.79 183.53,128.94 183.53,127.37 182.68,126.52 182.68,125.99 183.51,125.16 183.51,124.36 183.51,124.36 183.51,123.4 182.66,122.55 182.66,122.02 183.51,121.17 183.51,119.6 182.66,118.75 182.66,118.1 182.77,117.99 182.77,115.12 181.83,114.18 181.83,112.98 180.98,112.12 180.98,110.77 180.13,109.93 180.13,109.4 180.22,109.31 v1(180.22,108.92)
