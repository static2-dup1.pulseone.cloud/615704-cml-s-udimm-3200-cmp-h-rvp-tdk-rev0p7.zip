# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R3G42  10K  [SMR0603IA]  214.63 76.2 0 top
R3H4  549  [SMR1206A]  235.07 63.63 0 top
R3H8  549  [SMR1206A]  235.07 61.59 0 top
R3H9  549  [SMR1206A]  235.07 59.56 0 top
R3H10  0  [SMR0402IA]  226.82 58.04 270 top
R3H11  0  [SMR0402IA]  229.1 58.04 270 top
R3H12  0  [SMR0402IA]  230.25 58.04 270 top
R3H13  0  [SMR0402IA]  215.26 57.53 270 top
R3H14  0  [SMR0402IA]  216.4 57.53 270 top
R3H15  0  [SMR0402IA]  217.55 57.53 270 top
R3H16  0  [SMR0402IA]  218.69 57.53 270 top
R3H17  0  [SMR0402IA]  220.98 57.53 270 top
R3H18  0  [SMR0402IA]  222.12 57.53 270 top
R3H19  549  [SMR1206A]  235.07 57.53 0 top
R3H20  0  [SMR0402IA]  225.67 56.01 0 top
R3H21  100K  [SMR0402IA]  222.12 55.5 180 top
R3H22  549  [SMR1206A]  235.07 55.5 0 top
R3H23  100K  [SMR0402IA]  232.79 55.37 180 top
R3H24  0  [SMR0402IA]  225.67 54.86 0 top
R3H25  0  [SMR0402IA]  215.01 53.97 0 top
R3H26  0  [SMR0402IA]  225.67 53.72 0 top
R3H27  549  [SMR1206A]  235.07 53.47 0 top
R3H28  100K  [SMR0402IA]  221.23 53.21 0 top
R3H29  100K  [SMR0402IA]  231.9 53.08 0 top
R3H30  0  [SMR0402IA]  215.01 52.83 0 top
R3H33  100K  [SMR0402IA]  207.77 52.7 90 top
R3H34  0  [SMR0402IA]  225.67 52.58 0 top
R3H37  0  [SMR0402IA]  215.01 51.69 0 top
R3H38  0  [SMR0402IA]  217.67 51.69 270 top
R3H39  34K  [SMR0402IA]  226.56 51.31 270 top
R3H40  0  [SMR0402IA]  229.99 51.31 270 top
R3H41  0  [SMR0402IA]  221.23 50.93 0 top
R3H42  0  [SMR0402IA]  218.94 50.8 90 top
R3H43  0  [SMR0402IA]  220.09 50.8 90 top
R3H44  0  [SMR0402IA]  227.71 50.42 90 top
R3H45  0  [SMR0402IA]  228.85 50.42 90 top
R3L1  0  [SMR0603IA]  234.95 269.87 270 bottom
R3L2  0  [SMR0402IA]  241.3 266.83 180 bottom
R3L3  0  [SMR0402IA]  243.58 266.57 270 bottom
R3L4  0  [SMR0603IA]  234.95 265.68 90 bottom
R3M1  1K  [SMR0402IA]  222.12 259.59 180 bottom
R3M2  1K  [SMR0402IA]  219.45 259.59 0 bottom
R3M3  1K  [SMR0402IA]  221.23 258.06 0 bottom
R3M4  68.1K  [SMR0402IA]  220.34 258.06 180 bottom
R3M5  68.1K  [SMR0402IA]  221.23 254.76 0 bottom
R3M6  68.1K  [SMR0402IA]  220.34 254.76 180 bottom
R3M7  1K  [SMR0402IA]  222.12 253.24 180 bottom
R3M8  1K  [SMR0402IA]  219.45 253.24 0 bottom
R3M9  6.8  [SMR0805IA]  234.44 248.28 0 bottom
R3M10  1K  [SMR0402IA]  233.29 248.28 180 bottom
R3M11  6.8  [SMR0805IA]  211.07 248.28 0 bottom
R3M12  1K  [SMR0402IA]  209.93 248.28 180 bottom
R3M13  15K  [SMR0402IA]  237.99 247.9 0 bottom
R3M14  0  [SMR0402IA]  214.63 247.27 0 bottom
R3M15  0  [SMR0402IA]  237.99 247.14 0 bottom
R3M16  0  [SMR0402IA]  222.88 246.76 180 bottom
R3M17  0  [SMR0402IA]  234.56 246.12 90 bottom
R3M18  0  [SMR0402IA]  211.2 246.12 90 bottom
R3M19  0  [SMR0402IA]  232.66 245.74 90 bottom
R3M20  0  [SMR0402IA]  209.29 245.74 90 bottom
R3M21  0  [SMR0402IA]  232.66 244.98 0 bottom
R3M22  0  [SMR0402IA]  209.29 244.98 0 bottom
R3M23  0  [SMR0402IA]  222.88 244.47 90 bottom
R3M24  3.9  [SMR1005MA]  215.64 242.57 270 bottom
R3M25  3.9  [SMR1005MA]  239.14 242.31 270 bottom
R3M26  0  [SMR0402IA]  235.68 240.94 180 bottom
R3M27  0  [SMR0402IA]  236.47 240.92 0 bottom
R3M28  0  [SMR0402IA]  212.31 240.82 180 bottom
R3M29  0  [SMR0402IA]  213.1 240.79 0 bottom
R3M30  2.32K  [SMR0603A]  215.77 239.65 180 bottom
R3M31  2.32K  [SMR0603A]  239.14 239.39 180 bottom
R3M32  2.32K  [SMR0603A]  234.44 238.5 90 bottom
R3M33  2.32K  [SMR0603A]  211.07 238.38 90 bottom
R3M34  2.32K  [SMR0603A]  214.88 237.11 90 bottom
R3M35  2.32K  [SMR0603A]  238.37 236.85 90 bottom
R3M36  2.2  [SMR1206A]  226.56 236.22 90 bottom
R3M37  2.2  [SMR1206A]  224.4 236.22 90 bottom
R3M38  2.32K  [SMR0603A]  211.07 235.84 90 bottom
R3M39  2.32K  [SMR0603A]  234.44 235.71 90 bottom
R3M40  0.002  [SMR4_2512IG_RVP]  235.33 231.14 270 bottom
R3M41  0.002  [SMR4_2512IG_RVP]  225.42 231.14 270 bottom
R3M42  0.002  [SMR4_2512IG_RVP]  212.09 231.14 270 bottom
R3M45  0  [SMR0603IA]  228.34 254.25 270 bottom
R3P1  20  [SMR0402IA]  211.34 186.96 270 bottom
R3R1  0  [SMR0603IA]  207.39 151.64 45 bottom
R4A1  10K  [SMR0402IA]  199.51 286 90 top
R4A2  0  [SMR0402IA]  170.68 280.18 90 top
R4A3  10K  [SMR0402IA]  205.48 277.49 270 top
R4A4  15K  [SMR0402IA]  205.48 275.59 270 top
R4A5  0  [SMR0402IA]  172.72 274.32 0 top
R4A6  0  [SMR0402IA]  174.49 274.32 0 top
R4A7  0  [SMR0603IA]  204.97 273.3 180 top
R4A8  0  [SMR0603IA]  204.97 272.16 180 top
R4A9  0  [SMR0603IA]  204.85 271.02 180 top
R4A10  0  [SMR0603IA]  204.85 269.87 180 top
R4A11  0  [SMR0402IA]  198.24 267.59 270 top
R4A12  0  [SMR0402IA]  199.79 265.17 270 top
R4A13  220K  [SMR1005MD]  200.63 265.17 270 top
R4A14  220K  [SMR1005MD]  201.82 265.17 270 top
R4A15  0  [SMR0402IA]  203.6 265.17 270 top
R4A16  220K  [SMR1005MD]  204.47 265.17 270 top
R4A17  220K  [SMR1005MD]  205.62 265.17 270 top
R4A18  330  [SMR0402IA]  183.26 264.67 270 top
R4A19  330  [SMR0402IA]  194.94 264.67 0 top
R4A20  0  [SMR0402IA]  198.98 264.29 90 top
R4A21  0  [SMR0402IA]  202.79 264.29 90 top
R4A22  3.01K  [SMR0402IA]  190.24 263.78 90 top
R4A23  0  [SMR0402IA]  181.48 261.62 0 top
R4A24  0  [SMR0402IA]  192.27 260.98 90 top
R4A25  1K  [SMR0402IA]  181.48 259.84 0 top
R4B1  0  [SMR0402IA]  181.48 259.08 0 top
R4B2  1K  [SMR0402IA]  181.48 258.06 0 top
R4B3  0  [SMR0402IA]  191.64 257.81 0 top
R4B4  10K  [SMR0402IA]  181.48 257.3 0 top
R4B5  68.1K  [SMR0402IA]  198.09 256.79 180 top
R4B6  0  [SMR0402IA]  171.57 256.28 0 top
R4B7  0  [SMR0402IA]  192.53 256.16 180 top
R4B8  4.7K  [SMR0402IA]  193.92 256.16 90 top
R4B9  1K  [SMR0402IA]  197.2 255.9 0 top
R4B10  0.01  [SMR4_0603ID_RVP]  176.4 255.4 0 top
R4B11  1K  [SMR0402IA]  197.2 255.01 0 top
R4B12  10K  [SMR0402IA]  181.73 254.63 270 top
R4B13  10K  [SMR0402IA]  192.78 254.63 270 top
R4B14  68.1K  [SMR0402IA]  198.09 254.13 180 top
R4B15  0  [SMR0402IA]  189.73 253.74 90 top
R4B16  4.7K  [SMR0402IA]  190.5 253.74 90 top
R4B17  4.7K  [SMR0402IA]  191.26 253.74 90 top
R4B18  10K  [SMR0402IA]  192.02 253.74 90 top
R4B19  1K  [SMR0402IA]  197.23 253.24 0 top
R4B20  1  [SMR0603IA]  186.94 248.16 180 top
R4B21  1  [SMR0603IA]  200.4 248.03 180 top
R4B22  10K  [SMR0402IA]  189.23 247.9 270 top
R4B24  2.2  [SMR0603IA]  183 246.89 90 top
R4B25  2.2  [SMR0603IA]  196.34 246.89 90 top
R4B26  2.2  [SMR0603IA]  205.99 246.89 90 top
R4B27  0  [SMR0402IA]  189.48 245.49 270 top
R4B28  0  [SMR0603IA]  201.8 244.85 90 top
R4B29  0  [SMR0603IA]  188.46 244.73 90 top
R4B30  10uF  [SMC0603IA]  165.1 247.78 0 top
R4B35  1K  [SMR0402IA]  171.19 232.41 180 top
R4B40  499  [SMR0402IA]  180.97 227.68 180 top
R4B41  .002  [SMR4_1206IB_RVP]  178.18 244.85 270 top
R4C1  100  [SMR0402IA]  175.51 226.29 270 top
R4C2  56  [SMR0402IA]  176.27 226.29 270 top
R4C3  45.3  [SMR0402IA]  177.03 226.29 270 top
R4C4  1K  [SMR0402IA]  179.95 226.06 90 top
R4C5  1K  [SMR0402IA]  177.8 225.4 90 top
R4C6  20  [SMR0402IA]  177.8 223.77 90 top
R4C7  0  [SMR0402IA]  175.51 223.01 90 top
R4C8  220  [SMR0402IA]  176.27 223.01 90 top
R4C9  0  [SMR0402IA]  177.03 223.01 90 top
R4C10  62  [SMR0402IA]  175.89 217.42 270 top
R4C11  1K  [SMR0402IA]  174.11 217.3 0 top
R4C12  0  [SMR0402IA]  177.8 215.01 180 top
R4C13  0  [SMR0603IA]  175.64 212.47 270 top
R4C14  0  [SMR0603IA]  172.84 209.8 0 top
R4C15  0  [SMR0402IA]  179.83 209.55 180 top
R4C16  0.01  [SMR4_0603ID_RVP]  174.62 208.53 0 top
R4C19  0.01  [SMR4_0603ID_RVP]  172.36 203.15 90 top
R4C20  .005  [SMR0603MA]  178.81 203.07 270 top
R4C21  .005  [SMR0603MA]  184.15 203.07 270 top
R4C23  0.005  [SMR4_0805IC_RVP]  179.32 199.9 270 top
R4C24  0.005  [SMR4_0805IC_RVP]  181.35 199.9 270 top
R4C26  .005  [SMR0603MA]  176.91 199.64 270 top
R4C27  0  [SMR0603IA]  178.05 196.47 0 top
R4C28  0  [SMR0603IA]  182.62 196.47 180 top
R4C29  0  [SMR0603IA]  184.53 195.71 90 top
R4C30  0  [SMR0603IA]  185.67 195.71 90 top
R4D1  .002  [SMR4_1206IB_RVP]  176.53 192.4 270 top
R4D2  100  [SMR0603IA]  179.57 184.15 0 top
R4D5  1K  [SMR0402IA]  174.87 168.4 90 top
R4D8  0  [SMR0402IA]  174.87 166.5 90 top
R4G1  0  [SMR0402IA]  171.57 96.65 0 top
R4G2  0  [SMR0402IA]  172.46 95.88 180 top
R4G5  10K  [SMR0402IA]  188.97 94.11 180 top
R4G6  4.7K  [SMR0402IA]  188.97 93.22 180 top
R4G7  4.7K  [SMR0402IA]  182.49 93.09 180 top
R4G8  10K  [SMR0402IA]  181.61 92.2 0 top
R4G9  4.7K  [SMR0402IA]  188.97 92.2 180 top
R4G10  30  [SMR2512A]  195.83 85.22 0 top
R4G14  30  [SMR2512A]  195.83 81.28 0 top
R4G15  0  [SMR0402IA]  194.05 80.01 90 top
R4G16  0  [SMR0402IA]  178.68 78.61 0 top
R4G17  0  [SMR0402IA]  194.18 78.48 0 top
R4G18  220K  [SMR1005MD]  195.96 78.48 270 top
R4G19  0.002  [SMR4_2512IG_RVP]  182.88 73.53 180 top
R4G20  0.002  [SMR4_2512IG_RVP]  198.5 73.53 180 top
R4G21  0  [SMR0603IA]  205.23 72.64 90 top
R4G22  0  [SMR0402IA]  202.94 72.39 0 top
R4G23  51  [SMR1206A]  170.68 69.72 0 top
R4G24  51  [SMR1206A]  170.68 67.69 0 top
R4G25  75  [SMR1206A]  170.68 65.66 0 top
R4H1  75  [SMR1206A]  170.68 63.63 0 top
R4H2  75  [SMR1206A]  170.68 61.59 0 top
R4H3  22K  [SMR0402IA]  175 59.94 0 top
R4H4  0  [SMR0402IA]  193.04 59.05 270 top
R4H5  22k  [SMR0402IA]  197.61 59.05 270 top
R4H6  22K  [SMR0402IA]  175.89 58.8 180 top
R4H7  22k  [SMR0402IA]  182.24 58.8 180 top
R4H8  0  [SMR0402IA]  196.46 58.16 90 top
R4H11  22k  [SMR0402IA]  175 57.66 0 top
R4H12  22k  [SMR0402IA]  182.24 57.66 180 top
R4H13  0  [SMR0402IA]  186.16 57.53 270 top
R4H14  0  [SMR0402IA]  187.3 57.53 270 top
R4H15  0  [SMR0402IA]  188.45 57.53 270 top
R4H16  0  [SMR0402IA]  189.59 57.53 270 top
R4H17  0  [SMR0402IA]  199.26 56.64 270 top
R4H18  0  [SMR0402IA]  200.4 56.64 270 top
R4H19  0  [SMR0402IA]  201.54 56.64 270 top
R4H20  0  [SMR0402IA]  202.69 56.64 270 top
R4H21  22K  [SMR0402IA]  175 56.51 0 top
R4H22  22k  [SMR0402IA]  182.24 56.51 180 top
R4H23  100K  [SMR0402IA]  171.7 55.75 270 top
R4H24  0  [SMR0402IA]  185.53 55.5 0 top
R4H25  100K  [SMR0402IA]  193.02 55.5 180 top
R4H26  47K  [SMR0402IA]  175 55.37 0 top
R4H27  0  [SMR0402IA]  181.35 55.37 0 top
R4H28  100K  [SMR0402IA]  206.12 54.61 180 top
R4H29  22k  [SMR0402IA]  175.89 54.23 180 top
R4H30  47K  [SMR0402IA]  179.45 54.23 180 top
R4H31  100K  [SMR0402IA]  192.13 53.21 0 top
R4H32  0  [SMR0402IA]  199 53.08 0 top
R4H33  0  [SMR0402IA]  199 51.94 0 top
R4H34  100K  [SMR0402IA]  182.62 51.69 180 top
R4H35  13.3K  [SMR0402IA]  188.57 50.93 270 top
R4H36  0  [SMR0402IA]  192.13 50.93 0 top
R4H37  0  [SMR0402IA]  199 50.8 0 top
R4H38  88.7K  [SMR0402IA]  202.05 50.8 270 top
R4H39  1M  [SMR0402IA]  181.73 50.67 0 top
R4H40  0  [SMR0402IA]  186.29 50.04 90 top
R4H41  0  [SMR0402IA]  187.43 50.04 90 top
R4H42  0  [SMR0402IA]  189.72 50.04 90 top
R4H43  0  [SMR0402IA]  190.86 50.04 90 top
R4H44  0  [SMR0402IA]  205.23 50.04 0 top
R4H45  0  [SMR0402IA]  202.94 49.91 90 top
R4H46  0  [SMR0402IA]  204.08 49.91 90 top
R4H47  100K  [SMR0402IA]  175.26 49.78 270 top
R4H48  22k  [SMR0402IA]  177.03 49.53 0 top
R4H49  100  [SMR0402IA]  180.34 49.53 180 top
R4H50  0  [SMR0402IA]  174.11 48.89 90 top
R4H53  0  [SMR0402IA]  171.45 34.16 180 top
R4H54  0  [SMR0402IA]  171.45 33.02 180 top
R4J1  0  [SMR0402IA]  171.45 29.59 180 top
R4J3  0  [SMR0402IA]  171.45 27.3 180 top
R4J4  47K  [SMR0402IA]  174.87 6.86 270 top
R4J5  10K  [SMR0402IA]  174.87 8.25 90 top
R4J6  10K  [SMR0402IA]  171.45 6.86 270 top
R4J7  10K  [SMR0402IA]  172.46 6.86 270 top
R4J8  10K  [SMR0402IA]  173.48 5.97 90 top
R4J9  0  [SMR0402IA]  173.48 2.67 180 top
R4L1  0  [SMR0402IA]  172.33 279.91 0 bottom
R4L2  10K  [SMR0402IA]  171.45 262.38 270 bottom
R4M1  68.1K  [SMR0402IA]  205.35 258.06 270 bottom
R4M2  68.1K  [SMR0402IA]  204.34 258.06 270 bottom
R4M3  1K  [SMR0402IA]  206.12 257.94 90 bottom
R4M4  1K  [SMR0402IA]  203.58 257.94 90 bottom
R4M5  68.1K  [SMR0402IA]  205.23 254.76 0 bottom
R4M6  68.1K  [SMR0402IA]  204.34 254.76 180 bottom
R4M7  1K  [SMR0402IA]  206.12 253.24 180 bottom
R4M8  1K  [SMR0402IA]  203.45 253.24 0 bottom
R4M9  6.8  [SMR0805IA]  188.08 248.28 0 bottom
R4M10  1K  [SMR0402IA]  186.94 248.28 180 bottom
R4M11  0  [SMR0402IA]  192.53 247.65 270 bottom
R4M12  0  [SMR0402IA]  199.89 246.89 180 bottom
R4M13  0  [SMR0402IA]  188.21 246.12 90 bottom
R4M14  0  [SMR0402IA]  186.3 245.74 90 bottom
R4M15  0  [SMR0402IA]  186.3 244.98 0 bottom
R4M16  0  [SMR0402IA]  199.89 244.47 90 bottom
R4M17  3.9  [SMR1005MA]  192.65 242.31 270 bottom
R4M18  0  [SMR0402IA]  190.11 240.92 0 bottom
R4M19  0  [SMR0402IA]  189.35 240.92 180 bottom
R4M20  2.32K  [SMR0603A]  192.91 239.65 180 bottom
R4M21  2.32K  [SMR0603A]  188.21 238.38 90 bottom
R4M22  2.32K  [SMR0603A]  191.77 237.11 90 bottom
R4M23  2.2  [SMR1206A]  180.97 236.6 90 bottom
R4M24  2.2  [SMR1206A]  203.32 235.84 90 bottom
R4M25  2.2  [SMR1206A]  201.16 235.84 90 bottom
R4M26  2.32K  [SMR0603A]  188.21 235.84 90 bottom
R4M27  0.002  [SMR4_2512IG_RVP]  189 232.91 270 bottom
R4M28  0.002  [SMR4_2512IG_RVP]  202.31 231.14 270 bottom
R5A1  0  [SMR0402IA]  146.81 286.64 0 top
R5A2  200K  [SMR0402IA]  162.3 286 180 top
R5A3  100K  [SMR0402IA]  163.95 284.99 180 top
R5A4  2.2K  [SMR0402IA]  149.47 284.22 180 top
R5A5  0  [SMR0402IA]  162.17 284.1 90 top
R5A6  0  [SMR0402IA]  162.17 283.21 180 top
R5A7  10K  [SMR0402IA]  163.44 282.19 180 top
R5A8  47  [SMR0402IA]  148.46 281.43 90 top
R5A9  0  [SMR0402IA]  151.25 279.78 0 top
R5A10  22  [SMR0402IA]  159.25 279.78 180 top
R5A11  0  [SMR0603IA]  164.59 279.53 90 top
R5A12  0  [SMR0603IA]  165.73 279.53 90 top
R5A13  22  [SMR0402IA]  150.24 279.27 270 top
R5A14  47  [SMR0402IA]  158.36 278.64 0 top
R5A15  2.2K  [SMR0402IA]  151.25 278.38 0 top
R5A16  0  [SMR0603IA]  160.4 276.6 180 top
R5A17  0  [SMR0805IA]  163.83 276.48 180 top
R5A18  0  [SMR0805IA]  163.83 274.57 180 top
R5A19  10mOHM  [SMR4_0805IB_RVP]  136.14 273.91 0 top
R5A20  0  [SMR0603IA]  149.6 273.68 0 top
R5A21  0  [SMR0402IA]  144.52 261.49 270 top
R5A22  0  [SMR0402IA]  143.76 261.49 270 top
R5A23  0  [SMR0402IA]  146.17 273.18 90 top
R5A24  0  [SMR0402IA]  147.06 273.18 90 top
R5A25  10K  [SMR0402IA]  147.95 273.18 90 top
R5A26  10K  [SMR0402IA]  152.14 272.67 0 top
R5A27  0  [SMR0603IA]  149.6 272.41 0 top
R5A28  10K  [SMR0402IA]  136.52 267.97 180 top
R5A29  0  [SMR0402IA]  150.87 267.46 180 top
R5A30  0  [SMR0402IA]  153.41 267.08 270 top
R5A31  100K  [SMR0402IA]  137.41 266.83 90 top
R5A32  0  [SMR0402IA]  148.46 266.44 180 top
R5A33  2.2K  [SMR0402IA]  150.87 266.44 180 top
R5A34  100K  [SMR0402IA]  156.33 265.94 180 top
R5A35  100K  [SMR0402IA]  158.87 265.94 180 top
R5A36  100K  [SMR0402IA]  135.63 265.68 0 top
R5A37  0  [SMR0402IA]  148.46 265.43 180 top
R5A38  2.2K  [SMR0402IA]  150.87 265.43 180 top
R5A39  0  [SMR0402IA]  153.41 265.3 90 top
R5A40  10K  [SMR0402IA]  156.33 265.05 180 top
R5A41  100K  [SMR0402IA]  158.87 265.05 180 top
R5A42  10K  [SMR0402IA]  136.52 264.79 180 top
R5A43  0  [SMR0402IA]  156.33 264.16 180 top
R5A44  10K  [SMR0402IA]  158.87 264.16 180 top
R5A45  0  [SMR0402IA]  148.46 263.52 180 top
R5A46  10K  [SMR0402IA]  150.87 263.52 180 top
R5A47  10K  [SMR0402IA]  151.76 263.4 90 top
R5A48  100K  [SMR0402IA]  156.33 263.14 180 top
R5A49  10K  [SMR0402IA]  156.33 262.13 180 top
R5A50  100K  [SMR0402IA]  158.87 262.13 180 top
R5A51  1M  [SMR0402IA]  140.46 261.49 270 top
R5A52  0  [SMR0402IA]  143 261.49 270 top
R5A53  0  [SMR0402IA]  145.28 273.18 90 top
R5A54  0  [SMR0402IA]  143.51 273.18 90 top
R5A55  100K  [SMR0402IA]  147.06 261.49 270 top
R5A56  100K  [SMR0402IA]  148.84 261.49 270 top
R5A57  10K  [SMR0402IA]  156.33 261.11 180 top
R5A58  0  [SMR0402IA]  157.98 261.11 0 top
R5A59  2.2K  [SMR0402IA]  141.35 260.6 90 top
R5A60  2.2K  [SMR0402IA]  142.24 260.6 90 top
R5A61  0  [SMR0402IA]  145.41 260.6 90 top
R5A62  0  [SMR0402IA]  146.3 260.6 90 top
R5A63  0  [SMR0402IA]  155.44 260.09 0 top
R5A64  100K  [SMR0402IA]  158.87 260.09 180 top
R5B1  0  [SMR0402IA]  156.33 259.08 180 top
R5B2  0  [SMR0402IA]  157.98 259.08 0 top
R5B3  0  [SMR0402IA]  138.3 258.7 270 top
R5B4  0  [SMR0402IA]  139.19 258.7 270 top
R5B5  0  [SMR0402IA]  140.08 258.7 270 top
R5B6  2.2K  [SMR0402IA]  145.41 258.19 90 top
R5B7  2.2K  [SMR0402IA]  146.3 258.19 90 top
R5B8  100K  [SMR0402IA]  157.98 258.19 0 top
R5B9  0  [SMR0402IA]  151.51 257.68 90 top
R5B10  0  [SMR0402IA]  152.27 257.68 90 top
R5B11  0  [SMR0402IA]  153.03 257.68 90 top
R5B12  0  [SMR0402IA]  153.79 257.68 90 top
R5B13  3.3K  [SMR0402IA]  138.3 256.28 270 top
R5B14  2.2K  [SMR0402IA]  139.19 256.28 270 top
R5B15  2.2K  [SMR0402IA]  140.08 256.28 270 top
R5B16  0  [SMR0402IA]  147.19 248.66 90 top
R5B17  10uF  [SMC0603IA]  165.1 245.24 0 top
R5B19  0  [SMR0402IA]  147.19 243.84 90 top
R5B20  10K  [SMR0402IA]  147.95 243.84 90 top
R5B23  10K  [SMR0402IA]  147.19 241.81 0 top
R5B24  0  [SMR0402IA]  157.95 235.23 90 top
R5B25  0  [SMR0402IA]  148.33 241.04 180 top
R5B26  0  [SMR0402IA]  154.43 246.12 180 top
R5B27  0  [SMR0402IA]  157.19 235.33 90 top
R5B38  100K  [SMR0402IA]  147.19 236.09 270 top
R5B39  100K  [SMR0402IA]  147.95 236.09 270 top
R5B41  0  [SMR0402IA]  136.27 235.08 180 top
R5B43  0  [SMR0402IA]  136.27 234.22 180 top
R5B45  75  [SMR0402IA]  168.4 232.41 90 top
R5B48  0  [SMR0402IA]  164.84 230.04 90 top
R5B49  0  [SMR0402IA]  165.98 230.04 90 top
R5B52  0  [SMR0402IA]  150.49 230.25 90 top
R5B53  0  [SMR0402IA]  148.2 232.41 90 top
R5B54  0.01  [SMR4_0603ID_RVP]  164.97 249.05 0 top
R5B55  1.6  [SMR0805IA]  160.14 245.62 90 top
R5B56  0  [SMR0402IA]  162.3 247.39 180 top
R5B57  332  [SMR0402IA]  157.48 247.01 270 top
R5B58  100  [SMR0402IA]  149.35 245.36 270 top
R5B59  0  [SMR0402IA]  150.11 244.47 90 top
R5B60  0  [SMR0402IA]  152.01 245.24 0 top
R5B61  47.5K  [SMR0402IA]  155.32 244.73 90 top
R5B62  9.76K  [SMR0402IA]  157.48 245.36 0 top
R5B63  0  [SMR0402IA]  152.01 244.47 0 top
R5B64  0  [SMR0402IA]  153.67 244.6 270 top
R5B65  26.1K  [SMR0402IA]  154.43 243.71 90 top
R5B66  3.9  [SMR0402IA]  155.32 243.97 0 top
R5B67  121K  [SMR0402IA]  157.6 244.47 270 top
R5B68  169  [SMR0402IA]  158.36 244.47 270 top
R5B69  215K  [SMR0402IA]  149.73 242.57 180 top
R5B70  14.3K  [SMR0402IA]  150.36 241.87 0 top
R5B71  10K  [SMR0402IA]  149.09 240.79 90 top
R5B72  0  [SMR0603IA]  161.29 242.19 180 top
R5B73  0  [SMR0603IA]  159.89 241.04 0 top
R5B74  270  [SMR1005MD]  151.38 239.9 0 top
R5B75  475  [SMR0402IA]  150.49 238.25 90 top
R5B76  54.9K  [SMR0402IA]  151.27 239.14 270 top
R5B77  27.4K  [SMR0402IA]  152.27 237.45 90 top
R5B78  63.4  [SMR0402IA]  150.49 237.11 0 top
R5B79  130K  [SMR0402IA]  151.38 236.35 180 top
R5B80  0  [SMR0402IA]  160.27 236.85 0 top
R5B81  470  [SMR0402IA]  150.49 235.58 0 top
R5B82  0  [SMR0402IA]  158.72 235.46 270 top
R5B83  49.9  [SMR0402IA]  160.27 236.09 0 top
R5B84  13.3K  [SMR0402IA]  151.38 234.82 180 top
R5B85  0  [SMR0402IA]  163.44 234.73 90 top
R5B86  160  [SMR1005MD]  150.49 233.93 0 top
R5B87  10  [SMR0402IA]  164.21 234.73 90 top
R5B88  0  [SMR0603IA]  161.41 238.12 180 top
R5B89  8.2  [SMR0805IA]  153.54 234.57 90 top
R5B90  0  [SMR0603IA]  161.41 239.77 180 top
R5B91  0  [SMR0402IA]  156.43 235.33 90 top
R5C4  0  [SMR0402IA]  135.25 222.88 0 top
R5C5  0  [SMR0402IA]  135.25 221.99 0 top
R5C6  0  [SMR0402IA]  136.14 220.98 180 top
R5C7  100K  [SMR0402IA]  165.48 235.71 270 top
R5C8  100K  [SMR0402IA]  162.68 219.58 270 top
R5C9  10K  [SMR0402IA]  163.57 218.69 90 top
R5C10  0  [SMR0402IA]  169.92 237.74 270 top
R5C11  0  [SMR0402IA]  169.92 235.08 90 top
R5C12  0  [SMR0402IA]  164.59 218.69 90 top
R5C13  0  [SMR0402IA]  165.35 218.69 90 top
R5C14  0.01  [SMR4_0603ID_RVP]  161.92 215.39 0 top
R5C17  0.01  [SMR4_0603ID_RVP]  151 214.12 90 top
R5C18  10K  [SMR0402IA]  156.21 208.91 0 top
R5C19  0  [SMR0402IA]  157.32 210.06 90 top
R5C20  620  [SMR1206A]  165.6 212.6 90 top
R5C22  0  [SMR0402IA]  136.14 209.68 180 top
R5C23  0  [SMR0402IA]  136.14 209.68 90 top
R5C24  0  [SMR0402IA]  159.51 209.29 0 top
R5C25  0  [SMR0402IA]  164.97 208.91 270 top
R5C28  0  [SMR0402IA]  136.13 208.77 180 top
R5C29  34.8K  [SMR0402IA]  160.4 208.41 180 top
R5C30  100K  [SMR0402IA]  155.32 208.91 180 top
R5C33  10K  [SMR0402IA]  165.73 208.02 90 top
R5C34  59K  [SMR0402IA]  163.32 207.52 180 top
R5C35  100K  [SMR0402IA]  165.73 205.99 270 top
R5C36  100K  [SMR0402IA]  163.32 205.74 270 top
R5C38  1K  [SMR0402IA]  159.51 204.85 90 top
R5C39  0  [SMR0402IA]  160.27 204.85 90 top
R5C40  0  [SMR0402IA]  161.03 204.85 90 top
R5C41  100  [SMR0402IA]  161.79 204.85 90 top
R5C42  0  [SMR0402IA]  162.56 204.85 90 top
R5C43  0  [SMR0402IA]  164.08 204.85 0 top
R5C44  100  [SMR0402IA]  159.63 203.96 180 top
R5C45  0  [SMR0402IA]  151.38 203.33 270 top
R5C46  100K  [SMR0402IA]  157.09 202.44 90 top
R5C47  43.2K  [SMR0402IA]  159.89 202.94 270 top
R5C48  10K  [SMR0402IA]  152.14 202.44 90 top
R5C49  0  [SMR0402IA]  153.67 202.44 90 top
R5C50  0  [SMR0402IA]  153.67 201.29 270 top
R5C51  0  [SMR0805IA]  164.46 201.29 270 top
R5C52  0  [SMR0805IA]  166.62 201.17 90 top
R5C53  0  [SMR0402IA]  156.71 200.4 90 top
R5C54  0  [SMR0402IA]  160.14 199.52 270 top
R5C55  0  [SMR0402IA]  161.03 199.52 270 top
R5C56  0  [SMR0402IA]  161.92 199.52 270 top
R5C57  0  [SMR0402IA]  151.13 199.13 0 top
R5C58  100K  [SMR0402IA]  159.25 198.63 90 top
R5C59  0  [SMR0603IA]  162.94 198.5 270 top
R5C60  0  [SMR0402IA]  152.01 198.37 180 top
R5C61  0  [SMR0402IA]  153.03 198.25 90 top
R5C62  0  [SMR0402IA]  153.92 198.25 90 top
R5C63  22k  [SMR0402IA]  156.08 198.25 90 top
R5C64  100K  [SMR0402IA]  159.63 197.1 0 top
R5C69  100K  [SMR0402IA]  156.59 219.2 0 top
R5C70  0  [SMR0402IA]  151.13 196.59 90 top
R5C71  0  [SMR0402IA]  151.13 200.91 270 top
R5C72  100K  [SMR0402IA]  161.92 196.34 90 top
R5D1  2.2  [SMR1206A]  168.02 193.67 90 top
R5D3  0  [SMR0402IA]  152.78 191.39 180 top
R5D6  4.7K  [SMR0402IA]  134.23 190.5 0 top
R5D8  0  [SMR0402IA]  136.14 188.97 180 top
R5D9  0  [SMR0402IA]  136.14 188.09 180 top
R5D10  1K  [SMR0402IA]  135.25 185.29 0 top
R5D11  1K  [SMR0402IA]  136.14 184.4 180 top
R5D12  1K  [SMR0402IA]  136.14 183.51 180 top
R5D13  1K  [SMR0402IA]  135.25 182.62 0 top
R5D14  1K  [SMR0402IA]  135.25 181.74 0 top
R5D15  1K  [SMR0402IA]  136.14 180.85 180 top
R5D16  100K  [SMR0402IA]  155.82 177.8 270 top
R5D17  100K  [SMR0402IA]  156.59 177.8 270 top
R5D19  1K  [SMR0402IA]  152.01 176.91 90 top
R5D20  0  [SMR0402IA]  152.78 176.91 90 top
R5D21  0  [SMR0402IA]  155.06 176.91 90 top
R5D22  0  [SMR0402IA]  157.35 176.91 90 top
R5D23  100  [SMR0402IA]  151.51 175.13 90 top
R5D24  53.6K  [SMR0402IC]  152.4 175 270 top
R5D25  0  [SMR0805IA]  156.97 173.86 270 top
R5D26  0  [SMR0805IA]  159.25 172.85 90 top
R5D27  0.01  [SMR4_0603ID_RVP]  136.27 172.72 90 top
R5D28  0  [SMR0402IA]  152.4 172.46 90 top
R5D29  0.01  [SMR4_0603ID_RVP]  162.05 172.46 90 top
R5D30  0  [SMR0402IA]  154.3 171.58 270 top
R5D31  0  [SMR0603IA]  155.57 171.19 270 top
R5D32  100K  [SMR0402IA]  152.01 170.69 90 top
R5D33  0  [SMR0402IA]  152.78 170.69 90 top
R5D34  100K  [SMR0402IA]  153.54 170.69 90 top
R5D35  100K  [SMR0402IA]  151.89 169.8 0 top
R5D36  2.2  [SMR1206A]  165.22 165.99 270 top
R5D37  100K  [SMR0402IA]  148.08 164.97 0 top
R5D38  100K  [SMR0402IA]  155.7 164.34 90 top
R5D39  100K  [SMR0402IA]  153.41 163.19 180 top
R5D40  100K  [SMR0402IA]  154.55 163.07 0 top
R5D42  100K  [SMR0402IA]  156.46 168.15 180 top
R5E1  .002  [SMR4_1206IB_RVP]  161.29 160.65 0 top
R5E2  0  [SMR0402IA]  150.36 160.27 180 top
R5E3  10K  [SMR0402IA]  150.36 158.49 90 top
R5E4  0  [SMR0402IA]  154.05 156.84 0 top
R5E5  0  [SMR0402IA]  140.71 155.83 0 top
R5E7  0  [SMR0402IA]  154.05 155.32 0 top
R5E8  0  [SMR0402IA]  140.71 154.68 0 top
R5E10  10K  [SMR0402IA]  154.94 153.67 90 top
R5E11  0  [SMR0402IA]  155.7 153.67 90 top
R5E12  0  [SMR0402IA]  156.46 153.67 90 top
R5E13  0  [SMR0402IA]  157.98 152.91 180 top
R5E14  47K  [SMR0402IA]  157.98 153.67 90 top
R5E15  0  [SMR0402IA]  140.71 153.41 0 top
R5E17  0  [SMR0402IA]  134.65 152.79 0 top
R5E18  0  [SMR0402IA]  134.65 152.79 180 top
R5E19  0  [SMR0402IA]  140.71 152.27 0 top
R5E21  0  [SMR0402IA]  134.65 151.64 0 top
R5E22  0  [SMR0402IA]  134.65 151.64 180 top
R5E25  0  [SMR0402IA]  140.71 151 0 top
R5E27  0  [SMR0402IA]  134.65 150.5 180 top
R5E28  0  [SMR0402IA]  134.65 150.5 0 top
R5E29  0  [SMR0402IA]  140.71 149.86 0 top
R5E31  0  [SMR0402IA]  134.65 149.36 0 top
R5E32  0  [SMR0402IA]  134.65 149.36 180 top
R5E33  0  [SMR0402IA]  134.65 148.21 180 top
R5E34  0  [SMR0402IA]  134.65 148.21 0 top
R5E35  0  [SMR0402IA]  134.65 147.07 0 top
R5E36  0  [SMR0402IA]  134.65 147.07 180 top
R5E37  0  [SMR0402IA]  134.65 145.93 0 top
R5E38  0  [SMR0402IA]  134.65 145.93 180 top
R5E39  0  [SMR0402IA]  134.65 144.78 0 top
R5E40  0  [SMR0402IA]  134.65 144.78 180 top
R5E48  0  [SMR0603IA]  158.24 136.78 270 top
R5E49  0  [SMR0603IA]  159.51 136.78 270 top
R5E50  0  [SMR0603IA]  158.24 135.38 270 top
R5E51  0  [SMR0603IA]  159.51 135.38 270 top
R5E52  0  [SMR0603IA]  150.87 134.62 180 top
R5E53  0  [SMR0603IA]  152.27 134.62 180 top
R5E54  0  [SMR0603IA]  150.87 133.35 180 top
R5E55  0  [SMR0603IA]  152.27 133.35 180 top
R5E56  100K  [SMR0402IA]  150.36 154.68 180 top
R5E57  100  [SMR0603IA]  167.82 149.99 0 top
R5E58  0  [SMR0402IA]  153.82 148.41 270 top
R5E59  0  [SMR0402IA]  154.72 148.42 270 top
R5F3  0  [SMR0603IA]  149.22 116.58 0 top
R5F4  0  [SMR0603IA]  150.62 116.58 0 top
R5F5  0  [SMR0402IA]  153.92 115.44 0 top
R5F6  0  [SMR0402IA]  156.21 115.44 0 top
R5F7  0  [SMR0603IA]  149.22 115.31 0 top
R5F8  0  [SMR0603IA]  150.62 115.31 0 top
R5F9  620  [SMR1206A]  141.35 111.76 0 top
R5F10  10K  [SMR0402IA]  140.08 110.36 270 top
R5F11  0  [SMR0603IA]  135.12 109.85 180 top
R5F12  0.01  [SMR4_0603ID_RVP]  137.92 109.85 270 top
R5F13  0.005  [SMR4_0805IC_RVP]  146.17 107.06 270 top
R5F14  0  [SMR0402IA]  151.13 106.68 0 top
R5F15  0  [SMR0402IA]  152.9 106.73 0 top
R5F16  0  [SMR0402IA]  151.13 105.92 0 top
R5F17  0  [SMR0402IA]  152.9 105.92 0 top
R5F18  34.8K  [SMR0402IA]  142.87 103.5 270 top
R5F19  0  [SMR0402IA]  144.78 103.5 270 top
R5F20  0  [SMR0402IA]  141.35 102.61 90 top
R5F21  160K  [SMR1005MA]  143.76 102.61 90 top
R5F22  0  [SMR0402IA]  146.68 102.61 180 top
R5G1  200K  [SMR0402IA]  164.59 96.39 0 top
R5G2  10K  [SMR0402IA]  166.49 96.39 0 top
R5G4  5.1K  [SMR0402IA]  166.49 95.5 0 top
R5G5  0  [SMR0603IA]  158.11 95.38 270 top
R5G6  0  [SMR0402IA]  169.16 95.12 0 top
R5G7  0  [SMR0402IA]  155.44 94.36 180 top
R5G8  10  [SMR0402IA]  169.16 94.23 0 top
R5G9  0  [SMR0402IA]  170.05 93.22 180 top
R5G10  0  [SMR0603IA]  160.4 92.96 270 top
R5G11  0  [SMR0603IA]  158.11 92.58 90 top
R5G12  0  [SMR0402IA]  170.05 92.33 180 top
R5G13  10K  [SMR0402IA]  167.64 91.57 180 top
R5G14  0.01  [SMR4_0603ID_RVP]  156.84 87.37 0 top
R5G15  0.005  [SMR0805IC]  161.67 87.37 180 top
R5G16  0.005  [SMR0805IC]  161.67 84.83 180 top
R5G17  0  [SMR0402IA]  148.33 83.06 180 top
R5G18  0  [SMR0402IA]  167.64 82.93 0 top
R5G19  10K  [SMR0402IA]  160.02 81.41 0 top
R5G20  100K  [SMR0402IA]  168.65 80.52 270 top
R5G21  0  [SMR0402IA]  167.64 79.63 90 top
R5G22  0  [SMR0402IA]  153.03 78.23 270 top
R5G23  0  [SMR0402IA]  154.17 78.23 270 top
R5G24  10K  [SMR0402IA]  155.32 78.23 270 top
R5G25  0  [SMR0402IA]  156.46 78.23 270 top
R5G26  0  [SMR0402IA]  157.6 78.23 270 top
R5G29  0  [SMR0402IA]  150.49 69.72 0 top
R5G30  0  [SMR0402IA]  150.49 68.58 0 top
R5G33  0  [SMR0402IA]  150.49 67.44 0 top
R5G34  0  [SMR0402IA]  150.49 66.29 0 top
R5G35  0  [SMR0402IA]  150.49 65.15 0 top
R5H1  0  [SMR0402IA]  150.49 64.01 0 top
R5H2  0  [SMR0402IA]  150.49 62.86 0 top
R5H3  0  [SMR0402IA]  150.49 61.72 0 top
R5H4  0  [SMR0402IA]  150.49 60.58 0 top
R5H5  0  [SMR0402IA]  150.49 59.43 0 top
R5H6  0  [SMR0402IA]  134.62 39.5 270 top
R5H7  0  [SMR0402IA]  145.79 39.24 270 top
R5H8  0  [SMR0402IA]  146.93 39.24 270 top
R5H9  0  [SMR0402IA]  149.98 39.24 270 top
R5H10  0  [SMR0402IA]  151.13 39.24 270 top
R5H11  0  [SMR0402IA]  140.58 38.35 90 top
R5H12  0  [SMR0402IA]  142.36 38.35 90 top
R5H13  0  [SMR0402IA]  143.12 38.35 90 top
R5H14  1K  [SMR0402IA]  144.65 38.35 90 top
R5H15  0  [SMR0402IA]  148.97 38.35 90 top
R5J1  2.2K  [SMR0402IA]  170.56 31.88 0 top
R5J2  2.2K  [SMR0402IA]  170.56 30.73 0 top
R5J3  0  [SMR0402IA]  143.12 25.02 180 top
R5J4  10K  [SMR0402IA]  144.9 25.02 180 top
R5J5  0  [SMR0402IA]  137.16 22.86 0 top
R5J6  0  [SMR0402IA]  138.04 22.86 0 top
R5J7  10K  [SMR0402IA]  134.62 22.48 90 top
R5J8  0  [SMR0402IA]  140.08 9.52 270 top
R5J9  0  [SMR0402IA]  140.97 9.52 270 top
R5J10  0  [SMR0402IA]  141.73 9.52 270 top
R5J11  0  [SMR0402IA]  142.49 9.52 270 top
R5J12  0  [SMR0402IA]  143.25 9.52 270 top
R5J13  0  [SMR0402IA]  145.03 9.52 270 top
R5J14  0  [SMR0402IA]  145.92 9.52 270 top
R5J15  0  [SMR0402IA]  146.81 9.52 270 top
R5J16  0  [SMR0402IA]  148.97 9.52 270 top
R5J17  0  [SMR0402IA]  149.86 9.52 270 top
R5J18  0  [SMR0402IA]  135.12 8.63 90 top
R5J19  0  [SMR0402IA]  136.01 8.63 90 top
R5J20  0  [SMR0402IA]  136.77 8.63 90 top
R5J21  0  [SMR0402IA]  137.54 8.63 90 top
R5J22  0  [SMR0402IA]  138.3 8.63 90 top
R5J23  0  [SMR0402IA]  139.19 8.63 90 top
R5L1  0  [SMR0402IA]  162.81 271.27 90 bottom
R5L2  0  [SMR0402IA]  161.92 271.27 90 bottom
R5L3  200  [SMR0402IA]  170.56 270.89 0 bottom
R5L4  0  [SMR0402IA]  161.03 270 0 bottom
R5L5  200  [SMR0402IA]  170.56 269.37 0 bottom
R5L6  4.75k  [SMR1005MA]  162.05 268.86 270 bottom
R5L7  0  [SMR0402IA]  160.9 268.86 270 bottom
R5L8  100K  [SMR0402IA]  162.05 266.7 180 bottom
R5L9  100K  [SMR0402IA]  158.87 265.94 180 bottom
R5L10  3.01K  [SMR0402IA]  170.56 265.68 0 bottom
R5L11  0  [SMR0402IA]  156.33 265.56 180 bottom
R5L12  0  [SMR0402IA]  154.55 265.56 0 bottom
R5L13  10K  [SMR0402IA]  158.87 264.16 180 bottom
R5L14  100K  [SMR0402IA]  156.33 264.16 180 bottom
R5L15  10K  [SMR0402IA]  158.87 263.4 180 bottom
R5L16  2.2K  [SMR0402IA]  156.33 263.14 180 bottom
R5L17  10K  [SMR0402IA]  166.87 262.89 180 bottom
R5L18  10K  [SMR0402IA]  170.56 262.38 180 bottom
R5L19  200  [SMR0402IA]  162.56 262.38 180 bottom
R5L20  100K  [SMR0402IA]  158.87 262.13 180 bottom
R5L21  2.2K  [SMR0402IA]  156.33 262.13 180 bottom
R5L22  10K  [SMR0402IA]  166.87 262.13 180 bottom
R5L23  100K  [SMR0402IA]  159.63 261.11 0 bottom
R5L24  0  [SMR0402IA]  158.87 261.11 180 bottom
R5L25  0  [SMR0402IA]  155.44 261.11 0 bottom
R5M1  1.58K  [SMR0603IA]  160.52 242.95 180 bottom
R5M2  2.2  [SMR1206A]  171.57 243.08 180 bottom
R5M3  1.58K  [SMR0603IA]  158.36 241.68 180 bottom
R5M4  1.15K  [SMR0402IA]  159.38 241.04 90 bottom
R5M5  1K  [SMR0402IA]  160.14 241.04 90 bottom
R5M6  100K  [SMR0402IA]  149.35 239.14 0 bottom
R5M7  63.4  [SMR0402IA]  151.25 239.01 90 bottom
R5M8  143K  [SMR0402IA]  151.38 237.87 180 bottom
R5M9  24K  [SMR0402IA]  152.78 238.25 270 bottom
R5M10  100K  [SMR0402IA]  155.19 237.23 180 bottom
R5M11  30.1K  [SMR0402IA]  151.38 236.98 180 bottom
R5M12  68.1K  [SMR0402IA]  151.38 236.22 180 bottom
R5M13  100K  [SMR0402IA]  152.9 236.35 0 bottom
R5M14  0  [SMR0402IA]  154.68 236.35 0 bottom
R5M15  100K  [SMR0402IA]  151.51 235.08 180 bottom
R5M16  0  [SMR0402IA]  151.46 234.28 180 bottom
R5U1  30K  [SMR0402IA]  164.59 92.33 180 bottom
R5U2  2.2  [SMR1206A]  147.82 91.95 0 bottom
R5V1  10K  [SMR0402IA]  143.12 38.35 90 bottom
R5V2  10K  [SMR0402IA]  139.82 38.35 90 bottom
R5V3  10K  [SMR0402IA]  138.81 38.35 90 bottom
R5V4  10K  [SMR0402IA]  136.14 38.35 90 bottom
R5V5  10K  [SMR0402IA]  135.38 38.35 90 bottom
R5V6  10K  [SMR0402IA]  134.62 38.35 90 bottom
R5V7  10K  [SMR0402IA]  141.47 38.35 90 bottom
R5V8  10K  [SMR0402IA]  137.92 38.35 90 bottom
R5W1  0  [SMR0201IA]  145.59 5.99 270 bottom
R5W2  0  [SMR0201IA]  146.15 5.46 90 bottom
R6A1  0  [SMR0402IA]  122.17 286.76 270 top
R6A2  0  [SMR0402IA]  126.36 286.76 270 top
R6A3  0.01  [SMR4_0603ID_RVP]  110.23 286.38 0 top
R6A4  0.01  [SMR4_0603ID_RVP]  113.53 286.38 270 top
R6A5  0  [SMR0402IA]  121.15 285.88 90 top
R6A6  0  [SMR0402IA]  123.19 285.88 90 top
R6A7  0  [SMR0402IA]  123.95 285.88 90 top
R6A8  0  [SMR0402IA]  125.34 285.88 90 top
R6A9  0  [SMR0603IA]  108.83 284.99 90 top
R6A10  0  [SMR0402IA]  121.15 284.35 270 top
R6A11  0  [SMR0402IA]  122.17 284.35 270 top
R6A12  0  [SMR0402IA]  123.19 284.35 270 top
R6A13  0  [SMR0402IA]  105.41 283.84 0 top
R6A14  0  [SMR0402IA]  123.95 283.46 90 top
R6A15  0  [SMR0402IA]  125.34 283.46 90 top
R6A16  0  [SMR0402IA]  126.36 283.46 90 top
R6A17  0  [SMR0402IA]  129.03 283.46 0 top
R6A18  0.01  [SMR4_0603ID_RVP]  114.93 282.57 0 top
R6A19  0  [SMR0402IA]  108.07 282.45 0 top
R6A20  0  [SMR0402IA]  101.98 281.94 90 top
R6A21  0  [SMR0402IA]  102.74 281.94 90 top
R6A22  0  [SMR0402IA]  103.5 281.94 90 top
R6A23  0  [SMR0402IA]  129.03 281.68 0 top
R6A24  0  [SMR0805IA]  105.66 281.56 270 top
R6A25  0  [SMR0402IA]  101.98 280.41 270 top
R6A26  0  [SMR0402IA]  102.74 280.41 270 top
R6A27  0  [SMR0402IA]  103.5 280.41 270 top
R6A28  0  [SMR0603IA]  110.49 280.29 0 top
R6A29  0.01  [SMR4_0603ID_RVP]  113.28 280.29 0 top
R6A30  100K  [SMR0402IA]  118.99 280.16 180 top
R6A31  0  [SMR0805IA]  108.96 279.91 180 top
R6A32  0  [SMR0402IA]  113.91 279.02 180 top
R6A33  10K  [SMR0402IA]  115.82 279.02 180 top
R6A34  0.01  [SMR4_0603ID_RVP]  104.39 277.87 180 top
R6A35  0  [SMR0402IA]  109.47 276.73 270 top
R6A36  100K  [SMR0402IA]  117.85 276.1 0 top
R6A37  10K  [SMR0402IA]  117.85 275.33 0 top
R6A38  10K  [SMR0402IA]  118.74 274.57 180 top
R6A39  10K  [SMR0402IA]  129.03 274.45 0 top
R6A40  0  [SMR0402IA]  109.47 274.06 90 top
R6A41  0  [SMR0402IA]  110.36 274.06 90 top
R6A42  10K  [SMR0402IA]  117.85 273.81 0 top
R6A43  100K  [SMR0402IA]  121.53 273.56 270 top
R6A44  10K  [SMR0402IA]  124.33 273.56 270 top
R6A45  10K  [SMR0402IA]  125.34 273.56 270 top
R6A46  10K  [SMR0402IA]  126.36 273.56 270 top
R6A47  10K  [SMR0402IA]  127.5 273.56 270 top
R6A48  0  [SMR0402IA]  129.41 273.56 270 top
R6A49  10K  [SMR0402IA]  118.74 273.05 180 top
R6A50  22  [SMR0402IA]  128.52 272.67 90 top
R6A51  10K  [SMR0402IA]  130.3 272.67 90 top
R6A52  0  [SMR0402IA]  113.03 272.54 0 top
R6A53  0  [SMR0402IA]  115.82 272.54 180 top
R6A54  100K  [SMR0402IA]  123.31 271.52 180 top
R6A55  10K  [SMR0402IA]  130.3 271.14 180 top
R6A56  100K  [SMR0402IA]  120.39 270.51 0 top
R6A57  10K  [SMR0402IA]  109.85 270.25 90 top
R6A58  619K  [SMR0402IA]  115.31 269.75 90 top
R6A59  10K  [SMR0402IA]  117.34 269.62 180 top
R6A60  100K  [SMR0402IA]  119.38 269.49 270 top
R6A61  10K  [SMR0402IA]  124.33 269.49 90 top
R6A62  10K  [SMR0402IA]  125.34 269.49 90 top
R6A63  10K  [SMR0402IA]  126.36 269.49 90 top
R6A64  0  [SMR0402IA]  127.5 269.49 90 top
R6A65  100K  [SMR0402IA]  117.34 268.73 180 top
R6A66  10K  [SMR0402IA]  115.31 268.48 270 top
R6A67  1K  [SMR0402IA]  124.07 268.35 0 top
R6A68  0  [SMR0402IA]  118.49 267.71 0 top
R6A69  100K  [SMR0402IA]  124.96 267.46 180 top
R6A70  100K  [SMR0402IA]  117.34 267.33 180 top
R6A71  47K  [SMR0402IA]  112.9 267.21 180 top
R6A72  10K  [SMR0402IA]  98.42 266.7 180 top
R6A73  100K  [SMR0402IA]  124.07 266.44 0 top
R6A74  10K  [SMR0402IA]  128.52 265.68 90 top
R6A75  47K  [SMR0402IA]  124.96 265.56 180 top
R6A76  10K  [SMR0402IA]  129.79 264.67 180 top
R6A77  10mOHM  [SMR4_0805IB_RVP]  107.82 262.51 0 top
R6A78  10K  [SMR0402IA]  111.5 261.24 270 top
R6A79  10K  [SMR0402IA]  114.42 261.24 180 top
R6A80  0  [SMR0402IA]  102.1 260.73 180 top
R6A81  11.5K  [SMR0402IA]  109.98 260.35 90 top
R6A82  75K  [SMR0402IA]  110.74 260.35 90 top
R6A83  10mOHM  [SMR4_0805IB_RVP]  126.49 260.35 0 top
R6A84  0  [SMR0402IA]  102.1 259.84 180 top
R6A85  10K  [SMR0402IA]  104.26 279.53 90 top
R6A86  10K  [SMR0402IA]  104.26 282.7 90 top
R6A87  10K  [SMR0402IA]  104.26 284.48 270 top
R6A88  10K  [SMR0402IA]  104.26 281.3 270 top
R6B1  200  [SMR0402IA]  102.1 258.95 180 top
R6B2  10K  [SMR0402IA]  102.1 258.06 180 top
R6B3  0  [SMR0402IA]  128.65 258.06 0 top
R6B4  0  [SMR0402IA]  128.65 257.17 0 top
R6B5  10K  [SMR0402IA]  102.1 257.05 180 top
R6B6  10K  [SMR0402IA]  102.23 256.16 0 top
R6B7  0  [SMR0402IA]  128.65 256.16 0 top
R6B8  3.3K  [SMR0402IA]  129.54 255.4 180 top
R6B9  10K  [SMR0402IA]  102.1 254.51 90 top
R6B10  0  [SMR0402IA]  98.04 252.35 90 top
R6B11  49.9  [SMR0402IA]  101.21 252.98 180 top
R6B12  10K  [SMR0402IA]  113.41 251.08 270 top
R6B13  0  [SMR0402IA]  111.37 250.19 90 top
R6B14  10K  [SMR0402IA]  112.39 250.19 90 top
R6B15  0  [SMR0402IA]  91.05 245.87 180 top
R6B16  0  [SMR0402IA]  98.55 249.81 0 top
R6B17  0  [SMR0402IA]  101.09 249.84 270 top
R6B18  0  [SMR0402IA]  101.85 249.84 270 top
R6B19  10K  [SMR0402IA]  102.61 249.84 270 top
R6B20  0.002  [SMR4_2512IG_RVP]  120.26 246.89 0 top
R6B21  10K  [SMR0402IA]  105.53 244.22 180 top
R6B22  10K  [SMR0402IA]  105.53 242.95 180 top
R6B23  10K  [SMR0402IA]  105.53 241.68 180 top
R6B24  10mOHM  [SMR4_0805IB_RVP]  124.07 239.01 0 top
R6B25  15K  [SMR0402IA]  108.33 235.71 270 top
R6B26  10K  [SMR0402IA]  109.09 234.82 90 top
R6B27  10K  [SMR0402IA]  109.85 234.82 90 top
R6B35  10K  [SMR0402IA]  100.33 249.84 270 top
R6C7  0  [SMR0201IA]  120.19 222.32 0 top
R6C9  0  [SMR0201IA]  120.72 221.69 180 top
R6C10  0  [SMR0402IA]  120.9 220.47 180 top
R6C11  0  [SMR0603IA]  105.15 220.34 90 top
R6C12  0  [SMR0603IA]  106.29 220.34 90 top
R6C13  0  [SMR0402IA]  120.9 219.71 180 top
R6C14  0  [SMR0603IA]  98.17 195.4 90 top
R6C15  0  [SMR0603IA]  99.31 195.4 90 top
R6C16  0  [SMR0603IA]  113.26 185.14 315 top
R6C17  0  [SMR1206IA]  130.55 207.77 270 top
R6C18  0  [SMR0603IA]  112.45 184.33 315 top
R6C19  10K  [SMR0402IA]  99.56 184.73 270 top
R6C20  10K  [SMR0402IA]  127.76 196.21 270 top
R6C21  15K  [SMR0402IA]  128.52 195.32 90 top
R6D1  0  [SMR0603IA]  114.93 191.64 270 top
R6D2  0  [SMR0603IA]  116.07 191.64 270 top
R6D3  220K  [SMR1005MD]  117.98 191.51 180 top
R6D4  220K  [SMR1005MD]  118.87 191.51 0 top
R6D5  220K  [SMR1005MD]  126.36 191.51 180 top
R6D6  220K  [SMR1005MD]  127.12 191.51 0 top
R6D7  0  [SMR0402IA]  130.42 191.39 270 top
R6D8  0  [SMR0402IA]  132.33 191.39 270 top
R6D9  0  [SMR0402IA]  133.22 191.39 270 top
R6D10  0  [SMR0402IA]  109.47 182.19 180 top
R6D11  0  [SMR0402IA]  109.47 183.08 180 top
R6D12  0  [SMR0201IA]  108.78 184.04 180 top
R6D13  0  [SMR0201IA]  108.78 184.65 180 top
R6D14  0  [SMR0201IA]  107.06 196.72 180 top
R6D15  0  [SMR0201IA]  107.06 197.36 180 top
R6D16  0  [SMR0402IA]  107.44 195.83 180 top
R6D17  0  [SMR0402IA]  107.44 194.89 180 top
R6D18  0  [SMR0201IA]  120.85 190.83 90 top
R6D19  0  [SMR0201IA]  121.46 190.83 90 top
R6D20  0  [SMR0201IA]  123.9 190.8 90 top
R6D21  0  [SMR0201IA]  124.53 190.8 90 top
R6D22  0  [SMR0402IA]  131.31 190.5 90 top
R6D23  4.7K  [SMR0402IA]  130.42 188.97 270 top
R6D24  4.7K  [SMR0402IA]  133.22 188.97 270 top
R6D25  22  [SMR0402IA]  128.39 188.09 90 top
R6D26  4.7K  [SMR0402IA]  131.31 188.09 90 top
R6D27  4.7K  [SMR0402IA]  132.33 188.09 90 top
R6D28  4.7K  [SMR0402IA]  134.11 188.09 90 top
R6D30  22  [SMR0402IA]  125.85 186.05 180 top
R6D31  0  [SMR0603IA]  99.44 178.18 90 top
R6D32  1K  [SMR0402IA]  125.85 184.4 180 top
R6D33  0  [SMR0603IA]  102.36 175.39 90 top
R6D34  0.005  [SMR4_0805IC_RVP]  100.83 175.26 90 top
R6D35  1K  [SMR0402IA]  124.96 183.51 0 top
R6D36  1K  [SMR0402IA]  125.85 182.24 180 top
R6D37  1K  [SMR0402IA]  124.96 181.35 0 top
R6D38  0  [SMR0402IA]  110.23 180.97 0 top
R6D39  0  [SMR0402IA]  112.01 180.97 180 top
R6D40  0.022  [SMR4_0603ID_RVP]  104.39 179.83 0 top
R6D41  0  [SMR0402IA]  110.23 179.7 0 top
R6D42  0  [SMR0402IA]  112.01 179.7 180 top
R6D43  1K  [SMR0402IA]  128.52 178.56 270 top
R6D44  1K  [SMR0402IA]  130.3 178.56 270 top
R6D45  0  [SMR0402IA]  114.42 178.94 180 top
R6D46  1K  [SMR0402IA]  127.63 177.67 90 top
R6D47  1K  [SMR0402IA]  129.41 177.67 90 top
R6D48  10K  [SMR0402IA]  114.55 178.18 0 top
R6D49  620  [SMR0402IA]  99.31 176.66 270 top
R6D50  0  [SMR0603IA]  105.79 176.66 180 top
R6D51  100K  [SMR0402IA]  115.18 177.42 0 top
R6D52  0  [SMR0402IA]  116.58 175.13 180 top
R6D53  10K  [SMR0402IA]  117.47 175.13 90 top
R6D54  0  [SMR0603IA]  105.79 175.51 180 top
R6D55  0  [SMR0402IA]  116.58 175.89 180 top
R6D56  0  [SMR0402IA]  118.23 175.13 0 top
R6D57  1M  [SMR0402IA]  108.07 173.61 0 top
R6D58  0  [SMR0603IA]  133.47 172.59 0 top
R6D59  0  [SMR0402IA]  108.2 171.96 180 top
R6D60  0  [SMR0402IA]  108.2 171.96 90 top
R6D61  0  [SMR0402IA]  108.96 171.96 90 top
R6D62  0  [SMR0402IA]  108.96 171.96 0 top
R6D63  0  [SMR0603IA]  133.47 171.32 0 top
R6D64  0  [SMR0603IA]  133.47 170.05 0 top
R6D65  60.4  [SMR0402IA]  106.07 167.39 270 top
R6D66  30  [SMR0402IA]  100.83 167.13 270 top
R6D67  0  [SMR0402IA]  101.72 166.24 90 top
R6D68  113  [SMR0402IA]  115.69 163.96 225 top
R6E1  100  [SMR0402IA]  118.77 154.69 90 top
R6E2  0  [SMR0402IA]  130.84 153.93 0 top
R6E3  0  [SMR0402IA]  130.84 153.93 180 top
R6E4  0  [SMR0402IA]  130.84 152.79 180 top
R6E5  0  [SMR0402IA]  130.84 152.79 0 top
R6E6  0  [SMR0402IA]  130.84 151.64 180 top
R6E7  0  [SMR0402IA]  130.84 151.64 0 top
R6E8  0  [SMR0402IA]  130.84 150.5 0 top
R6E9  0  [SMR0402IA]  130.84 150.5 180 top
R6E10  0  [SMR0402IA]  130.84 149.36 0 top
R6E11  0  [SMR0402IA]  130.84 149.36 180 top
R6E12  0  [SMR0402IA]  130.84 148.21 180 top
R6E13  0  [SMR0402IA]  130.84 148.21 0 top
R6E14  0  [SMR0402IA]  130.84 147.07 180 top
R6E15  0  [SMR0402IA]  130.84 147.07 0 top
R6E16  0  [SMR0402IA]  130.84 145.93 180 top
R6E17  0  [SMR0402IA]  130.84 145.93 0 top
R6F1  10K  [SMR0402IA]  110.87 118.24 270 top
R6F2  4.7K  [SMR0402IA]  99.06 117.35 90 top
R6F3  1K  [SMR0402IA]  104.9 117.35 90 top
R6F4  0  [SMR0402IA]  106.04 117.35 90 top
R6F5  10K  [SMR0402IA]  110.87 116.46 270 top
R6F6  0  [SMR0402IA]  99.56 115.57 270 top
R6F7  10K  [SMR0402IA]  103.12 115.57 90 top
R6F8  4.7K  [SMR0402IA]  104.9 115.57 90 top
R6F9  3.3K  [SMR0402IA]  106.04 115.57 90 top
R6F10  0  [SMR0603IA]  115.82 113.41 0 top
R6F11  10K  [SMR0402IA]  110.87 113.16 90 top
R6F12  10K  [SMR0402IA]  108.2 112.27 90 top
R6F13  0  [SMR0603IA]  117.22 112.01 180 top
R6F14  0  [SMR0402IA]  111.76 111.63 270 top
R6F15  0  [SMR0402IA]  110.87 110.74 90 top
R6F16  0.005  [SMR4_0805IC_RVP]  117.47 110.49 180 top
R6F17  0  [SMR0402IA]  110.87 109.85 270 top
R6F18  10K  [SMR0402IA]  109.6 108.96 90 top
R6F19  0  [SMR0402IA]  111.76 108.96 90 top
R6F20  0  [SMR0402IA]  112.9 108.96 90 top
R6F21  10K  [SMR0402IA]  113.91 108.96 90 top
R6F22  0  [SMR0402IA]  98.55 107.57 270 top
R6F23  0  [SMR0402IA]  102.87 107.57 270 top
R6F24  0  [SMR0402IA]  102.01 107.56 270 top
R6F25  10K  [SMR0402IA]  113.03 107.44 0 top
R6F26  0  [SMR0402IA]  106.04 107.31 90 top
R6F28  0  [SMR0402IA]  104.77 106.68 90 top
R6F30  .002  [SMR4_1206IB_RVP]  130.42 105.54 90 top
R6F31  0  [SMR0402IA]  106.29 105.41 270 top
R6F32  0  [SMR0402IA]  107.18 105.41 90 top
R6F35  10K  [SMR0402IA]  104.64 104.01 90 top
R6F36  0  [SMR0402IA]  106.29 102.74 90 top
R6F37  .002  [SMR4_1206IB_RVP]  130.3 99.44 90 top
R6F38  10K  [SMR0402IA]  105.79 99.19 180 top
R6F39  10K  [SMR0402IA]  106.93 99.19 0 top
R6F40  10K  [SMR0402IA]  104.64 102.36 90 top
R6F41  3.3K  [SMR0402IA]  122.68 35.43 270 top
R6G1  0  [SMR0201IA]  110.74 83.26 270 top
R6G2  0  [SMR0603IA]  105.02 82.8 180 top
R6G3  0  [SMR0201IA]  111.35 82.73 90 top
R6G4  0  [SMR0201IA]  110.87 72.11 270 top
R6G5  0  [SMR0402IA]  128.9 72.13 90 top
R6G6  0  [SMR0402IA]  130.42 72.13 90 top
R6G7  0  [SMR0603IA]  103.88 71.5 180 top
R6G8  0  [SMR0201IA]  111.48 71.58 90 top
R6G9  0  [SMR0402IA]  124.96 70.23 90 top
R6G10  0  [SMR0402IA]  126.49 70.23 90 top
R6G11  0  [SMR0201IA]  129.36 70 270 top
R6G12  0  [SMR0603IA]  122.8 69.47 180 top
R6G13  0  [SMR0201IA]  129.97 69.47 90 top
R6H1  10K  [SMR0402IA]  113.79 58.16 270 top
R6H2  0  [SMR0402IA]  113.79 54.86 90 top
R6H3  0  [SMR0402IA]  114.8 54.86 90 top
R6H4  0  [SMR0402IA]  116.84 54.86 90 top
R6H5  0  [SMR0402IA]  117.85 54.86 90 top
R6H6  0  [SMR0603IA]  119.5 54.35 270 top
R6H7  0  [SMR0603IA]  120.9 54.35 270 top
R6H8  0  [SMR0402IA]  107.69 53.34 270 top
R6H9  0  [SMR0402IA]  108.71 53.34 270 top
R6H10  0  [SMR0402IA]  109.72 53.34 270 top
R6H11  0  [SMR0402IA]  110.74 53.34 270 top
R6H12  0  [SMR0402IA]  111.76 53.34 270 top
R6H13  0  [SMR0402IA]  113.79 53.34 270 top
R6H14  0  [SMR0402IA]  114.8 53.34 270 top
R6H15  0  [SMR0402IA]  115.82 53.34 270 top
R6H16  0  [SMR0402IA]  116.84 53.34 270 top
R6H17  0  [SMR0402IA]  117.85 53.34 270 top
R6H18  0  [SMR0402IA]  112.77 52.45 90 top
R6H19  10K  [SMR0402IA]  98.17 46.35 270 top
R6H20  1K  [SMR0402IA]  127.5 42.8 0 top
R6H21  1K  [SMR0402IA]  127.5 41.91 0 top
R6H22  1K  [SMR0402IA]  118.11 41.65 270 top
R6H23  0  [SMR0402IA]  127.5 41.02 0 top
R6H24  0  [SMR0402IA]  108.83 40.77 90 top
R6H25  0  [SMR0402IA]  109.98 40.77 90 top
R6H26  0  [SMR0402IA]  111.12 40.77 90 top
R6H27  0  [SMR0402IA]  112.26 40.77 90 top
R6H28  0  [SMR0402IA]  113.41 40.77 90 top
R6H29  0  [SMR0402IA]  114.55 40.77 90 top
R6H30  0  [SMR0402IA]  115.69 40.77 90 top
R6H31  0  [SMR0402IA]  116.84 40.77 90 top
R6H32  0  [SMR0603IA]  119.5 40.13 90 top
R6H33  0  [SMR0603IA]  120.9 40.13 90 top
R6H34  0  [SMR0402IA]  109.98 39.24 0 top
R6H35  0  [SMR0402IA]  112.26 39.24 0 top
R6H36  0  [SMR0402IA]  114.55 39.24 0 top
R6H37  10K  [SMR0402IA]  118.11 35.43 270 top
R6H38  0  [SMR0402IA]  126.49 36.32 0 top
R6H39  0  [SMR0402IA]  127.38 35.43 270 top
R6H40  0  [SMR0402IA]  129.15 36.32 180 top
R6H41  0  [SMR0402IA]  128.52 35.43 270 top
R6H42  0  [SMR0402IA]  130.3 35.43 270 top
R6H43  0  [SMR0402IA]  130.93 36.32 180 top
R6H44  0  [SMR0402IA]  119.25 34.54 90 top
R6H45  0  [SMR0402IA]  124.33 34.54 90 top
R6H46  0  [SMR0402IA]  125.34 34.54 90 top
R6H47  0  [SMR0402IA]  126.36 34.54 90 top
R6J1  0.01  [SMR4_0603ID_RVP]  113.66 24.13 270 top
R6J2  1K  [SMR0402IA]  117.47 23.37 270 top
R6J3  0  [SMR0402IA]  122.68 23.37 270 top
R6J4  0  [SMR0402IA]  123.57 23.37 270 top
R6J5  0  [SMR0402IA]  128.52 23.37 270 top
R6J6  0  [SMR0402IA]  129.41 23.37 270 top
R6J7  0  [SMR0402IA]  130.17 23.37 270 top
R6J8  0  [SMR0402IA]  131.31 23.37 270 top
R6J9  1K  [SMR0402IA]  118.49 22.48 90 top
R6J10  0  [SMR0402IA]  120.77 22.48 90 top
R6J11  0  [SMR0402IA]  121.79 22.48 90 top
R6J12  0  [SMR0402IA]  126.74 22.48 90 top
R6J13  10K  [SMR0402IA]  127.63 22.48 90 top
R6J14  0  [SMR0402IA]  132.2 22.48 90 top
R6J15  0  [SMR0402IA]  133.85 22.48 90 top
R6J16  10K  [SMR0402IA]  116.71 9.52 270 top
R6J17  1K  [SMR0402IA]  121.41 9.52 270 top
R6J18  1K  [SMR0402IA]  122.8 9.52 270 top
R6J19  0  [SMR0402IA]  126.23 9.52 270 top
R6J20  0  [SMR0402IA]  127.38 9.02 0 top
R6J21  0  [SMR0402IA]  129.03 9.02 0 top
R6J22  0  [SMR0402IA]  131.69 9.02 180 top
R6J23  0  [SMR0402IA]  132.58 9.02 180 top
R6J24  0  [SMR0402IA]  113.28 8.63 90 top
R6J25  0  [SMR0402IA]  114.04 8.63 90 top
R6J26  0  [SMR0402IA]  114.93 8.63 90 top
R6J27  0  [SMR0402IA]  117.6 8.63 90 top
R6J28  3.01K  [SMR0402IA]  120.52 8.63 90 top
R6J29  1K  [SMR0402IA]  123.69 8.63 90 top
R6J30  100  [SMR0402IA]  112.52 7.49 0 top
R6J31  0.005  [SMR4_0805IC_RVP]  106.42 7.36 0 top
R6J32  100K  [SMR0402IA]  105.53 4.06 180 top
R6J33  0  [SMR0402IA]  102.87 3.68 90 top
R6L1  22  [SMR0402IA]  125.47 270.38 0 bottom
R6L2  22  [SMR0402IA]  125.47 269.49 0 bottom
R6R1  10K  [SMR0402IA]  107.69 157.48 45 bottom
R6T3  10K  [SMR0402IA]  105.02 115.57 180 bottom
R6T5  0  [SMR0402IA]  100.45 114.68 90 bottom
R6T6  4.7K  [SMR0402IA]  110.1 114.17 90 bottom
R6T7  0  [SMR0402IA]  109.09 114.17 90 bottom
R6T8  0  [SMR0603IA]  104.01 113.79 0 bottom
R6T9  0  [SMR0402IA]  109.09 113.28 270 bottom
R6T10  0  [SMR0603IA]  104.01 112.65 0 bottom
R6T11  100K  [SMR0402IA]  110.1 112.39 90 bottom
R6T12  0.01  [SMR4_0603ID_RVP]  105.41 111.25 180 bottom
R6T13  10K  [SMR0402IA]  107.44 109.85 270 bottom
R6T14  0  [SMR0603IA]  104.01 109.85 0 bottom
R6T15  10K  [SMR0402IA]  108.58 108.96 90 bottom
R6T16  0  [SMR0603IA]  104.01 108.71 0 bottom
R6T17  20K  [SMR0402IA]  99.31 107.95 270 bottom
R6T18  20K  [SMR0402IA]  99.31 106.3 270 bottom
R6T19  0  [SMR0402IA]  99.31 103 90 bottom
R6T20  10K  [SMR0402IA]  108.33 102.87 270 bottom
R6T21  0  [SMR0402IA]  107.31 102.87 270 bottom
R6T22  10K  [SMR0402IA]  110.35 99.31 90 bottom
R6U1  0  [SMR0402IA]  105.66 97.03 180 bottom
R6U2  0  [SMR0402IA]  102.74 97.03 0 bottom
R6U3  10  [SMR0402IA]  97.91 93.72 270 bottom
R6U4  33  [SMR0402IA]  97.91 91.18 0 bottom
R6U5  33  [SMR0402IA]  98.8 89.53 270 bottom
R6U6  33  [SMR0402IA]  98.8 89.53 90 bottom
R6V1  10K  [SMR0402IA]  101.21 33.78 90 bottom
R6W1  0  [SMR0402IA]  108.83 27.56 270 bottom
R6W2  10K  [SMR0402IA]  107.82 27.56 270 bottom
R6W3  0  [SMR0402IA]  119.88 5.97 270 bottom
R6W4  1  [SMR0603IA]  126.74 5.21 90 bottom
R7A1  0  [SMR0402IA]  63.5 286.38 0 top
R7A2  330  [SMR0402IA]  63.5 284.22 0 top
R7A3  0  [SMR0402IA]  89.78 275.84 180 top
R7A4  330  [SMR0402IA]  89.78 274.06 180 top
R7A5  10K  [SMR0402IA]  93.34 272.92 0 top
R7A6  22k  [SMR0402IA]  88.64 266.57 0 top
R7A7  0  [SMR0402IA]  93.34 266.57 180 top
R7A8  75K  [SMR0402IA]  69.34 261.36 180 bottom
R7A9  0  [SMR0402IA]  68.45 260.35 0 bottom
R7A10  0  [SMR0402IA]  74.8 259.97 180 top
R7A11  0  [SMR0402IA]  76.2 259.97 0 top
R7A12  0  [SMR0402IA]  81.4 259.97 180 top
R7A13  0  [SMR0402IA]  82.55 259.97 0 top
R7A14  100K  [SMR0402IA]  72.89 259.97 180 top
R7B1  0  [SMR0402IA]  61.72 259.46 0 top
R7B2  10K  [SMR0402IA]  61.72 258.44 0 top
R7B3  100K  [SMR0402IA]  61.72 257.43 0 top
R7B4  100K  [SMR0402IA]  68.07 255.78 90 top
R7B5  100K  [SMR0402IA]  61.72 256.41 0 top
R7B6  100K  [SMR0402IA]  68.19 258.44 90 top
R7B7  10K  [SMR0402IA]  68.83 254.76 180 top
R7B8  10K  [SMR0402IA]  67.94 253.87 0 top
R7B9  10K  [SMR0402IA]  89.02 252.35 90 top
R7B10  10K  [SMR0402IA]  89.78 252.35 90 top
R7B11  0  [SMR0402IA]  91.56 252.35 90 top
R7B12  10K  [SMR0402IA]  92.71 252.35 90 top
R7B13  2.2K  [SMR0402IA]  95.5 252.35 90 top
R7B14  2.2K  [SMR0402IA]  96.39 252.35 90 top
R7B15  0  [SMR0402IA]  97.28 252.35 90 top
R7B16  0  [SMR0603IA]  72 251.08 0 top
R7B17  0  [SMR0603IA]  75.69 251.08 270 top
R7B18  0  [SMR0402IA]  95.5 250.95 0 top
R7B19  0  [SMR0402IA]  97.28 250.32 90 top
R7B20  0  [SMR0603IA]  72 249.68 0 top
