# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SPI_TPM_GPIO_R2: length 3.5
  TOP w0.1: EU8G3.14 34.3,72.5 33.78,73.02 32.63,73.02 R8G62.1
SPI_TPM_GPIO_RST_N: length 3.1
  TOP w0.1: 82.33,64.9 J7G1.33
SPI_TPM_PIRQ: length 164.1
  TOP w0.089: U6E1.T45 106.44,136.55 106.4,136.51 106.4,136.39 106.32,136.3 106.32,135.77 106.26,135.71 106.26,135.27 106.09,135.1 106.09,129.71 106.62,129.18
  TOP w0.1: 106.62,129.18 108.28,127.52 108.28,121.92 108.89,121.31 108.89,111.13 108.13,110.37 108.13,108.27 107.89,108.04 107.89,104.95 v1(108.83,104.01) ; v1(32.38,76.83) 33.02,76.83 R8G52.2 33.14,76.33 32.63,75.82 32.63,75.06 R8G63.2
  LAY5 w0.125: v1(108.83,104.01) 108.33,103.5 108.33,94.12 94.59,80.38 92.46,80.38 90.77,78.69 89.58,78.69 86.48,75.58 86.48,73.07 81.47,68.06 75.63,68.06 72.47,64.9 71.05,64.9 70.79,64.65 69.4,64.65 68.76,64.01 67.63,64.01 66.99,64.65 62.04,64.65 59.45,62.06 52.18,62.06 51.74,62.5 48.56,62.5 46.6,60.54 46.6,59.71 45.95,59.06 44.74,59.06 41.56,55.88 v1(35.94,55.88)
  LAY6 w0.125: v1(35.94,55.88) 35.56,55.88 35.43,56.01 35.43,59.69 36.45,60.71 36.45,65.19 34.67,66.97 34.67,67.56 33.37,68.86 33.37,71.46 34.67,72.76 34.67,74.54 v1(32.38,76.83)
SPI_TPM_PIRQ_LT: length 122.1
  TOP w0.1: R8G58.1 33.9,76.2 33.9,78.13 34,78.23 36.7,78.23 37.21,78.74 v1(37.97,78.74) 37.71,78.48 37.71,67.44 38.22,66.93 38.22,66.17 R8G84.1 ; R7H17.1 v1(91.22,63.24)
  LAY5 w0.125: v1(41.4,48) 41.88,48 42.99,49.11 46.13,49.11 48.82,51.8 49.89,51.8 51.53,53.44 54.05,53.44 54.79,52.7 55.42,52.7 56.09,53.37 58.31,53.37 58.57,53.11 68.72,53.11 69.21,53.59 73.99,53.59 75.01,52.57 78.61,52.57 79.75,53.72 80.51,53.72 81.72,54.93 86.74,54.93 87.03,54.64 89.27,54.64 90.12,55.5 90.12,55.96 90.5,56.33 90.5,57.02 90.88,57.4 91.18,57.4 91.56,57.78 91.56,62.9 v1(91.22,63.24)
  LAY6 w0.125: v1(41.4,48) 42.41,48 46.07,51.66 46.07,54.05 45.51,54.61 44.34,54.61 43.44,55.52 43.44,60.48 44.27,61.31 44.27,62.26 40.46,66.07 40.46,76.25 v1(37.97,78.74)
SPI_TPM_PIRQ_LT_R: length 3.1
  TOP w0.1: J7G1.47 91.22,64.9
SPI_TPM_PIRQ_R1: length 4.1
  TOP w0.1: EU8G3.4 34.8,67.69 35.43,67.05 36.32,67.05 R8G77.1 R8G84.2
SPI_TPM_PIRQ_R2: length 2.8
  TOP w0.1: R8G63.1 33.52,73.66 34.8,72.38 EU8G3.13
SPI_WP0_FLASH_N: length 45.8
  TOP w0.1: v1(70.38,90.42) 69.85,89.89 69.85,88.52 69.19,87.86 69.19,80.16 70.48,78.87 R7G19.2 ; EU7G3.3 94.74,84.71 v1(95.37,85.34) 95.14,85.57 U7G4.9
  BOTTOM w0.1: v1(95.37,85.34) 93.2,85.34 92.06,86.49 87.88,86.49 86.23,88.14 83.04,88.14 81.67,89.5 80.04,89.5 78.9,90.64 75.1,90.64 74.74,91 70.96,91 v1(70.38,90.42)
SPI_WP_TPM_N: length 6.3
  TOP w0.1: J7G1.45 89.95,64.94 R7H2.1 90.29,64.9 90.55,64.64 90.55,63.12 R7H20.2
SPI_WPN_PCON: length 26.8
  TOP w0.1: J2A2.2 249.19,274.42 246.99,274.42 246.5,273.94 246.5,270.51 244.85,268.86 244.85,267.59 ; 244.85,267.59 245.74,267.59 247.01,266.32 247.01,265.43 247.65,264.79 247.65,263.78 247.9,263.52 248.41,263.52 248.66,263.27 248.66,262.13 R2A67.1 249.42,261.36 249.42,259.97 250.57,258.82 U2B1.3 ; 244.85,267.59 242.8,267.59 U3A5.E2
SPI_WPN_PCON_J: length 2.4
  TOP w0.1: R2A35.2 247.14,272.67 J2A2.1
SPKR_OUT: length 8.2
  TOP w0.38: J9G7.1 7.11,74.17 11.17,74.17 R9G30.1 Q9G5.2
SPKR_PD_N: length 3.1
  TOP w0.1: J9A5.8 23.36,261.87 23.74,262.25 R8A30.2
SRAIL_DIS_GATE: length 114.3
  TOP w0.38: Q3G2.5 218.83,79.26 v1(218.56,78.99)
  TOP w0.508: v1(170.81,55.88) 170.94,55.75 R4H23.1 171.71,55.77 Q4H2.2 Q4H2.5
  LAY5 w0.38: v1(218.56,78.99) 216.94,80.62 209.56,80.62 208.77,81.41 198.12,81.41 197.33,80.62 191.58,80.62 190.11,79.15 179.07,79.15 178.81,78.89 173.35,78.89 171.29,76.83 168.65,76.83 v1(168.14,77.34)
  BOTTOM w0.5: J4J1.1 171.95,24.76 171.95,52.83 170.81,53.97 v1(170.81,55.88) 171.45,56.51 171.45,66.29 168.14,69.59 v1(168.14,77.34)
SRCCLKREQ0_WLAN_N: length 147.2
  TOP w0.089: 82.95,142.62 83.55,142.62 84.16,143.23 84.6,143.23 85.28,143.91 88.96,143.91 89.06,144.01 91.86,144.01 91.92,143.96 U6E1.BF31
  TOP w0.1: v1(75.5,139.61) 75.56,139.67 R7E35.1 75.94,139.95 78.1,139.95 79.12,140.97 79.5,140.97 81.15,142.62 82.95,142.62 ; v1(74.29,246.89) 74.04,247.14 R7B29.1
  LAY5 w0.125: v1(79.37,204.34) 77.66,202.63 77.66,200.34 78.17,199.83 78.17,186.69 81.4,183.45 81.4,176.73 80.77,176.1 80.77,174.62 79.68,173.54 79.68,165.92 79.12,165.36 79.12,160.65 79.43,160.34 79.43,153.41 79,152.98 79,151.65 78.24,150.89 78.24,150.36 77.87,149.99 77.21,149.99 76.96,149.73 76.96,145.67 78.12,144.51 78.12,142.49 77.86,142.24 77.34,142.24 75.5,140.4 v1(75.5,139.61) ; v1(74.29,246.89) 73.78,246.38 73.78,244.68 74.3,244.16 77.91,244.16 79.59,242.49 83.33,242.49 v1(84.17,243.33)
  LAY6 w0.125: v1(79.37,204.34) 79.37,217.04 82.1,219.77 82.1,222.85 83.63,224.37 83.63,234.12 82.55,235.2 82.55,238.47 82.8,238.72 82.8,241.96 v1(84.17,243.33)
SRCCLKREQ1_LAN_N: length 241.6
  TOP w0.089: U6E1.BE31 92.31,143.8 92.23,143.73 91.88,143.73 91.79,143.81 90.65,143.81 90.5,143.81 89.93,143.81 89.13,143.81 89.04,143.72 85.36,143.72 84.68,143.04 84.24,143.04 83.31,142.11 82.17,142.11 ; v1(81.28,142.11) 80.99,142.11
  TOP w0.1: v1(190.24,252.98) 189.86,253.36 189.86,253.62 R4B15.1 ; 82.17,142.11 v1(81.28,142.11) ; R7E40.2 76.32,139.7 78.26,139.7 79.28,140.71 79.59,140.71 80.99,142.11
  LAY5 w0.125: v1(86.1,246) 86.5,245.6 90.94,245.6 91.91,244.64 101.14,244.64 101.86,245.35 103.6,245.35 104.31,244.65 105.03,244.65 105.68,245.29 107.88,245.29 109.13,244.05 111.72,244.05 111.93,244.26 116.02,244.26 116.45,243.83 125.86,243.83 127.07,245.04 130.08,245.04 131.44,246.41 131.44,247.39 132.33,248.27 135.2,248.27 138.2,251.27 147.55,251.27 148.15,251.87 173.62,251.87 174.09,251.4 180.64,251.4 182.77,253.53 189.69,253.53 v1(190.24,252.98) ; v1(84.83,201.55) 85.34,201.04 85.34,199.11 84.73,198.5 84.73,183.41 84.44,183.13 84.44,174.86 82.28,172.7 82.28,165.88 83.04,165.13 83.04,164.23 84.12,163.15 84.12,158.16 83.82,157.86 83.56,157.86 83.31,157.61 83.31,153.52 82.29,152.51 82.29,149.73 80.64,148.08 80.64,146.05 81.38,145.31 81.38,142.22 v1(81.28,142.11)
  LAY6 w0.125: v1(86.1,246) 86.88,245.22 86.88,226.71 86.23,226.06 86.23,225.04 85.96,224.77 85.96,206.18 86.54,205.6 86.54,202.8 85.29,201.55 v1(84.83,201.55)
SRCCLKREQ2_M.2_SSD_N: length 130.8
  TOP w0.089: U6E1.AR32 v1(97.49,142.88)
  TOP w0.1: R8G81.2 31.49,67.44 30.48,68.45 v1(29.99,68.45) 29.46,67.92 29.46,67.44 29.71,67.18 R8G73.1
  LAY5 w0.125: v1(29.99,68.45) 30.48,68.45 32.88,70.86 32.88,72.39 35.29,74.8 36.57,74.8 40.82,79.05 44.8,79.05 45.18,79.43 48.94,79.43 51.66,82.15 57.76,82.15 59.01,83.39 63.11,83.39 64.77,85.04 65.15,85.04 66.96,86.86 69.3,86.86 69.81,87.37 72.29,87.37 73.48,88.56 73.48,89.62 74.04,90.18 77.58,90.18 78.23,89.53 79.62,89.53 81.61,91.51 83.76,91.51 84.58,92.33 85.25,92.33 85.55,92.63 85.55,101.86 84.82,102.59 84.82,106.05 85.5,106.73 85.5,108.74 86.4,109.65 86.4,117.02 88.72,119.33 88.72,119.92 90.11,121.31 90.11,127.2 92.03,129.12 92.03,134.71 91.31,135.44 91.31,137.16 92.45,138.3 92.45,139.83 93.72,141.1 93.85,141.1 94.36,141.6 94.61,141.6 94.86,141.86 95.37,141.86 95.88,142.37 96.92,142.37 97.44,142.88 v1(97.49,142.88)
SRCCLKREQ3_CPU_SSD_N: length 282.7
  TOP w0.089: U6E1.BB30 v1(93.75,143.56)
  TOP w0.1: v1(164.33,218.03) 164.59,218.28 R5C12.1 R5C9.1
  LAY5 w0.125: v1(93.75,143.56) 92.32,144.98 92.32,148.21 92.58,148.47 98.17,148.47 99.82,150.11 100.91,150.11 101.95,151.15 101.95,151.36 102.24,151.65 102.24,157.68 98.03,161.89 98.03,178.29 97.01,179.31 97.01,185.56 94.62,187.95 94.62,197.85 v1(90.8,201.67) ; v1(89.15,221.92) 90.34,220.72 97.4,220.72 98.8,219.33 98.8,215.24 99.84,214.2 115.99,214.2 124.93,223.14 130.4,223.14 138.35,215.19 138.35,165.17 138.81,164.72 139.67,164.72 140.56,163.83 143.36,163.83 144.37,162.81 146.3,162.81 146.93,163.45 146.93,166.22 148.33,167.62 148.33,189.33 147.94,189.71 147.94,191.25 148.33,191.64 148.33,203.81 148.59,204.07 148.59,205.99 151.25,208.66 151.25,209.52 155.21,213.48 159.63,213.48 159.89,213.74 159.89,214.88 160.9,215.9 162.2,215.9 v1(164.33,218.03)
  LAY6 w0.125: v1(90.8,201.67) 91.32,202.2 91.32,204.39 89.07,206.64 89.07,220.44 89.61,220.98 89.61,221.46 v1(89.15,221.92)
SRCCLKREQ4_PCIEX4_SLOT3_N: length 186.2
  TOP w0.089: U6E1.BA30 v1(94.49,143.75)
  TOP w0.1: v1(24.63,217.93) 25.78,217.93 28.7,220.85 R8C11.2 R8C12.1 29.78,221.8 Q8C1.3
  LAY6 w0.125: v1(18.54,137.16) 18.03,137.67 18.03,138.46 18.61,139.04 18.61,140.53 20.57,142.49 20.57,148.33 19.81,149.09 19.81,154.18 18.67,155.31 18.67,159.16 17.41,160.42 17.41,170.43 18.21,171.24 18.21,181.92 19.1,182.81 19.1,191.06 22.35,194.31 22.35,195.93 23.84,197.42 23.84,202.38 25.15,203.69 25.15,205.39 25.91,206.15 25.91,207 25.27,207.64 25.27,209.55 24.63,210.18 v1(24.63,217.93)
  BOTTOM w0.1: v1(94.49,143.75) 94.22,144.01 92.96,144.01 92.21,143.25 89.92,143.25 88.62,141.96 84.76,141.96 81.87,139.06 78.78,139.06 77.99,138.28 74.98,138.28 74.56,138.7 73.21,138.7 72.71,139.2 71.39,139.2 70.12,137.93 69.25,137.93 67,135.68 63.46,135.68 62.94,135.16 57.71,135.16 52.71,130.16 52.71,129.16 50.21,126.66 39.44,126.66 36.5,129.6 30.54,129.6 28.88,131.26 24.38,131.26 22.41,133.23 22.41,134.05 20.44,136.02 20.44,136.4 20.06,136.78 18.92,136.78 v1(18.54,137.16)
SRCCLKREQ5_PCIEX4_SLOT2_N: length 188.8
  TOP w0.089: U6E1.AN29 98.35,144.13 v1(98.35,144.13)
  TOP w0.1: v1(29.84,222.71) 29.84,222.88 R8C8.2 R8C9.1 31.75,222.38 33.21,220.92 Q8C2.3
  LAY6 w0.125: v1(29.84,222.71) 29.84,222.5 30.32,222.02 30.32,217.03 30.74,216.6 30.74,212.03 31.13,211.64 31.13,210.29 30.74,209.9 30.74,209.54 34.6,205.68 34.6,204.28 34.92,203.96 34.92,199.94 35.87,199 35.87,197.46 34.41,196 34.41,186.01 32.43,184.03 29.7,184.03 28.3,182.63 28.3,179.13 28.44,178.99 28.44,173.2 27.71,172.47 27.46,172.47 27.04,172.06 27.04,166.63 28.06,165.61 28.06,158.57 26.54,157.05 26.54,153.41 28.19,151.76 28.19,149.21 27.32,148.33 27.32,141.85 27.07,141.6 27.07,132.31 v1(28.95,130.43)
  BOTTOM w0.089: 92.45,142.87 93.28,142.87 93.44,143.03 94,143.03 94.22,143.26 94.78,143.26 94.9,143.38 97.02,143.38 97.15,143.51 97.73,143.51 v1(98.35,144.13)
  BOTTOM w0.1: v1(28.95,130.43) 30.25,129.12 36.3,129.12 39.07,126.36 50.33,126.36 53.05,129.08 56.34,129.08 60.14,132.88 62.28,132.88 63.88,134.47 63.88,135.13 64.13,135.38 67.13,135.38 69.38,137.63 70.25,137.63 71.52,138.9 72.59,138.9 73.09,138.4 74.44,138.4 74.86,137.98 78.88,137.98 78.99,137.87 80.62,137.87 81.51,138.76 81.99,138.76 84.98,141.76 88.79,141.76 89.91,142.87 92.45,142.87
SRCCLKREQ6_TR_N: length 264.3
  TOP w0.1: U5A2.Y6 v2(164.09,263.5) ; R6F23.2 v1(102.87,105.79)
  LAY5 w0.125: v2(164.09,263.5) 163.7,263.12 162.05,263.12 161.17,264 161.17,265.31 159.3,267.18 151.51,267.18 148.27,270.43 146.54,270.43 145.98,269.87 145.39,269.87 145.03,270.24 139.63,270.24 139.31,269.92 139.31,264.29 137.16,262.13 v1(136.39,262.13) ; v1(126.61,187.45) 127.12,186.94 127.12,181.61 126.87,181.35 126.87,180.11 127.38,179.6 127.38,173.61 130.96,170.03 130.96,165.67 130.17,164.88 130.17,159.27 137.03,152.41 137.03,138.4 131.08,132.46 126.34,132.46 125.24,131.37 125.24,127.56 123.72,126.04 119.65,126.04 115.44,121.83 115.44,120.9 109.6,115.07 109.6,111.33 108.12,109.85 107.14,109.85 104.65,107.36 104.65,107.12 103.83,106.3 103.37,106.3 v1(102.87,105.79)
  LAY6 w0.125: v1(126.61,187.45) 126.23,187.45 124.58,189.1 124.58,192.81 121.81,195.58 114.44,195.58 107.44,202.59 107.44,210.84 104.26,214.02 104.26,227.1 103.76,227.61 103.76,229.97 109.97,236.19 109.97,240.6 108.96,241.61 108.96,243.17 114.8,249.02 114.8,251.46 116.71,253.36 124.75,253.36 125.73,254.34 125.73,256.92 123.88,258.76 123.88,261.68 124.48,262.28 130.71,262.28 131.69,263.27 135.25,263.27 v1(136.39,262.13)
SRCCLKREQ6_TR_U2_N: length 31.4
  TOP w0.089: U6E1.AE47 101.89,136.07 101.89,135.43 101.96,135.35 101.96,131.68 101.03,130.75 101.03,126.55 101.12,126.46
  TOP w0.1: 101.12,126.46 101.12,121 103.12,119 103.12,117.78 103.37,117.52 103.37,116.71 102.43,115.77 102.43,110.05 102.01,109.63 R6F24.1 102.86,107.56 R6F23.1
SRCCLKREQ6_U2_N: length 80.1
  TOP w0.1: R6F24.2 102.01,105.51 102.99,104.52 v1(102.99,103.25) ; v1(153.03,78.99) R5G22.1 R5G23.1
  LAY5 w0.125: v1(153.03,78.99) 152.27,79.75 150.17,79.75 149.66,79.24 139.75,79.24 139.38,78.86 138.41,78.86 135.55,76 115.09,76 113.88,77.21 111.25,77.21 v1(110.36,78.1)
  LAY6 w0.125: v1(110.36,78.1) 110.23,78.1 108.96,79.37 108.96,79.88 108.45,80.39 107.24,80.39 105.84,81.78 105.84,95.58 103.9,97.52 103.9,100.61 102.99,101.52 v1(102.99,103.25)
SRCCLKREQ7_PCIEX16_N: length 267.2
  TOP w0.089: 102.86,128.6 102.86,128.8 102.64,129.02 102.64,130.81 103.13,131.3 103.13,135.43 103.18,135.47 U6E1.AC48
  TOP w0.1: v1(136.88,220.34) 136.88,220.37 136.27,220.98 R5C6.1 135.63,220.47 132.01,220.47 Q6C1.3 ; v1(106.63,243.13) 107.26,243.76 118.94,243.76 119.15,243.55 131.74,243.55 133.74,241.55 137.17,241.55 138.36,242.75 139.75,242.75 140.58,243.58 144.19,243.58 144.9,242.88 146.05,242.88 146.68,243.51 146.68,244.47 146.93,244.73 R5B19.2 R5B20.2 ; 102.86,128.6 102.86,120.4 103.8,119.46 103.8,117.77 103.88,117.69 v1(103.88,117.09)
  LAY5 w0.125: v1(117.37,186.82) 117.85,186.33 117.85,184.75 118.94,183.66 118.94,173.48 116.58,171.13 116.58,164.21 115.95,163.58 115.95,161.49 117.48,159.96 117.48,152.2 115.83,150.55 115.83,139.51 117.72,137.61 117.72,131.05 109.6,122.92 109.6,122.05 104.64,117.09 v1(103.88,117.09) ; v1(100.83,214.88) 101.26,214.45 115.89,214.45 124.82,223.39 134.47,223.39 136.88,220.98 v1(136.88,220.34)
  LAY6 w0.125: v1(117.37,186.82) 117.39,186.79 118.13,186.79 118.36,187.01 118.36,190.1 116.46,191.99 114.05,191.99 100.83,205.2 v1(100.83,214.88) 101.07,215.12 101.07,217.23 100.13,218.18 100.13,222.64 101.1,223.61 101.1,227.95 100.44,228.61 100.44,232.09 98.62,233.91 98.62,237.27 101.13,239.78 104.13,239.78 105.12,238.79 106.15,238.79 106.79,239.43 106.79,242.97 v1(106.63,243.13)
SRCCLKREQ8_FOX_N: length 217.3
  TOP w0.089: U6E1.AE41 v1(101.52,138.84)
  TOP w0.1: R7B21.2 90.69,250.49 90.69,251.75 91.29,252.35 R7B11.1 91.82,252.35 92.2,252.73 v1(92.2,254)
  LAY5 w0.125: v1(108.2,254.63) 107.88,254.95 103.81,254.95 103.16,254.31 102.6,254.31 100.33,256.58 99.65,256.58 99.41,256.81 93.36,256.81 91.94,255.4 91.94,254.53 92.2,254.28 v1(92.2,254) ; v1(102.87,117.35) 103.25,117.73 104.57,117.73 107.48,120.63 107.48,121.7 109.11,123.34 109.55,123.34 117.4,131.19 117.4,137.46 115.5,139.36 115.5,152.64 116.84,153.98 116.84,160.14 115.63,161.34 115.63,164.78 116.14,165.29 116.14,171.25 117.47,172.58 117.47,176.65 118.12,177.29 118.12,183.88 117.47,184.53 117.47,185.95 v1(117.34,186.08)
  LAY6 w0.125: v1(108.2,254.63) 109.98,252.86 109.98,252.8 110.1,252.67 110.11,252.67 110.51,252.27 110.51,249.7 107.11,246.3 107.11,239.28 106.27,238.44 104.99,238.44 103.98,239.46 101.28,239.46 98.95,237.13 98.95,234.06 100.76,232.24 100.76,228.75 101.42,228.09 101.42,223.46 100.45,222.49 100.45,218.32 101.93,216.85 101.93,213.04 103.3,211.66 103.3,203.2 114.19,192.31 116.61,192.31 118.68,190.24 118.68,186.63 118.11,186.05 117.37,186.05 v1(117.34,186.08)
  BOTTOM w0.089: v1(101.52,138.84) 102.36,138 102.36,135.76 101.85,135.25
  BOTTOM w0.1: v1(102.87,117.35) 102.87,118.07 100.64,120.29 100.64,127.28 101.54,128.17 101.54,134.94 101.85,135.25
SRCCLKREQ9_2ND_PCIEX16_N: length 229.5
  TOP w0.089: 100.58,128.27 100.64,128.33 100.64,130.9 101.58,131.84 101.58,135.17 101.45,135.3 U6E1.AF48
  TOP w0.1: Q5B1.3 148.39,237.81 147.87,238.33 147.87,240.59 R5B25.1 148.33,241.17 148.08,241.43 R5B23.2 148.38,242.11 148.38,246.28 148.14,246.52 v1(148.14,246.53) ; 100.58,128.27 100.17,127.85 100.17,120.52 102.14,118.54 v1(102.14,118.11)
  LAY5 w0.125: v1(98.67,240.54) 99.73,241.59 106.85,241.59 109.62,238.82 116.89,238.82 118.49,240.41 126.87,240.41 128.07,241.61 133.56,241.61 140.01,248.06 146.84,248.06 148.13,246.77 148.13,246.54 v1(148.14,246.53) ; v1(116.58,187.6) 115.81,186.83 115.81,184.7 117.28,183.22 117.28,177.63 116.59,176.94 116.59,172.88 115.31,171.6 115.31,166.79 114.55,166.03 114.55,164.69 114.8,164.44 114.8,160.99 115.69,160.1 115.69,154.23 114.67,153.21 114.67,139.01 116.32,137.36 116.32,132 115.39,131.07 114.3,131.07 114.04,130.81 114.04,129.82 111.22,127 108.96,127 102.14,120.18 v1(102.14,118.11)
  LAY6 w0.125: v1(98.67,240.54) 98.67,239 97.61,237.94 97.61,233.49 97.91,233.19 97.91,229.71 100.09,227.53 100.09,224.35 98.87,223.13 98.87,202.62 103.98,197.51 104.75,197.51 111.89,190.38 114.47,190.38 115.44,189.41 115.44,188.75 v1(116.58,187.6)
SRCCLKREQ9_PEG_N: length 4.1
  TOP w0.1: J5B2.A6 145.78,241.05 146.17,240.66 146.93,240.66 147.32,241.04 147.44,241.04 147.44,240.79 147.32,240.66 147.32,239.77 Q5B1.2
SRCCLKREQ10_3RD_PCIEX16_N: length 151.7
  TOP w0.089: U6E1.AC41 v1(103.77,138.84)
  TOP w0.1: 150.36,159.38 R5E2.1 150.36,162.42 Q5D2.3 145.92,162.48 145.53,162.88 144.46,162.88 143.51,163.83 140.84,163.83 140.2,164.46 138.17,164.46 v1(133.47,169.16)
  LAY5 w0.125: v1(111.88,103.88) 111.37,104.39 111.37,106.68 112.26,107.57 113.03,107.57 113.41,107.95 113.41,109.81 113.73,110.14 113.73,113.87 119.56,119.7 121.67,119.7 123.56,121.59 125.07,121.59 127.08,119.57 128.66,119.57 132.74,123.64 132.74,131.5 139.42,138.18 139.42,152.63 132.01,160.03 132.01,164.12 132.81,164.91 132.81,168.5 v1(133.47,169.16)
  BOTTOM w0.089: 103.02,135.92 103.02,138.09 v1(103.77,138.84)
  BOTTOM w0.1: v1(111.88,103.88) 110.87,104.9 110.87,110.16 109.85,111.17 109.11,111.17 108.07,112.21 108.07,116.09 105.95,118.22 104.55,118.22 103.02,119.75 103.02,135.92
SRCCLKREQ10_PEG_N: length 11.6
  TOP w0.1: R5E2.2 148.21,161.53 Q5D2.2 146.3,161.53 145.4,162.43 144.27,162.43 143.17,163.53 139.41,163.53 J5B2.B82
SRCCLKREQ14_M.2_SSD_2ND_N: length 146
  TOP w0.089: U6E1.AC44 v1(103.77,137.32)
  TOP w0.1: v1(44.19,67.64) R8G78.2 R8G72.1
  LAY5 w0.125: v1(112.9,105.41) 113.38,104.93 113.38,97.75 95.01,79.37 93.97,79.37 91.9,77.31 91.9,75.8 89.37,73.27 88.51,73.27 82.29,67.05 76.05,67.05 72.88,63.89 71.46,63.89 71.21,63.64 69.81,63.64 69.18,63 67.54,63 65.59,61.06 54.06,61.06 52.83,59.82 49.23,59.82 47.46,58.05 47,58.05 v1(44.83,55.88)
  LAY6 w0.125: v1(44.19,67.64) 44.19,66.19 45.34,65.04 45.34,60.96 44.83,60.45 v1(44.83,55.88)
  BOTTOM w0.1: v1(112.9,105.41) 112.36,105.95 112.36,110.14 111.4,111.1 111.4,114.97 107.14,119.23 105.81,119.23 104.64,120.39 104.64,136.44 v1(103.77,137.32)
SSD_CPU_PCIE_CLKREQ_N: length 2.4
  TOP w0.1: J5B3.52 164.53,220.87 164.87,220.53 164.87,219.87 R5C12.2
SSD_CPU_PE_WAKE_N: length 2.3
  TOP w0.1: J5B3.54 165.03,221.04 165.35,220.72 R5C13.2
SSD_PCIE_CLKREQ2_N: length 5.8
  TOP w0.1: R8G72.2 v1(43.18,65.15) ; J8H1.6 v1(41.27,62.23)
  BOTTOM w0.1: v1(41.27,62.23) 41.27,63.12 43.18,65.02 v1(43.18,65.15)
SSD_PCIE_CLKREQ_N: length 2.1
  TOP w0.1: J8H1.52 29.77,65.6 29.71,65.66
SSD_PE_WAKE_N: length 2.3
  TOP w0.1: R8G79.1 28.82,64.9 29.27,64.45 J8H1.54
SSD_PERST_N: length 2.2
  TOP w0.1: R8G80.1 30.27,65.32 J8H1.50
SSD_RST_N: length 20.7
  TOP w0.1: R8G33.2 R8G36.2 R8G40.1 31.36,82.17 v1(32.25,81.28) ; v1(29.99,67.69) 30.6,67.08 R8G80.2
  LAY5 w0.125: v1(32.25,81.28) 31.75,81.28 31.11,80.64 31.11,73.53 30.48,72.9 30.48,71.68 29.46,70.67 29.46,68.22 v1(29.99,67.69)
SSD_RST_R_N: length 2.3
  TOP w0.1: R8G36.1 33.28,82.92 U8G1.4
SSD_SATA_DEVSLP: length 1.4
  TOP w0.1: R8H39.1 Q8H2.1
SSD_SATA_DEVSLP_R: length 2.5
  TOP w0.1: J8H1.38 33.27,64.51 32.38,65.4 R8G82.1
SSD_SUS_CLK: length 95.1
  TOP w0.1: v1(28.62,68.71) 26.54,66.62 26.54,63.75 26.33,63.55 J8H1.68 ; R7F18.2 v1(70.86,117.22)
  LAY5 w0.125: v1(73.98,89.41) 73.98,88.36 72.49,86.87 70.02,86.87 69.51,86.36 67.17,86.36 65.35,84.54 64.97,84.54 63.32,82.89 59.27,82.89 58.02,81.65 51.86,81.65 49.14,78.93 45.39,78.93 45.01,78.55 41.03,78.55 36.78,74.3 35.5,74.3 33.38,72.18 33.38,70.65 30.86,68.13 30.86,67.31 30.48,66.93 29.46,66.93 28.6,67.79 28.6,68.65 28.62,68.68 v1(28.62,68.71)
  LAY6 w0.125: v1(73.98,89.41) 73.98,92.93 73.09,93.83 73.09,99.11 70.1,102.1 70.1,110.38 70.53,110.81 70.53,116.89 v1(70.86,117.22)
SSP1_TXD_SDW2_DATA_POST1_OUT: length 4.1
  TOP w0.1: R9B1.2 18.28,259.21 19.68,257.81 J9A5.11
STARTUP_LATCH_SET: length 6.8
  TOP w0.1: R6J3.2 122.68,21.92 121.23,20.47 121.23,16.98 J6J2.68
SUS_CLK_CODEC: length 198.6
  TOP w0.1: R7F20.2 v1(72.51,115.7) ; R6A52.1 113.03,272.92 v1(113.41,273.3)
  LAY5 w0.125: v1(86.36,269.75) 86.99,270.38 86.99,271.02 88.26,272.29 93.72,272.29 94.36,271.65 95.98,271.65 96.11,271.78 107.44,271.78 108.45,272.79 112.9,272.79 v1(113.41,273.3) ; v1(72.51,115.7) 72.03,116.18 72.03,119.4 75.94,123.32 75.94,123.95 77.59,125.6 77.59,129.28 78.48,130.17 78.48,132.71 79.02,133.25 79.02,135.83 81.05,137.86 81.05,141.06 80.77,141.35 80.77,144.88 79.23,146.42 79.23,148.45 80.5,149.72 80.5,151.75 80.77,152.02 81.15,152.02 82.3,153.17 82.3,159.04 82.66,159.4 82.66,164.97 81.91,165.73 81.91,172.85 84.07,175.01 84.07,183.36 84.35,183.64 84.35,198.65 84.83,199.13 v1(84.83,200.79)
  LAY6 w0.125: v1(84.83,200.79) 85.06,200.79 86.92,202.64 86.92,205.75 86.33,206.34 86.33,224.62 86.6,224.89 86.6,225.9 87.25,226.55 87.25,245.74 85.08,247.91 85.08,250.96 83.83,252.22 83.83,256.68 85.59,258.44 85.59,268.6 86.36,269.37 v1(86.36,269.75)
SUS_STAT_ESPI_RST_EC_AIC_N: length 5.4
  TOP w0.1: R6J7.2 131.19,21.46 131.19,18.79 130.63,18.24 J6J2.123
SUS_STAT_ESPI_RST_EC_N: length 67.9
  TOP w0.1: U8F6.53 18.5,96.69 18.66,96.52 23.11,96.52 25.9,99.31 v1(27.68,99.31) ; v1(64.89,128.9) 65.4,129.41 66.67,129.41 67.69,130.43 R7E60.2
  BOTTOM w0.1: v1(27.68,99.31) 27.68,100.51 31.75,104.58 31.75,105.51 34.12,107.89 35.59,107.89 36.7,109.01 39.5,109.01 44.22,113.73 44.22,115.16 46.23,117.16 55.35,117.16 64.38,126.19 64.38,128.4 v1(64.89,128.9)
SUS_STAT_ESPI_RST_HDR_N: length 33.3
  TOP w0.1: R6J6.2 v1(129.41,21.72) ; v1(104.39,25.65) 101.72,25.65 101.21,26.16 J7J1.19
  LAY3 w0.1: v1(104.39,25.65) 104.92,25.12 105.66,25.12 106.83,23.94 111.83,23.94 112.41,23.37 114.04,23.37 114.55,22.86 120.26,22.86 120.43,22.7 124.82,22.7 126.31,21.21 128.9,21.21 v1(129.41,21.72)
SUS_STAT_ESPI_RST_N: length 188.7
  TOP w0.089: 81.58,136.07 84.8,139.29 87,139.29 87.97,140.26 90.34,140.26 90.44,140.36 91.44,140.36 91.5,140.42 U6E1.BF38
  TOP w0.1: R6J7.1 R6J6.1 v1(129.41,24.13) ; v1(65.65,128.9) 66.94,128.9 68.58,130.54 R7E60.1 68.58,131.23 70.08,132.73 71.64,132.73 R7E55.1 72.75,133.84 74.49,133.84 75.29,134.64 77.28,134.64 78.71,136.07 81.58,136.07
  LAY3 w0.1: v1(65.65,128.9) 64.61,127.85 64.61,120.68 68.19,117.09 68.19,115.96 71.12,113.04 71.12,110.78 72.86,109.03 72.86,106.69 78.58,100.96 79.73,100.96 82.45,98.24 85.73,98.24 87.83,96.14 90.42,96.14 91.82,94.74 97.19,94.74 98.51,93.41 98.51,90.87 100.15,89.24 113.94,89.24 120.13,83.05 120.96,83.05 122.68,81.34 122.68,80.77 123.95,79.5 v1(124.84,79.5)
  LAY8 w0.1: v1(124.84,79.5) 123.11,77.78 123.11,75.89 120.03,72.81 120.03,59.44 124.2,55.27 124.2,36.32 125.41,35.11 128.84,35.11 131.19,32.76 131.19,26.67 129.41,24.89 v1(129.41,24.13)
SUSACK_EC: length 236
  TOP w0.1: J6J2.96 v1(125.04,10.87) ; v1(27.3,101.6) 25.78,103.12 24.89,103.12 23.62,104.39 U8F6.21 ; R7E47.2 67.12,133.55 67.12,132.4 66.04,131.32 v1(66.04,130.55)
  LAY3 w0.1: v1(123.69,80.64) 123.19,81.15 123.19,81.59 122.32,82.45 122.32,83.4 115.94,89.79 101.85,89.79 100.2,91.44 100.2,92.4 97.38,95.22 92.01,95.22 90.62,96.61 88.02,96.61 85.92,98.71 83.56,98.71 83.18,99.09 83.18,101.09 82.04,102.23 77.99,102.23 74.29,105.93 74.29,108.5 73.66,109.13 73.66,111.16 69.04,115.79 69.04,124 66.16,126.87 66.16,130.43 v1(66.04,130.55)
  LAY8 w0.1: v1(123.69,80.64) 119.1,76.05 119.1,59.06 121.17,56.99 121.17,49.97 121.97,49.17 121.97,35.57 123.73,33.81 126.87,33.81 129.13,31.56 129.13,27.4 125.6,23.87 125.6,11.42 v1(125.04,10.87)
  BOTTOM w0.1: v1(27.3,101.6) 27.77,101.6 29.88,103.7 29.88,104.64 32.92,107.68 32.92,108.61 33.65,109.35 34.92,109.35 35.28,109.71 37.06,109.71 41.21,113.86 41.85,113.86 45.85,117.86 55.06,117.86 63.62,126.42 63.62,129.16 64.13,129.67 65.15,129.67 v1(66.04,130.55)
SUSACK_N: length 28.5
  TOP w0.089: U6E1.BE35 92.26,141.6 92.19,141.53 91.88,141.53 91.79,141.61 91.12,141.61 90.88,141.61 90.72,141.62 90.15,141.62 89.99,141.62 89.94,141.56 86.88,141.56 86.45,141.13 85.15,141.13 83.21,139.19
  TOP w0.1: 83.21,139.19 80.97,136.96 78.21,136.96 77.63,136.37 77.02,136.37 76.44,135.79 74.54,135.79 74.36,135.61 70.07,135.61 R7E47.1 68.7,134.24 R7E50.2 68.45,134.24 67.69,133.48 R7E53.2
SUSWARN_EC: length 229.5
  TOP w0.1: R7E56.2 66.97,131.87 66.97,130.38 66.51,129.92 65.15,129.92 v1(64.13,128.9) ; v1(113.64,17.05) 113.64,16.95 J6J2.20 ; U8F6.111 32.1,97.89 31.75,97.53 v1(31.75,97.15)
  LAY3 w0.1: v1(64.13,128.9) 64.13,120.14 67.05,117.22 67.05,115.57 70.61,112.01 70.61,110.62 72.39,108.84 72.39,105.48 78.04,99.82 80.2,99.82 82.26,97.76 85.53,97.76 89.93,93.36 96.28,93.36 96.77,93.85 97.4,93.85 98.04,93.22 98.04,90.68 99.95,88.76 113.75,88.76 119.93,82.58 120.77,82.58 v1(122.18,81.16)
  LAY8 w0.1: v1(113.64,17.05) 113.15,17.53 113.15,25.53 113.66,26.03 113.66,27.3 113.94,27.58 113.94,31.33 116.84,34.23 117.41,34.23 121.52,38.33 121.52,48.98 120.71,49.78 120.71,56.8 118.65,58.87 118.65,77.14 122.18,80.68 v1(122.18,81.16)
  BOTTOM w0.1: v1(64.13,128.9) 63.85,128.62 63.85,126.33 55.16,117.63 46.03,117.63 43.75,115.35 43.75,113.93 39.3,109.48 35.38,109.48 35.01,109.12 33.8,109.12 33.14,108.46 33.14,107.58 30.11,104.55 30.11,103.61 27.04,100.54 27.04,96.65 27.4,96.29 29.43,96.29 30.75,97.61 31.29,97.61 v1(31.75,97.15)
SUSWARN_N_SUSPWRDNACK: length 29.1
  TOP w0.089: 83.56,138.43 85.69,140.56 86.69,140.56 87.12,140.99 90.18,140.99 90.18,140.99 90.2,140.99 90.25,141.04 91.56,141.04 91.75,140.85 92.06,140.85 92.09,140.82 92.76,140.82 92.83,140.74 92.96,140.74 93.01,140.69 U6E1.BC37
  TOP w0.1: 83.56,138.43 81.4,136.27 78.58,136.27 77.42,135.11 75.09,135.11 74.29,134.31 72.3,134.31 71.19,133.21 69.88,133.21 69.26,132.59 R7E56.1 R7E53.1
SV_ADVANCE_GP48: length 215
  TOP w0.1: R7F50.1 90.04,107.31 88.9,106.17 88.9,105.54 89.4,105.03 v1(89.4,104.9) ; R9E26.2 13.84,143.64 11.3,143.64 9.52,145.41 7.36,145.41 6.98,145.03 6.98,141.86 J9E8.1
  LAY5 w0.125: v1(89.4,104.9) 87.89,103.39 87.89,93.46 88.28,93.07 88.28,90.77 86.85,89.34 85.66,89.34 84.58,88.26 83.03,88.26 82.28,87.51 80.91,87.51 78.89,85.49 73.17,85.49 72.64,84.96 68.07,84.96 66.42,83.32 65.48,83.32 63.8,81.64 59.97,81.64 58.76,80.42 55.05,80.42 54.56,79.93 51.95,79.93 49.71,77.68 45.91,77.68 45.54,77.31 43.21,77.31 39.24,73.34 39.24,72.01 36.19,68.96 36.19,66.62 35.52,65.95 33.52,65.95 33.04,66.43 29.07,66.43 28.06,67.44 28.06,68.96 28.89,69.78 28.89,70.8 29.98,71.89 29.98,74.55 30.35,74.92 30.35,81.79 29.71,82.42 29.71,84.33 30.35,84.96 30.73,84.96 31.75,85.98 31.75,88.64 33.53,90.42 33.53,106.55 34.16,107.18 34.16,108.71 33.53,109.34 33.53,112.01 35.83,114.32 35.83,116.1 37.15,117.42 37.15,120.83 34.29,123.7 32.89,123.7 31.52,125.07 31.52,128.62 27.24,132.9 27.24,142.3 v1(26.46,143.08)
  BOTTOM w0.1: v1(26.46,143.08) 19.5,143.08 17.85,141.42 11.67,141.42 11.37,141.73 6.85,141.73 J9E8.1
SV_DETECT: length 21.3
  TOP w0.089: U6E1.N47 108.23,135.91 108,135.68 108,135.63 108,135.35 107.91,135.26 107.91,131.2 110.66,128.44 110.66,128.31
  TOP w0.1: 110.66,128.31 110.66,119.91 111.35,119.23 111.35,117.83 R6F1.2 R6F5.1
SVR_EN: length 5.2
  TOP w0.1: EU4B1.6 190.39,258.94 190.67,258.66 190.67,258.52 191.38,257.81 R4B3.1 191.64,257.43 191.89,257.17 193.8,257.17 R4B8.2
SW_I2C1_SCL_1.2K: length 1.9
  TOP w0.38: R8A6.2 SW8A2.3
SW_I2C1_SCL_2.7K: length 1.9
  TOP w0.38: R8A7.2 SW8A2.2
SW_I2C1_SCL_10K: length 1.9
  TOP w0.38: R8A8.2 SW8A2.1
SW_I2C1_SCL_22K: length 1.9
  TOP w0.38: R8A5.2 SW8A2.4
SW_I2C1_SDA_1.2K: length 1.9
  TOP w0.38: R8A2.2 SW8A1.3
SW_I2C1_SDA_2.7K: length 1.9
  TOP w0.38: R8A3.2 SW8A1.2
SW_I2C1_SDA_10K: length 1.9
  TOP w0.38: R8A4.2 SW8A1.1
SW_I2C1_SDA_820: length 1.9
  TOP w0.38: R8A1.2 SW8A1.4
SW_I2C2_SCL_1.2K: length 1.9
  TOP w0.38: SW8A3.3 R8A16.2
SW_I2C2_SCL_2.7K: length 1.9
  TOP w0.38: SW8A3.2 R8A15.2
SW_I2C2_SCL_10K: length 1.9
  TOP w0.38: SW8A3.1 R8A14.2
SW_I2C2_SCL_820: length 1.9
  TOP w0.38: SW8A3.4 R8A17.2
SW_I2C2_SDA_1.2K: length 1.9
  TOP w0.38: SW8A4.3 R8A20.2
SW_I2C2_SDA_2.7K: length 1.9
  TOP w0.38: SW8A4.2 R8A19.2
SW_I2C2_SDA_10K: length 1.9
  TOP w0.38: SW8A4.1 R8A18.2
SW_I2C2_SDA_22K: length 1.9
  TOP w0.38: SW8A4.4 R8A21.2
SW_ON_N: length 520.7
  TOP w0.089: U6E1.BE46 v1(91.87,136.76)
  TOP w0.1: R1C43.1 300.6,210.95 300.96,210.59 v1(300.99,210.59) ; R5H8.2 146.93,38.04 147.84,37.13 148.64,37.13 v1(149.09,37.59) 148.97,37.72 R5H15.1 R5H9.2 ; v1(95.63,97.28) 94.74,98.17 94.74,100.71 95.63,101.6 95.63,107.2 96.01,107.57 96.01,107.96 96.21,108.16 96.21,110.68 96.6,111.07 96.6,113.72 97.19,114.31 v1(97.19,114.93) 97.19,117.06 R7F29.2
  LAY5 w0.125: v1(100.07,18.41) 100.73,19.08 102.48,19.08 104.43,21.03 106.48,21.03 107.93,22.48 112.05,22.48 112.19,22.35 113.91,22.35 115.7,24.13 117.36,24.13 118.13,23.37 118.84,23.37 119.35,23.88 119.91,23.88 120.41,23.37 122.09,23.37 122.6,22.86 129.97,22.86 130.67,23.56 130.67,24.19 131.95,25.47 133.68,25.47 137.56,29.35 148.07,29.35 v1(148.97,28.45) 149.6,29.08 152.38,29.08 159.72,36.42 159.72,39.81 163.67,43.76 166.41,43.76 168.69,46.05 182.99,46.05 185.3,48.36 194.11,48.36 199.26,53.51 199.26,55.4 200.53,56.67 201.93,56.67 202.18,56.92 211.67,56.92 213.34,55.25 215.09,55.25 219.45,50.89 219.45,49.78 221.34,47.9 232.05,47.9 233.79,49.63 235.43,49.63 235.58,49.78 251.24,49.78 253.55,52.1 263.52,52.1 265.43,54 269.21,54 270.96,55.75 272.97,55.75 273.3,56.08 273.3,56.77 275.95,59.42 278.22,59.42 278.98,60.18 280.92,60.18 281.94,61.2 281.94,61.34 283.59,62.99 286.32,62.99 288.31,64.98 291.17,64.98 291.84,65.66 291.84,66.93 291.59,67.18 291.59,68.78 296.92,74.11 296.92,80.84 300.63,84.55 300.63,94.6 301.51,95.48 301.51,105.01 300.6,105.92 300.6,116.84 299.72,117.73 299.72,121.45 300.95,122.68 300.95,133.08 301.65,133.77 301.65,155.4 300.54,156.51 300.54,197.29 300.22,197.61 300.22,209.82 v1(300.99,210.59) ; v1(97.19,114.93) 96.76,114.93 94.1,117.59 94.1,125.86 93.59,126.36 93.59,133.86 91.87,135.58 v1(91.87,136.76)
  LAY6 w0.125: v1(148.97,28.45) 149.09,28.57 v1(149.09,37.59) ; v1(95.63,97.28) 95.63,95.88 97.92,93.58 97.92,62.75 100.34,60.33 100.34,41.26 100.71,40.89 100.71,39.37 99.72,38.38 99.72,32.76 99.56,32.61 99.56,29.59 99.18,29.21 99.18,19.3 v1(100.07,18.41)
SX_EXIT_HOLDOFF_N: length 38
  TOP w0.1: v1(34.27,91.78) 33.93,91.44 32.51,91.44 31.41,92.53 29.64,92.53 28.81,93.36 28.81,94.5 28.06,95.25 25.46,95.25 24.17,93.96 21.57,93.96 20.02,92.41 U8F6.67 ; v1(35.56,76.07) 35.05,75.56 35.05,75.18 R8G59.2
  LAY6 w0.125: v1(34.27,91.78) 33.78,91.29 33.78,89.99 34.25,89.52 34.25,77.38 v1(35.56,76.07)
SX_EXIT_HOLDOFF_N_ISH_GP_6: length 122.2
  TOP w0.089: 83.43,138.68 85.5,140.75 86.61,140.75 87.04,141.18 90.1,141.18 90.1,141.18 90.12,141.18 90.17,141.23 91.64,141.23 91.77,141.1 U6E1.BF36
  TOP w0.1: 83.43,138.68 81.25,136.5 78.4,136.5 77.54,135.63 v1(77.29,135.63) 77.08,135.63 76.79,135.34 74.76,135.34 74.29,134.87 R7E49.2 ; v1(58.69,66.67) 58.67,66.65 58.67,65.15 R8H3.1
  LAY5 w0.125: v1(66.99,97.6) 67.07,97.68 70.97,97.68 72.62,96.03 80.09,96.03 80.62,96.55 80.62,97.32 80.03,97.9 80.03,98.68 79.78,98.93 78.21,98.93 75.57,101.58 75.57,108.12 72.39,111.3 72.39,114.93 71.53,115.79 71.53,120.55 77.09,126.12 77.09,135.39 77.29,135.58 v1(77.29,135.63)
  LAY6 w0.125: v1(58.69,66.67) 59.71,67.69 61.02,67.69 63.22,69.9 63.22,76.4 61.08,78.54 61.08,93.09 60.96,93.22 60.96,94.61 62.22,95.88 65.27,95.88 v1(66.99,97.6)
SX_EXIT_HOLDOFF_PCH_N: length 89.3
  TOP w0.1: v1(69.34,133.48) 71.12,133.48 72.21,134.57 72.84,134.57 R7E49.1 ; v1(35.56,76.83) 35.43,76.71 R8G55.1 R8G59.1
  LAY6 w0.125: v1(34.41,109.85) 34.41,107.69 35.17,106.93 35.17,105.37 34.74,104.94 34.74,100.53 33.99,99.78 33.99,96.67 34.79,95.87 34.79,90.68 34.5,90.39 34.5,87.92 35.33,87.09 35.33,78.13 35.05,77.85 35.05,77.34 v1(35.56,76.83)
  BOTTOM w0.1: v1(34.41,109.85) 34.5,109.94 36.97,109.94 41.12,114.09 41.75,114.09 45.76,118.09 54.97,118.09 63.37,126.49 63.37,131.22 64.18,132.03 66.17,132.03 67.61,133.47 69.33,133.47 v1(69.34,133.48)
SX_EXIT_HOLDOFF_R1_N: length 13
  TOP w0.1: R8G55.2 v1(35.56,77.6) ; EU8G3.6 35.8,67.68 v1(35.68,67.56)
  LAY6 w0.125: v1(35.56,77.6) 36.19,76.96 36.19,72.41 35.17,71.4 35.17,69.34 35.68,68.83 v1(35.68,67.56)
SX_EXIT_HOLDOFF_R2_N: length 3.1
  TOP w0.1: EU8G3.11 35.8,73.42 R8G65.1 R8G64.1
TBT_BATLOW_N: length 9.4
  TOP w0.089: 160.38,265.01 161.54,265.01 U5A2.U2
  TOP w0.1: 160.38,265.01 159.97,265.01 159.76,264.8 159.51,264.8 159.33,264.62 156.76,264.62 R5A40.1 156.33,264.72 156.23,264.62 154.47,264.62 153.67,263.81 CR5A7.2
TBT_CIO_PLUG_EVENT_AIC_N: length 103.8
  TOP w0.1: v1(104.64,101.47) 104.14,101.98 104.14,102.49 103.88,102.74 103.88,104.95 104.34,105.41 104.34,108.03 105.79,109.47 105.79,111.38 105.58,111.58 105.58,116 106.04,116.46 R6F4.1 ; J6J1.14 123.82,31.24 122.68,32.38 R6F41.2 121.15,36.07 116.58,36.07 v1(115.82,35.3)
  LAY6 w0.125: v1(115.82,35.3) 115.82,35.69 118.74,38.61 118.74,40.51 118.49,40.76 118.49,49.2 118.74,49.46 118.74,57.25 114.29,61.7 114.29,75.14 110.72,78.71 110.09,78.71 109.3,79.51 109.3,80.15 108.73,80.71 107.38,80.71 106.17,81.93 106.17,95.73 104.64,97.25 v1(104.64,101.47)
TBT_CIO_PLUG_EVENT_N: length 31.6
  TOP w0.089: U6E1.Y46 104.31,136.22 104.31,135.67 104.28,135.64 104.28,135.22 104.22,135.15 104.09,135.02 104.09,130.9 103.63,130.45 103.63,129.92 104.01,129.54 104.01,128.97
  TOP w0.1: R6F28.2 104.77,108.02 106.01,109.27 106.01,111.47 105.81,111.68 105.81,113.93 106.5,114.62 106.5,117.78 R6F4.2 106.5,118.69 106.5,120.41 105.2,121.71 105.2,124.49 104.74,124.96 104.74,127.78 104.01,128.51 104.01,128.97
TBT_CIO_PWR_EN: length 115.9
  TOP w0.089: U6E1.M45 108.64,136.55 108.6,136.51 108.6,136.21 108.48,136.1 108.48,135.3 108.29,135.1 108.29,131.35 110.36,129.28 110.67,129.28 110.71,129.25
  TOP w0.1: 110.71,129.25 111.12,128.84 111.12,120.1 111.81,119.41 111.81,117.58 111.6,117.38 111.6,112.55 113.03,111.12 113.03,109.98 112.47,109.42 112.47,108.91 111.37,107.82 111.37,105.92 v1(111.88,105.41) ; R6H44.2 121,35.43 v1(121.25,35.18)
  LAY6 w0.125: v1(111.88,105.41) 112.39,104.9 112.39,104.47 112.64,104.22 112.64,101.24 114.68,99.21 114.68,88.32 120.05,82.95 120.05,79.61 122.3,77.36 122.3,72.29 119.5,69.49 119.5,62.08 124.38,57.2 124.38,38.3 v1(121.25,35.18)
TBT_FRC_PWR: length 34.5
  TOP w0.089: 104.48,129 104.48,129.5 104.76,129.78 104.76,135.51 104.54,135.73 U6E1.Y47
  TOP w0.1: 104.48,129 104.48,128.68 105.22,127.95 105.22,125.13 105.66,124.68 105.66,121.89 106.95,120.6 106.95,114.43 106.26,113.74 106.26,111.87 106.47,111.66 106.47,109.08 106.04,108.65 R6F26.2 105.53,107.69 105.53,106.3 105.79,106.04 105.79,104.14 R6F36.2
TBT_FRC_PWR_AIC: length 96.4
  TOP w0.1: v1(106.17,101.73) 106.17,102.61 R6F36.1
  LAY5 w0.125: v1(112.52,31.37) 114.25,33.1 120.64,33.1 122.55,31.19 J6J1.12
  LAY6 w0.125: v1(112.52,31.37) 112.52,32.51 114.54,34.54 115.97,34.54 116.33,34.9 116.33,35.66 118.99,38.33 118.99,40.64 118.74,40.89 118.74,49.1 118.99,49.35 118.99,57.35 116.58,59.77 116.58,73.2 112.01,77.78 112.01,78.48 112.77,79.25 112.77,79.88 111.69,80.97 107.49,80.97 106.42,82.03 106.42,95.83 104.9,97.36 104.9,100.45 v1(106.17,101.73)
TBT_FRC_PWR_BP: length 221.6
  TOP w0.089: U5A2.V4 162.79,264.8 v2(162.79,264.83)
  TOP w0.1: v1(105.99,106.55) 106.04,106.6 R6F26.1
  LAY5 w0.125: v1(105.99,106.55) 105.99,107.63 106.88,108.52 107.56,108.52 107.82,108.27 107.82,107.06 108.07,106.81 110.49,106.81 112.26,108.58 112.26,109.5 113.15,110.39 113.15,114.12 119.31,120.28 121.42,120.28 126.5,125.35 126.5,126.36 127.7,127.56 130.12,127.56 130.28,127.72 130.28,128.96 130.73,129.41 131.51,129.41 132.13,130.03 132.13,131.73 138.81,138.4 138.81,152.41 131.44,159.79 131.44,164.37 132.23,165.16 132.23,171.09 131.77,171.55 131.77,175.79 131.32,176.25 131.32,177.51 129.3,179.52 129.3,184.58 129.94,185.21 129.94,188.27 130.43,188.77 130.43,190.54 131.38,191.49 131.38,192.38 131.91,192.91 131.91,196.13 129.91,198.13 129.91,208.75 129.79,208.88 129.79,211.5 129.01,212.28 127.69,212.28 127.15,212.83 v1(127.12,212.83)
  LAY6 w0.125: v1(153.16,262.38) 153.44,262.1 153.44,261.11 153.18,260.86 149.07,260.86 148.68,260.47 146.36,260.47 146.05,260.16 146.05,259.6 145.4,258.95 143.76,258.95 141.9,257.1 141.9,256.42 140.88,255.39 137.78,255.39 130.74,248.35 130.74,246.76 122.99,239.01 122.99,238.45 122.55,238.01 122.55,235.88 123.7,234.74 123.7,226.74 125.53,224.9 125.53,217.83 126.63,216.74 126.63,213.32 v1(127.12,212.83)
  BOTTOM w0.1: v2(162.79,264.83) 162.76,264.8 161.68,264.8 161.37,264.49 161.37,263.82 160.27,262.73 159.46,262.73 158.87,263.31 R5L15.1 158.41,262.93 157.56,262.93 R5L14.1 155.88,263.7 154.35,263.7 153.28,262.63 153.28,262.51 v1(153.16,262.38)
TBT_PA_HPD: length 10.3
  TOP w0.1: R5A30.1 152.78,267.08 152.65,266.95 v1(152.65,266.7) ; EU5A1.30 146.21,265.13 147.13,264.22 148.98,264.22 v1(149.22,263.98)
  BOTTOM w0.1: v1(149.22,263.98) 149.22,264.54 149.86,265.17 151.51,265.17 151.89,265.56 151.89,266.19 152.4,266.7 v1(152.65,266.7)
TBT_PB_HPD: length 12
  TOP w0.1: v1(149.98,264.29) 149.82,264.45 147.39,264.45 146.3,265.53 EU5A1.31
  BOTTOM w0.1: R5L11.1 155.82,266.06 153.67,266.06 152.14,264.54 150.24,264.54 v1(149.98,264.29)
TBT_PCIE_RBIAS: length 2.6
  TOP w0.1: U5A2.N16 v2(168.64,266.1)
  BOTTOM w0.089: R5L10.1 170.55,265.68 170.46,265.78 168.97,265.78 v2(168.64,266.1)
TBT_PD_I2C_CLK: length 18.9
  TOP w0.089: U5A2.V2 161.54,264.55 160.4,264.55 160.14,264.29 v1(160.17,264.29)
  TOP w0.1: R5A37.1 v1(149.22,265.43)
  BOTTOM w0.1: v1(160.17,264.29) 160.62,264.74 160.62,265.97 159.73,266.85 157.6,266.85 157,267.46 152.22,267.46 151.72,266.95 148.97,266.95 148.59,266.57 148.59,266.06 v1(149.22,265.43)
TBT_PD_I2C_DATA: length 16.8
  TOP w0.089: U5A2.V1 160.83,264.32 160.28,263.77 159.9,263.77 v1(159.79,263.65)
  TOP w0.1: R5A32.1 v1(149.22,266.44)
  BOTTOM w0.1: v1(159.79,263.65) 159.76,263.65 159.63,263.78 159.63,264.67 160.14,265.17 160.14,265.65 159.23,266.55 157.44,266.55 156.84,267.16 152.34,267.16 151.51,266.32 149.35,266.32 v1(149.22,266.44)
TBT_PLUG_EVENT_N: length 246.2
  TOP w0.089: U5A2.AA1 161.21,262.94 160.9,262.63 160.9,262.38
  TOP w0.1: v1(118.74,252.73) 119.24,253.22 125.95,253.22 127.04,252.14 145.43,252.14 147.76,254.46 152.85,254.46 154.92,256.54 158.75,256.54 160.4,258.19 160.4,261.24 160.58,261.42 160.58,261.67 160.9,262 160.9,262.38 ; 104.64,103.25 104.14,103.76 104.14,104.39 R6F35.2 104.9,105.15 v1(104.9,105.79) 104.77,105.92 R6F28.1
  LAY5 w0.125: v1(104.9,105.79) 105.15,106.05 105.15,107.5 107,109.35 108.33,109.35 110.1,111.12 110.1,114.86 112.59,117.35 113.91,117.35 117.85,121.28 121.01,121.28 125.49,125.77 125.49,131.26 126.44,132.21 131.19,132.21 137.28,138.3 137.28,152.51 130.42,159.37 130.42,164.78 131.21,165.57 131.21,170.13 127.63,173.71 127.63,179.7 127.12,180.21 127.12,181.25 127.37,181.5 127.37,187.45 v1(126.61,188.21)
  LAY6 w0.125: v1(126.61,188.21) 125.83,188.21 124.84,189.2 124.84,192.91 121.92,195.83 115.69,195.83 107.69,203.83 107.69,210.95 104.52,214.12 104.52,227.2 104.01,227.71 104.01,229.87 110.23,236.09 110.23,240.7 109.21,241.72 109.21,243.07 118.74,252.6 v1(118.74,252.73)
TBT_RBIAS: length 2.2
  TOP w0.1: U5A2.J6 v2(163.44,268.7)
  BOTTOM w0.1: v2(163.44,268.7) 163.06,268.32 162.78,268.32 162.44,267.98 R5L6.2
TBT_RSENSE: length 1.3
  TOP w0.1: U5A2.J5 v2(162.79,268.7)
  BOTTOM w0.1: R5L6.1 162.05,268.86 162.3,268.86 162.45,268.7 v2(162.79,268.7)
TBT_RST_N: length 46.9
  TOP w0.1: v1(139.95,263.02) 139.95,263.27 140.16,263.48 EU5A1.16
  LAY5 w0.125: v1(162.43,272.92) 161.51,273.84 144.85,273.84 141.83,276.86 138.24,276.86 135.25,273.86 135.25,271.67 134.64,271.06 134.64,269.67 134.11,269.13 v1(134.11,267.71)
  BOTTOM w0.1: v1(139.95,263.02) 138.68,264.29 137.16,264.29 135.12,266.32 134.74,266.32 134.11,266.95 v1(134.11,267.71) ; v1(162.43,272.92) 162.43,272.67 R5L2.2
TBT_RST_R_N: length 13.9
  TOP w0.1: R5A26.2 153.03,272.03 v1(152.9,271.91) ; U5A2.E5 v2(162.79,270.65)
  LAY5 w0.125: v2(162.79,270.65) 160.73,272.71 153.71,272.71 v1(152.9,271.91)
  BOTTOM w0.1: R5L2.1 R5L1.1 162.81,270.67 v2(162.79,270.65)
TBT_SLP_S3_N: length 5.7
  TOP w0.1: R5A43.1 156.84,263.65 158.36,263.65 R5A44.1 159.4,264.16 160.03,264.78 U5A2.U1
TBT_TCK: length 4.8
  TOP w0.1: v2(169.29,264.15) U5A2.W19
  BOTTOM w0.1: R5L22.1 168.02,262.13 168.42,262.53 TP5L2.1 168.98,262.86 169.39,262.86 169.59,263.07 169.59,263.85 v2(169.29,264.15)
TBT_TDI: length 2.4
  TOP w0.1: v2(169.94,263.48) 169.94,263.5 170.27,263.83 U5A2.W20
  BOTTOM w0.1: v2(169.94,263.48) 169.96,263.5 TP4L2.1 170.68,262.51 R5L18.1
TBT_TDO: length 3.4
  TOP w0.089: U5A2.Y19 169.29,263.5 v2(169.24,263.5)
  BOTTOM w0.1: v2(169.24,263.5) 169.24,263.45 168.88,263.09 168.22,263.09 TP5L1.1 167.38,262.63 167.13,262.89 R5L17.1
TBT_TMS: length 4
  TOP w0.089: U5A2.Y20 170.56,263.48 v2(170.56,264.15)
  BOTTOM w0.1: v2(170.56,264.15) 170.69,264.03 TP4L1.1 171.7,263.02 171.45,262.76 R4L2.1
TBT_TMU_CLK_OUT: length 4.5
  TOP w0.089: 160.39,262.51 160.39,262.78 161.02,263.4 U5A2.Y1
  TOP w0.1: 160.39,262.51 160.39,262.25 159.38,261.24 159.38,260.6 R5A64.1
TBT_TMU_CLKIN: length 11
  TOP w0.1: v2(164.09,264.15) 163.77,263.83 U5A2.W6
  BOTTOM w0.089: 162.3,264.54 162.41,264.54 162.47,264.48 163.77,264.48 v2(164.09,264.15)
  BOTTOM w0.1: R5L21.1 R5L16.1 156.84,262.63 159.13,262.63 159.33,262.43 160.4,262.43 161.67,263.69 161.67,264.41 161.79,264.54 162.3,264.54
TBT_USB_FORCE_PWR: length 7.8
  TOP w0.1: v2(163.44,264.13) 163.44,264.15 U5A2.V5
  BOTTOM w0.089: 163.12,263.2 163.12,263.36 163.12,263.81 v2(163.44,264.13)
  BOTTOM w0.1: 163.12,263.2 163.12,262.15 161.64,260.68 159.81,260.68 159.63,260.86 R5L23.1 R5L24.1
TBT_WAKE_AIC_N: length 135.6
  TOP w0.1: R7F44.1 R7F48.1 83.94,111.38 83.94,110.44 82.19,108.69 82.19,101.48 81.4,100.7 81.4,100.28 v1(79.55,98.42)
  LAY5 w0.125: v1(76.96,32.23) 77.49,32.76 110.44,32.76 112.32,30.88 113.56,30.88 114.04,31.37 115.67,31.37 116.18,31.88 120.29,31.88 121.28,30.89
  LAY6 w0.125: v1(76.96,32.23) 80.52,35.8 80.52,43.3 79.88,43.94 79.88,47.54 80.99,48.66 80.99,54.58 81.92,55.51 81.92,61.61 81.7,61.84 81.7,71.28 80.74,72.23 80.74,76.17 82.04,77.47 82.04,78.73 81.63,79.14 81.63,83.46 80.91,84.18 80.91,94.49 78.23,97.18 78.23,98.55 78.48,98.8 79.17,98.8 v1(79.55,98.42)
TBT_WAKE_N: length 8.4
  TOP w0.089: 160.01,262.6 160.01,262.67 160.98,263.63 161.54,263.63 U5A2.Y2
  TOP w0.1: R5A63.2 R5A57.1 156.84,260.6 158.62,260.6 158.87,260.86 R5A58.2 158.87,261.24 160.01,262.38 160.01,262.6
TBT_XTAL_25_IN: length 4.6
  TOP w0.1: R4A5.1 172.72,274.06 171.82,273.17 171.82,271.14 171.67,270.99 171.19,270.99 U5A2.D22
TBT_XTAL_25_IN_R: length 2.5
  TOP w0.1: R4A5.2 C4A7.1 173.6,275.72 Y4A1.1
TBT_XTAL_25_OUT: length 5.6
  TOP w0.1: U5A2.D23 171.75,270.76 172.08,271.09 172.08,272.92 172.97,273.81 173.99,273.81 R4A6.1
TBT_XTAL_25_OUT_R: length 4.8
  TOP w0.1: R4A6.2 C4A8.1 173.99,275.72 173.99,277.02 Y4A1.3
TBTA_RX1_ESD_N: length 22.5
  TOP w0.1: U5A2.A21 170.48,272.17 170.48,272.95 arc(170.5,273.06) 170.56,273.15 arc(170.7,273.37) 170.76,273.63 170.76,276.54 arc(170.94,277.46) 171.46,278.24 172.06,278.84 arc(172.29,279) 172.56,279.09 arc(173.1,279.25) 173.56,279.58 174.99,281.01 arc(175.3,281.47) 175.41,282.01 175.41,282.18 arc(175.41,282.23) 175.44,282.27 CR4A4.1 175.47,282.63 arc(175.44,282.67) 175.43,282.72 175.43,282.89 arc(175.45,282.98) 175.5,283.06 176.03,283.59 arc(176.17,283.8) 176.22,284.04 176.22,285.89 arc(176.09,286.55) 175.71,287.12 175.4,287.43 arc(175.05,287.66) 174.64,287.74 174.11,287.74 arc(173.57,287.63) 173.1,287.32 172.83,287.05 arc(172.73,286.9) 172.69,286.73 172.69,286.17 arc(172.69,286.13) 172.66,286.1 172.63,286.06 arc(172.61,286.03) 172.6,285.99 J4A1.B10
TBTA_RX1_ESD_P: length 22.5
  TOP w0.089: 170.28,272.41 170.28,271.85 arc(170.28,271.81) 170.31,271.77 170.38,271.71 arc(170.4,271.69) 170.44,271.68 U5A2.B21
  TOP w0.1: 170.28,272.41 170.28,272.95 arc(170.31,273.13) 170.42,273.29 arc(170.52,273.44) 170.56,273.63 170.56,276.54 arc(170.75,277.54) 171.32,278.38 171.92,278.98 arc(172.2,279.18) 172.53,279.28 arc(173.01,279.43) 173.42,279.72 174.85,281.15 arc(175.11,281.55) 175.21,282.01 175.21,282.21 arc(175.2,282.25) 175.17,282.3 CR4A3.1 175.19,282.65 arc(175.22,282.7) 175.23,282.74 175.23,282.89 arc(175.26,283.06) 175.36,283.2 175.89,283.73 arc(175.98,283.87) 176.02,284.04 176.02,285.89 arc(175.9,286.48) 175.57,286.98 175.26,287.29 arc(174.97,287.48) 174.64,287.54 174.11,287.54 arc(173.64,287.45) 173.25,287.18 172.97,286.91 arc(172.91,286.82) 172.89,286.73 172.89,286.27 arc(172.9,286.22) 172.93,286.18 173.06,286.05 arc(173.09,286.01) 173.1,285.96 J4A1.B11
TBTA_RX2_ESD_N: length 13.4
  TOP w0.089: 167.98,272.41 167.98,272.02 arc(167.95,271.92) 167.9,271.83 U5A2.B15
  TOP w0.1: 167.98,272.41 167.98,272.92 arc(167.92,273.19) 167.76,273.43 arc(167.39,273.99) 167.25,274.66 167.25,280.22 arc(167.36,280.74) 167.65,281.18 167.94,281.47 arc(168.13,281.75) 168.19,282.07 168.19,282.2 arc(168.2,282.25) 168.23,282.29 CR5A2.1 168.22,282.64 arc(168.18,282.7) 168.17,282.77 168.17,282.8 arc(168.2,282.98) 168.3,283.13 168.59,283.42 arc(168.69,283.57) 168.73,283.75 168.73,283.88 arc(168.74,283.95) 168.79,284.02 168.85,284.08 J4A1.A10
TBTA_RX2_ESD_P: length 13.4
  TOP w0.089: 167.78,272.78 167.78,272.7 arc(167.75,272.59) 167.69,272.49 167.57,272.37 arc(167.53,272.31) 167.52,272.24 167.52,272.13 arc(167.58,272.02) 167.71,272.05 167.75,272.08 U5A2.A15
  TOP w0.1: J4A1.A11 168.49,283.94 arc(168.52,283.9) 168.53,283.85 168.53,283.75 arc(168.51,283.65) 168.45,283.56 168.16,283.27 arc(168.02,283.06) 167.97,282.8 167.97,282.74 arc(167.95,282.67) 167.91,282.61 CR5A1.1 arc(167.8,282.38) 167.88,282.35 arc(167.96,282.31) 167.99,282.23 167.99,282.07 arc(167.94,281.82) 167.8,281.61 167.51,281.32 arc(167.17,280.82) 167.05,280.22 167.05,274.66 arc(167.2,273.92) 167.62,273.29 arc(167.74,273.12) 167.78,272.92 167.78,272.78
TBTA_SBU1: length 2.9
  TOP w0.1: v2(163.44,269.35) 162.79,269.35 162.47,269.03 U5A2.H4
  BOTTOM w0.1: R5L4.2 162.57,269.35 v2(163.44,269.35)
TBTA_SBU2: length 2.6
  TOP w0.1: U5A2.J4 162.15,268.07 162.15,267.43 v2(162.18,267.4)
  BOTTOM w0.1: v2(162.18,267.4) 161.47,267.4 R5L7.2
TBTA_TX1_C_N: length 2.6
  TOP w0.089: 169.36,272.41 169.36,272.02 arc(169.38,271.92) 169.43,271.83 U5A2.B19
  TOP w0.1: 169.36,272.41 169.36,272.75 arc(169.34,272.82) 169.31,272.89 arc(169.23,273.06) 169.21,273.25 169.21,273.71 arc(169.2,273.76) 169.17,273.8 169.06,273.91 arc(169.01,273.94) 168.97,273.95 C5A16.2
TBTA_TX1_C_P: length 2.6
  TOP w0.089: U5A2.A19 169.59,272.08 169.62,272.05 arc(169.75,272.02) 169.82,272.13 169.82,272.24 arc(169.8,272.31) 169.76,272.37 169.64,272.49 arc(169.58,272.59) 169.56,272.7
  TOP w0.1: 169.56,272.7 169.56,272.75 arc(169.54,272.88) 169.48,273 arc(169.42,273.12) 169.41,273.25 169.41,273.62 arc(169.42,273.72) 169.48,273.8 169.56,273.88 arc(169.64,273.93) 169.73,273.95 C5A17.2
TBTA_TX1_ESD_N: length 11.2
  TOP w0.1: J4A1.A3 172.35,283.79 arc(172.36,283.72) 172.41,283.66 172.76,283.3 172.93,283.14 arc(173.01,283.03) 173.06,282.91 arc(173.07,282.86) 173.07,282.79 arc(173.05,282.7) 173,282.62 CR4A1.1 173.03,282.27 arc(173.06,282.23) 173.07,282.18 173.07,282.07 arc(172.97,281.57) 172.69,281.15 170.4,278.86 arc(169.54,277.57) 169.24,276.06 169.24,275.19 arc(169.22,275.12) 169.18,275.05 168.96,274.83 C5A16.1
TBTA_TX1_ESD_P: length 11.2
  TOP w0.1: C5A17.1 169.54,274.83 arc(169.47,274.86) 169.44,274.93 169.44,276.06 arc(169.72,277.5) 170.54,278.72 172.83,281.01 arc(173.16,281.5) 173.27,282.07 173.27,282.2 arc(173.28,282.25) 173.31,282.29 CR4A2.1 173.3,282.64 arc(173.28,282.67) 173.27,282.71 173.27,282.79 arc(173.22,283.06) 173.07,283.28 172.91,283.44 arc(172.86,283.51) 172.85,283.58 J4A1.A2
TBTA_TX2_C_N: length 5
  TOP w0.089: 168.9,272.41 168.9,272.02 arc(168.87,271.92) 168.82,271.83 U5A2.B17
  TOP w0.1: 168.9,272.41 168.9,272.75 arc(168.84,273.03) 168.67,273.28 168.65,273.3 arc(168.42,273.65) 168.34,274.05 168.34,275.61 arc(168.42,276.02) C5A13.2
TBTA_TX2_C_P: length 5
  TOP w0.089: U5A2.A17 168.67,272.08 168.63,272.05 arc(168.5,272.02) 168.44,272.13 168.44,272.24 arc(168.45,272.31) 168.49,272.37 168.61,272.49 arc(168.67,272.59) 168.7,272.7
  TOP w0.1: 168.7,272.7 168.7,272.75 arc(168.69,272.76) 168.69,272.78 arc(168.65,272.97) 168.53,273.14 168.51,273.16 arc(168.24,273.57) 168.14,274.05 168.14,275.86 arc(168.12,275.98) 168.05,276.07 C5A12.2
TBTA_TX2_ESD_N: length 11.8
  TOP w0.1: C5A13.1 168.31,277.58 arc(168.28,277.62) 168.27,277.67 168.27,278.63 arc(168.34,278.98) 168.54,279.27 168.86,279.59 arc(169.17,280.07) 169.29,280.63 169.29,280.82 arc(169.31,280.93) 169.37,281.03 CR5A6.1 169.54,281.52 arc(169.55,281.57) 169.58,281.61 169.64,281.67 arc(169.66,281.7) 169.67,281.74 v1(169.67,281.83) ; J4A1.B3 169.1,286.51 arc(169.12,286.59) v1(169.16,286.65)
  LAY5 w0.115: v1(169.16,286.65) 168.97,286.47 arc(168.91,286.38) 168.89,286.27 168.89,285.57 arc(168.88,285.47) 168.84,285.38 arc(168.79,285.29) 168.78,285.19 168.78,284.63 arc(168.79,284.57) 168.82,284.52 169.6,283.75 arc(169.83,283.2) 169.6,282.65 arc(169.45,282.46) 169.36,282.23 arc(169.36,282.23) 169.36,282.22 arc(169.38,282.14) 169.42,282.07 v1(169.67,281.83)
TBTA_TX2_ESD_P: length 11.8
  TOP w0.1: J4A1.B2 168.6,286.16 arc(168.55,286.43) v1(168.4,286.65) ; v1(168.78,281.83) 168.78,281.74 arc(168.79,281.7) 168.81,281.67 168.87,281.61 arc(168.9,281.57) 168.91,281.52 CR5A5.1 168.95,281.15 arc(169.05,281) 169.09,280.82 169.09,280.63 arc(168.99,280.14) 168.72,279.73 168.4,279.41 arc(168.16,279.05) 168.07,278.63 168.07,277.6 arc(168.06,277.55) 168.03,277.51 C5A12.1
  LAY5 w0.115: v1(168.4,286.65) 168.58,286.47 arc(168.64,286.38) 168.66,286.27 168.66,285.57 arc(168.66,285.54) 168.64,285.51 arc(168.57,285.35) 168.55,285.19 168.55,284.63 arc(168.58,284.48) 168.66,284.36 169.44,283.58 arc(169.6,283.2) 169.44,282.81 arc(169.25,282.57) 169.14,282.29 arc(169.12,282.2) 169.07,282.12 v1(168.78,281.83)
TCH_PNL_I2C_EN: length 20
  TOP w0.1: Q8E6.1 39.75,150.11 39.62,149.99 36.19,149.99 36.04,150.14 Q8E5.1 35.43,150.88 34.54,149.99 33.9,149.99 33.02,149.1 33.02,147.45 32.51,146.94 R8E39.2 33.65,146.05 34.06,145.64 Q8E8.1 35.07,143.76 37.59,143.76 37.84,144.02 Q8E7.1
