# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SATA2_PWR_EN_R: length 9.2
  TOP w0.1: R8H66.2 R8H70.1 45.97,29.84 44.7,28.57
PCH_SATA3_PWR_EN: length 191.4
  TOP w0.089: 110.16,127.91 110.16,128.41 108.96,129.6 107.53,131.04 107.53,135.42 107.57,135.46 U6E1.P48
  TOP w0.1: v1(43.68,38.99) 43.43,38.99 42.92,38.48 42.92,37.34 42.54,36.96 ; v1(110.36,103.88) 109.32,104.93 109.32,106.48 110.16,107.32 110.16,127.91
  LAY5 w0.125: v1(123.19,41.53) 105.89,41.53 105.76,41.65 94.1,41.65 90.53,38.08 90.53,37.44 89.66,36.57 79.5,36.57 78.95,37.12 75.72,37.12 75.01,37.84 67.81,37.84 66.92,36.95 66.24,36.95 65.86,37.33 64.81,37.33 64.3,36.82 52.07,36.82 49.66,39.23 47.69,39.23 47.05,38.6 46.11,38.6 45.84,38.86 45.84,39.25 45.48,39.62 45.2,39.62 44.57,38.99 v1(43.68,38.99)
  LAY6 w0.125: v1(110.36,103.88) 110.36,101.75 113.42,98.69 113.42,87.8 118.79,82.43 118.79,78.93 120.77,76.95 120.77,71.83 118.74,69.8 118.74,60.75 121.87,57.62 121.87,57.19 122.68,56.39 122.68,49.53 123.57,48.64 123.57,42.31 123.19,41.93 v1(123.19,41.53)
PCH_SATA3_PWR_EN_R: length 6.5
  TOP w0.1: R8H69.1 R8H65.2 43.68,32.13 44.7,31.11
PCH_SATA_LED_BJT2: length 5.6
  TOP w0.1: R9G40.2 20.32,65.78 19.43,64.9 18.76,64.9 18.66,65 Q9G6.6 18.66,66.42 18.54,66.55 18.16,66.55 18.01,66.4 Q9G6.5
PCH_SATA_LED_N: length 6.6
  TOP w0.38: Q9G6.2 18.01,69.07 18.28,69.34 18.92,69.34 19.17,69.59 R9G35.2 R9G36.2 R9G38.2 R9G39.2
PCH_SLP_A_APS_N: length 3
  TOP w0.1: J9H3.6 18.41,37.84 20.19,37.84 R9H19.1
PCH_SLP_A_N: length 328.9
  TOP w0.089: U6E1.BE40 92.51,139.33 91.88,139.33 91.81,139.4 90.88,139.4 90.73,139.25 88.32,139.25 87.08,138.01 86.96,138.01
  TOP w0.1: v1(53.46,45.08) 53.66,45.28 EU8H1.9 ; R8E17.1 v1(30.6,152.91) ; J8J13.24 47.52,16.28 J8J10.2 ; 86.96,138.01 85.61,138.01 81.96,134.36 81.37,134.36 80.48,133.48 78.32,133.48 76.85,132 75.91,132 75.48,131.57 73.74,131.57 72.75,130.58 70.83,130.58 69.08,128.83 69.08,124.47 68.31,123.7 66.04,123.7 63.55,126.19 63.55,133.4 61.36,135.58 61.36,140.31 60.14,141.53 60.14,146.63 60.32,146.81 60.32,151.41 v1(59.18,152.55) ; v1(19.17,37.21) 19.43,36.96 20.95,36.96 R9H19.2 ; C8H22.1 44.83,40.13 42.54,40.13 R8H55.1 41.27,39.88 v1(41.27,39.75)
  LAY6 w0.125: J8J13.24 44.63,12 42.47,12 41.52,12.95 41.52,22.6 41.14,22.99 41.14,24.51 41.52,24.89 41.52,36.57 40.76,37.34 40.76,38.35 41.27,38.86 v1(41.27,39.75) ; v1(19.17,37.21) 19.17,37.97 18.54,38.61 17.52,38.61 16.88,39.25 16.88,47.17 19.49,49.79 19.49,65.04 18.16,66.38 18.16,80.77 18.87,81.49 18.87,99.48 18.28,100.07 18.28,105.66 19.05,106.42 19.05,107.95 18.28,108.71 18.28,120.65 19.43,121.79 19.43,130.68 17.65,132.46 17.65,138.55 18.28,139.19 v1(18.28,154.86)
  BOTTOM w0.1: v1(19.17,37.21) 20.12,36.26 20.12,35.37 20.98,34.51 21.62,34.51 23.61,32.53 25.78,32.53 26.29,33.03 34.03,33.03 39.73,38.73 40.25,38.73 v1(41.27,39.75) 41.65,40.13 48.51,40.13 v1(53.46,45.08) ; v1(18.28,154.86) 19.17,153.98 24.91,153.98 25.7,153.19 30.32,153.19 v1(30.6,152.91) 30.88,153.19 40.15,153.19 40.59,153.62 52.16,153.62 52.93,152.86 58.87,152.86 v1(59.18,152.55)
PCH_SLP_S0_N: length 23.9
  TOP w0.089: 83.28,144.52 83.88,145.11 83.99,145.11 84.19,145.31 88.24,145.31 88.38,145.46 91.54,145.46 91.75,145.24 92.32,145.24 92.35,145.21 92.56,145.21 92.64,145.13 92.96,145.13 93.01,145.09 U6E1.BC28
  TOP w0.1: 83.28,144.52 80.01,144.52 79.39,143.89 78.2,143.89 77.72,143.41 76.98,143.41 76.61,143.03 72.66,143.03 72.24,142.62 70.73,142.62
PCH_SPI_OE_N: length 53
  TOP w0.1: Q7G1.3 79.35,91.82 77.08,89.55 77.08,87.63 76.28,86.82 U7G1.4 73.99,86.82 73.5,86.33 73.05,86.33 72.77,86.61 72.77,87.12 73.6,87.96 73.6,88.62 73.76,88.77 U7G1.1 v1(74.67,89.41) ; v1(83.05,80.01) 82.61,79.57 U7G2.10 v1(79.12,79.57) ; v1(82.82,85.72) 82.38,86.17 79.43,86.17 78.58,87.02 78.58,87.73 78.97,88.12 U7G1.13 v1(82.01,88.12) ; R7G14.2 72.89,82.17 U7G2.1 75.69,82.17 v1(76.96,80.9) 76.28,80.22 U7G2.4
  BOTTOM w0.1: v1(82.82,85.72) 82.82,83.06 82.55,82.78 82.55,80.52 v1(83.05,80.01) ; v1(79.12,79.57) 78.29,79.57 v1(76.96,80.9) ; v1(82.01,88.12) 82.01,88.67 81.53,89.15 78.99,89.15 78.45,89.69 74.96,89.69 v1(74.67,89.41)
PCH_SPKR_AMP_PD_N: length 176.6
  TOP w0.1: 35.43,258.19 33.78,256.54 Q8B2.2 ; 35.43,258.19 v1(36.19,258.19) ; 35.43,258.19 35.43,258.82 34.03,260.22 30.35,260.22 29.97,260.6 v1(29.97,263.78) CR8A1.1 27.94,263.78 26.41,262.25 R8A30.1 ; U6E1.AV7 v1(95.33,155.29)
  LAY5 w0.125: v1(72.79,258.7) 72.77,258.7 71.9,257.83 63.89,257.83 61.86,255.81 60.57,255.81 60.23,256.16 53.43,256.16 52.81,256.78 37.35,256.78 36.19,257.94 v1(36.19,258.19)
  BOTTOM w0.089: v1(95.33,155.29) 95.33,155.71 95.44,155.82 95.44,156.4 95.56,156.51 95.56,158.56 94.61,159.51
  BOTTOM w0.1: v1(72.79,258.7) 78.71,252.78 79.44,252.78 84.64,247.58 84.64,242.32 84.35,242.03 84.35,222.71 78.83,217.19 78.83,199.62 79.4,199.05 79.4,179.55 79.78,179.16 79.78,177.13 81.53,175.39 83.31,175.39 89.02,169.67 89.02,165.8 94.61,160.21 94.61,159.51
PCH_SRTCRST_N: length 359.5
  TOP w0.089: U6E1.BD46 v1(93.18,136.39)
  TOP w0.1: v1(83.05,113.44) 82.37,114.11 82.37,115.1 C7F7.1 R7F23.2 ; J8J13.28 54.98,12.57 TP8J2.1 54.99,18.74 v1(54.73,19)
  LAY5 w0.125: v1(84.45,20.83) 83.56,21.72 68.76,21.72 67.64,20.6 60.98,20.6 60.44,20.06 58.66,20.06 57.65,19.05 54.78,19.05 v1(54.73,19) 53.97,19.76 53.97,20.57 53.48,21.06 52.48,21.06 50.78,19.36 50.78,17.47 49.81,16.5 27.41,16.5 24.86,19.05 22.22,19.05 21.71,19.56 14.6,19.56 13.71,18.67 13.71,17.14 12.57,16 v1(10.53,16)
  LAY6 w0.125: v1(84.45,20.83) 85.45,21.82 85.45,26.2 84.59,27.06 84.59,40.14 85.09,40.64 85.09,41.65 84.32,42.42 84.32,43.55 85.09,44.32 85.72,44.32 86.28,44.88 86.28,45.67 85.6,46.35 85.6,50.12 87.42,51.93 87.42,59.48 88.2,60.27 88.2,62.34 87.84,62.71 87.84,63.68 89.29,65.13 89.29,72.54 88.01,73.83 88.01,76.58 88.13,76.71 88.13,79.93 87.29,80.77 87.29,96.09 v1(82.67,100.71) ; v1(10.53,16) 10.2,16.33 10.2,48.41 8.73,49.88 8.73,55.96 9.08,56.31 9.08,62.81 9.89,63.62 9.89,69.79 10.79,70.69 10.79,80.39 9.9,81.28 9.9,96.51 10.79,97.41 10.79,99.69 10.28,100.21 10.28,101.4 9.9,101.77 9.9,104.14 10.16,104.39 10.16,119.43 9.2,120.39 9.2,133.26 10.53,134.59 10.53,139.92 12.19,141.58 J9E6.2
  BOTTOM w0.1: v1(82.67,100.71) 82.89,100.93 82.89,113.28 v1(83.05,113.44) 83.08,113.44 83.82,114.17 83.82,115.06 82.55,116.33 82.55,116.84 83.56,117.85 83.68,117.85 83.78,117.96 83.78,119.35 87.46,123.03 87.46,126.55 91.96,131.04 91.96,132.35 92.58,132.97 92.58,134.74 93.47,135.63 93.47,136.1 v1(93.18,136.39)
PCH_SUSCLK: length 35.1
  TOP w0.089: U6E1.BE45 v1(92.71,137.2)
  TOP w0.1: R7F17.1 R7F18.1 R7F19.1 R7F20.1 R7F21.1 R7F22.1 v1(74.04,119.63)
  BOTTOM w0.1: v1(74.04,119.63) 78.61,119.63 80.93,121.95 80.93,124.22 83.66,126.95 83.66,129.67 84.68,130.7 85.73,130.7 87.87,132.84 89.99,132.84 91.33,134.18 91.33,135.49 92.32,136.48 92.32,136.82 v1(92.71,137.2)
PCH_SYSPWROK: length 789.5
  TOP w0.089: U6E1.AU3 96.14,157.71 96.14,158.25 96.1,158.29 96.1,160.18 94.02,162.26 92.73,162.26 90.65,164.34
  TOP w0.1: v1(64.41,180.41) 64.46,180.47 65.78,180.47 68.88,183.57 72.73,183.57 75.07,181.23 76.49,181.23 76.99,181.73 77.72,181.73 79.11,180.34 80.83,180.34 81.83,179.34 81.83,175.47 C7D2.1 81.91,175.26 82.56,174.61 87.18,174.61 90.08,171.71 90.08,164.91 90.65,164.34 ; R9G17.1 TP9G1.1 21.2,85.72 v1(20.95,85.47) ; v1(45.82,198.63) 43.05,198.63 42.67,199.01 42.03,199.01 R8C67.2 R8C66.2 40,199.39 40,198.2 40.13,198.07 40.13,196.72 39.97,196.56 Q8C12.3 38.51,196.56 38.48,196.59 R8C80.2 R8D1.2 36.57,195.32 35.94,194.69 31.49,194.69 29.75,192.94 29.75,190.53 29.01,189.8 26.09,189.8 25.63,189.34 v1(22.35,189.34) ; R1C37.1 301.62,214.25 302.51,215.14 v1(302.76,215.14)
  LAY5 w0.125: v1(20.06,17.65) 20.96,18.55 24.5,18.55 25.24,17.81 25.24,15.08 26.48,13.84 50.6,13.84 50.94,14.19 50.94,16.22 51.81,17.09 51.81,17.91 52.45,18.54 53.46,18.54 55.62,16.38 57.65,16.38 58.52,17.25 v1(59.94,17.25) 61.21,17.25 62.07,16.38 65.85,16.38 67.81,18.34 67.81,20.06 68.96,21.22 76.43,21.22 77.34,20.31 79.37,20.31 80.27,21.21 83.36,21.21 84.12,20.45 84.12,19.7 87.38,16.43 105.15,16.43 108.65,19.94 109.85,19.94 110.22,19.57 111.11,19.57 111.76,18.92 116.96,18.92 118.23,20.19 119.38,20.19 119.48,20.3 120.41,20.3 121.68,19.03 126.47,19.03 127.5,20.06 131.57,20.06 132.46,20.95 132.46,21.13 134.97,23.64 134.97,25.34 137.97,28.35 147.6,28.35 148.56,27.39 149.63,27.39 150.32,28.08 153.52,28.08 170.48,45.04 183.4,45.04 185.71,47.36 194.52,47.36 200.26,53.1 200.26,54.99 200.94,55.67 202.34,55.67 202.59,55.92 211.26,55.92 212.93,54.25 214.68,54.25 217.94,50.99 217.94,49.58 220.62,46.9 232.47,46.9 234.2,48.63 251.5,48.63 253.97,51.1 263.94,51.1 265.29,52.45 269.08,52.45 271.38,54.75 274.46,54.75 276.18,56.47 276.18,57.74 276.86,58.42 278.63,58.42 279.4,59.18 281.96,59.18 283,60.21 283.86,60.21 284.35,60.7 285.44,60.7 288.72,63.99 292.02,63.99 295.22,67.18 302.51,67.18 303.27,67.94 303.27,91.3 302.62,91.95 302.62,92.82 303.33,93.53 303.33,214.57 v1(302.76,215.14)
  LAY6 w0.125: v1(59.94,17.25) 59.94,9.53 J8J13.36 ; v1(22.35,189.34) 21.82,189.34 20.43,187.94 20.43,178.83 19.54,177.94 19.54,171.71 21.71,169.54 22.6,169.54 24.13,168.02 24.13,158.68 22.82,157.37 22.82,151.78 23.98,150.62 23.98,132.03 25.41,130.6 25.41,124.62 23.11,122.32 23.11,116.4 21.87,115.16 21.87,113.06 21.08,112.27 21.08,102.49 21.46,102.11 21.46,98.03 21.21,97.79 21.21,96.82 20.38,95.99 20.38,86.04 v1(20.95,85.47) 20.95,84.6 22.24,83.31 22.24,79.27 19.92,76.94 19.92,70.57 20.2,70.29 20.2,66.1 20.75,65.56 20.75,57.81 21.7,56.85 21.7,52.62 20.75,51.66 20.75,49.27 19.99,48.51 19.99,41.17 20.68,40.48 20.68,18.27 v1(20.06,17.65)
  BOTTOM w0.1: v1(64.41,180.41) 64.32,180.41 62.57,182.16 62.57,182.82 62.03,183.36 62.03,185.31 51.1,196.24 48.74,196.24 46.35,198.63 v1(45.82,198.63)
PCH_THERMTRIP_N: length 311.8
  TOP w0.1: R6D49.1 98.73,177.23 98.73,180.54 98.17,181.11 98.17,184.15 v1(98.8,184.78) ; v1(176.14,162.69) 174.37,164.46 174.37,166.88 R4D8.2 R4D5.1 ; v1(127.26,166.13) 127.26,166 134.49,158.77 138.27,158.77 139.83,157.22 146.91,157.22 148.09,156.03 148.09,151.29 145.61,148.81 145.61,132.19 147.11,130.7 150.75,130.7 151.82,129.63 151.82,124.94 154.59,122.17 v1(154.6,122.17)
  LAY5 w0.125: v1(109.85,186.43) 102.23,186.43 100.58,184.78 v1(98.8,184.78) ; v1(228.21,81.15) 227.95,80.89 225.64,80.89 224.99,81.53 218.44,81.53 217.97,82 210.14,82 206.46,85.68 201.61,85.68 200.02,87.27 198.9,87.27 197.43,88.75 187.43,88.75 186.93,88.24 181.31,88.24 174.55,81.49 170.51,81.49 168.65,79.63 168.65,79.21 165.86,76.42 164.81,76.42 164.25,75.86 157.19,75.86 155.82,74.49 v1(155.82,73.53)
  LAY6 w0.125: v1(109.85,186.43) 109.85,185.34 124.71,170.48 124.71,168.68 v1(127.26,166.13) ; v1(155.82,73.53) 155.95,73.66 155.95,83.69 153.03,86.61 153.03,96.49 154.19,97.65 154.19,113.41 153.41,114.19 153.41,117.9 154.6,119.09 v1(154.6,122.17) 154.6,132.12 155.63,133.16 157.16,133.16 158.36,134.36 158.36,139.19 156.84,140.71 156.84,145.63 160.18,148.97 165.6,148.97 168.71,152.08 168.71,155.45 169.48,156.21 173.48,156.21 175.64,158.37 175.64,159.76 176.14,160.27 v1(176.14,162.69)
PCH_THERMTRIP_R_N: length 19.8
  TOP w0.089: 102.33,164.52 102.33,164.27 102.22,164.16 102.22,161.05 102.22,161.05 102.33,160.94 102.33,157.96 102.35,157.94 102.35,157.78 U6E1.AD3
  TOP w0.1: 102.33,164.52 102.33,171.2 99.31,174.22 R6D49.2
PCH_WAKE_N: length 538.1
  TOP w0.089: U6E1.BB47 93.33,135.22 93.49,135.06 93.49,134.77 91.06,132.33 90.8,132.33
  TOP w0.1: R5A63.1 154.68,259.33 154.68,256.94 152.66,254.92 147.57,254.92 145.25,252.59 127.22,252.59 126.14,253.68 111.95,253.68 v1(111.25,254.38) ; v1(146.68,233.04) 147.32,232.41 R5B53.1 ; 69.46,247.65 66.16,247.65 65.91,247.9 65.91,249.81 65.53,250.19 63.24,250.19 62.48,250.95 62.48,255.27 62.2,255.55 60.61,255.55 59.99,256.16 v1(59.99,258.19) ; R8B22.2 R8B24.2 46.73,234.69 v1(47.37,235.33) ; v1(90.67,253.49) 90.55,253.36 90.55,252.03 90.39,251.87 90.39,251.21 90.17,250.99 90.17,248.71 90.47,248.41 92.6,248.41 92.98,248.03 94.23,248.03 94.99,248.79 94.99,250.44 R7B18.1 ; v1(86.23,129.03) 87.32,129.03 90.63,132.33 90.8,132.33 ; R5C13.1 165.35,218.28 v1(165.1,218.03) ; R8G79.2 28.82,68.07 29.33,68.58 29.33,69.59 30.22,70.48 v1(30.98,70.48) ; R7F49.2 R7F48.2 81.66,112.77 v1(81.66,112.9)
  LAY5 w0.125: v1(93.21,193.93) 89.53,190.24 89.53,189.23 88.51,188.21 88.51,178.94 91.46,176 91.46,161.47 89.66,159.67 89.66,152.17 88.39,150.9 88.39,140.33 86.99,138.94 86.99,130.05 86.74,129.79 86.74,129.16 86.61,129.03 v1(86.23,129.03) ; v1(92.45,221.61) 93.09,222.25 101.44,222.25 108.24,215.46 115.47,215.46 117.85,217.83 117.85,222.88 118.36,223.39 119.33,223.39 119.83,222.89 122.45,222.89 124.68,225.12 129.87,225.12 130.64,225.89 134.49,225.89 135.55,226.95 137.66,226.95 138.37,227.66 138.37,234.26 138.99,234.88 140.27,234.88 141.85,233.3 143.25,233.3 144.52,234.57 146.05,234.57 146.68,233.93 v1(146.68,233.04) 147.54,232.18 149.44,232.18 150.24,231.39 150.24,227.71 155.64,222.3 160.22,222.3 163.44,219.07 164.05,219.07 v1(165.1,218.03) ; v1(81.66,112.9) 81.66,112.49 82.66,111.49 82.66,101.38 82.16,100.89 82.16,99.74 82.44,99.46 82.88,99.46 83.16,99.19 83.16,98.65 82.65,98.15 82.65,95.69 79.41,92.45 72.89,92.45 72.39,91.95 68.07,91.95 64.89,88.77 63.66,88.77 60.24,85.34 58.29,85.34 57.78,84.83 57.78,83.31 57.37,82.9 51.34,82.9 48.63,80.18 46.02,80.18 44.93,81.28 43.18,81.28 42.16,82.29 40.76,82.29 38.6,80.14 38.6,78.48 38.22,78.1 35.2,78.1 32.38,75.28 32.38,71.88 v1(30.98,70.48) ; v1(111.25,254.38) 110.73,253.86 107.85,253.86 107.33,254.37 104.06,254.37 103.41,253.73 101.48,253.73 v1(101.09,254.13) 100.47,254.13 100.06,253.72 96.62,253.72 96.31,253.42 93.11,253.42 92.94,253.24 91.31,253.24 91.05,253.49 v1(90.67,253.49) 90.55,253.36 84.23,253.36 83.2,254.4 83.2,255.12 82.55,255.78 76.81,255.78 73.12,259.46 72.41,259.46 71.52,258.57 61.99,258.57 61.61,258.19 60,258.19 v1(59.99,258.19) 58.98,259.21 54.35,259.21 v1(54.1,258.95)
  LAY6 w0.125: v1(93.21,193.93) 94.99,195.71 94.99,198.25 93.85,199.39 93.85,208.51 92.96,209.4 92.96,221.11 v1(92.45,221.61) 92.2,221.87 92.2,238.48 96.08,242.37 96.08,243.66 100.33,247.9 101.62,247.9 102.27,248.55 102.27,252.94 v1(101.09,254.13) ; v1(54.1,258.95) 54.1,254.51 52.97,253.38 52.97,239.13 49.17,235.33 v1(47.37,235.33)
  BOTTOM w0.1: v1(86.23,129.03) 86.23,128.52 82.45,124.75 82.45,118.18 81.6,117.32 81.6,115.44 81.02,114.87 81.02,113.79 81.66,113.16 v1(81.66,112.9)
PCHXDP_PM_RSMRST_N: length 2.7
  TOP w0.1: R6H22.1 118.11,42.42 118.08,42.44 J6H2.39
PCIE3_LAN_FOX_RX_C_DN: length 4
  TOP w0.1: EU7A3.24 98.32,261.09 98.42,261.19 99.67,261.19 100.46,261.98 100.86,261.98 C6A47.2
PCIE3_LAN_FOX_RX_C_DP: length 4
  TOP w0.1: C6A42.2 100.88,262.18 100.38,262.18 99.59,261.39 98.45,261.39 98.34,261.49 EU7A3.25
PCIE3_LAN_FOX_RX_DN: length 142.9
  TOP w0.1: 109.32,149.95 v1(109.32,150.49) ; C6A47.1 v1(102.87,261.62)
  LAY6 w0.115: v1(102.87,261.62) 102.66,261.82 102.38,261.82 102.1,261.55 102.1,259.69 102.84,258.95 103.88,258.95 105.02,257.81 105.02,254.13 103.25,252.35 103.25,248.03 101.77,246.55 100.37,246.55 97.43,243.61 97.43,239.6 94.61,236.78 94.61,227.71 94.97,227.35 94.97,222.09 95.48,221.58 95.48,216.68 96.11,216.05 96.11,199.86 96.62,199.36 96.62,194.34 95.22,192.94 95.22,187.42 97.15,185.49 97.15,179.77 98.88,178.05 98.88,173.73 102.22,170.38 114.73,170.38 115.41,169.7 115.41,167.16 116.94,165.63 116.94,164.06 116.33,163.45 116.33,155.25 111.36,150.28 110.72,150.28 110.45,150.01 109.92,150.01 109.44,150.49 v1(109.32,150.49)
PCIE3_LAN_FOX_RX_DP: length 142.9
  TOP w0.1: C6A42.1 v1(102.87,262.51) ; U6E1.J18 v1(110.06,150.73)
  LAY6 w0.115: v1(110.06,150.73) 109.88,150.55 109.88,150.38 110.02,150.24 110.36,150.24 110.63,150.51 111.26,150.51 116.1,155.34 116.1,163.55 116.71,164.16 116.71,165.54 115.18,167.06 115.18,169.6 114.63,170.15 102.13,170.15 98.65,173.63 98.65,177.95 96.92,179.68 96.92,185.39 94.99,187.32 94.99,193.04 96.39,194.44 96.39,199.26 95.88,199.77 95.88,215.95 95.25,216.59 95.25,221.49 94.74,221.99 94.74,227.26 94.38,227.61 94.38,236.88 97.2,239.7 97.2,243.7 100.28,246.78 101.68,246.78 103.02,248.12 103.02,252.44 104.79,254.22 104.79,257.71 103.79,258.72 102.74,258.72 101.87,259.59 101.87,261.64 102.28,262.05 102.68,262.05 102.87,262.24 v1(102.87,262.51)
PCIE3_LAN_FOX_TX_C_DN: length 4.1
  TOP w0.1: C6A41.2 100.97,263.64 100.51,263.64 99.37,262.49 98.41,262.49 98.21,262.29 EU7A3.27
PCIE3_LAN_FOX_TX_C_DP: length 4.1
  TOP w0.1: C6A38.2 100.77,263.84 100.43,263.84 99.28,262.69 EU7A3.28
PCIE3_LAN_FOX_TX_DN: length 151.4
  TOP w0.1: v1(120.65,150.24) 120.35,149.94 120.35,149.69 120.13,149.47 113.29,149.47 U6E1.B19 ; C6A41.1 v1(102.87,263.4)
  LAY6 w0.115: v1(102.87,263.4) 103.12,263.65 103.88,263.65 104.41,263.12 104.41,259.31 105.53,258.19 105.53,253.74 105.28,253.49 105.28,252.47 105.66,252.09 105.66,251.33 105.15,250.82 105.15,248.35 101.55,244.75 99.52,244.75 97.94,243.17 97.94,239.29 95.25,236.6 95.25,228.78 95.63,228.4 95.63,222.88 96.01,222.5 96.01,217.93 96.64,217.3 96.64,200.28 97.28,199.64 97.28,194.05 95.88,192.66 95.88,187.58 97.66,185.8 97.66,180.02 99.84,177.83 99.84,173.84 101.72,171.96 110.54,171.96 111.53,170.96 114.96,170.96 116.02,169.91 116.02,167.31 117.47,165.86 117.47,162.88 117.01,162.42 117.01,151.01 118.64,149.37 120.04,149.37 120.36,149.69 120.36,149.95 v1(120.65,150.24)
PCIE3_LAN_FOX_TX_DP: length 151.4
  TOP w0.1: C6A38.1 v1(102.87,264.29) ; U6E1.C19 112.8,149.68 113.2,149.68 113.21,149.67 120.04,149.67 120.15,149.77 120.15,149.93 v1(119.84,150.24)
  LAY6 w0.115: v1(102.87,264.29) 102.87,264.16 103.14,263.88 103.98,263.88 104.64,263.21 104.64,259.4 105.76,258.28 105.76,253.65 105.51,253.4 105.51,252.57 105.89,252.19 105.89,251.24 105.38,250.73 105.38,248.26 101.65,244.52 99.61,244.52 98.17,243.08 98.17,239.2 95.48,236.5 95.48,228.88 95.86,228.5 95.86,222.98 96.24,222.6 96.24,218.03 96.87,217.39 96.87,200.37 97.51,199.74 97.51,193.96 96.11,192.56 96.11,187.67 97.89,185.9 97.89,180.11 100.07,177.93 100.07,173.93 101.82,172.19 110.64,172.19 111.63,171.19 115.06,171.19 116.25,170 116.25,167.4 117.7,165.96 117.7,162.79 117.24,162.33 117.24,151.1 118.74,149.6 119.95,149.6 120.13,149.78 120.13,149.95 v1(119.84,150.24)
PCIE4_M.2_WLAN_RX_DN: length 118.8
  TOP w0.1: 107.8,149.95 v1(107.8,150.49) ; R7B66.1 80.61,234.6 83.3,234.6 83.95,233.95 92.7,233.95 v1(93.03,234.28)
  LAY6 w0.089: v1(107.8,150.49) 107.7,150.59 107.7,150.77 107.86,150.92 109,150.92 109.25,151.18 109.59,151.18 109.8,151.38 110.36,151.38 110.49,151.51 110.74,151.51 111.12,151.89 111.38,151.89 112.26,152.78 112.26,152.87 112.52,153.12 112.55,153.12
  LAY6 w0.115: v1(93.03,234.28) 93.34,233.97 93.57,233.97 93.82,233.72 93.82,228.5 93.44,228.12 93.44,222.72 93.95,222.22 93.95,217.07 94.99,216.03 94.99,199.84 95.88,198.95 95.88,194.69 94.48,193.29 94.48,187.07 96.39,185.16 96.39,179.45 97.79,178.05 97.79,173.7 101.95,169.54 107.82,169.54 110.13,167.23 113.28,167.23 114.53,165.98 114.53,165.68 115.41,164.79 115.41,155.99 112.55,153.12
PCIE4_M.2_WLAN_RX_DP: length 118.7
  TOP w0.1: U6E1.R18 v1(107.04,150.49) ; R7B70.1 80.13,234.3 80.23,234.4 83.22,234.4 83.87,233.75 92.73,233.75 v1(93.03,233.46)
  LAY6 w0.089: 112.39,153.29 112.06,152.96 112.06,152.86 111.29,152.09 111.04,152.09 110.65,151.71 110.4,151.71 110.27,151.59 109.71,151.59 109.51,151.38 109.17,151.38 108.92,151.13 107.77,151.13 107.14,150.49 v1(107.04,150.49)
  LAY6 w0.115: 112.39,153.29 115.18,156.08 115.18,164.69 114.3,165.58 114.3,165.89 113.18,167 110.03,167 107.72,169.31 101.85,169.31 97.56,173.61 97.56,177.96 96.16,179.35 96.16,185.07 94.25,186.97 94.25,193.39 95.65,194.78 95.65,198.86 94.76,199.75 94.76,215.93 93.72,216.97 93.72,222.12 93.21,222.63 93.21,228.22 93.59,228.6 93.59,233.63 93.48,233.74 93.32,233.74 v1(93.03,233.46)
PCIE4_M.2_WLAN_RX_R_DN: length 11.3
  TOP w0.1: J7C1.43 71.26,236.82 71.41,236.67 72.47,236.67 73.73,235.41 73.73,234.88 75.11,233.5 77.48,233.5 78.58,234.59 78.91,234.59 79.24,234.92 R7B66.2
PCIE4_M.2_WLAN_RX_R_DP: length 11.4
  TOP w0.1: J7C1.41 71.26,236.32 71.41,236.47 72.38,236.47 73.53,235.33 73.53,234.79 75.02,233.3 77.57,233.3 78.66,234.39 78.96,234.39 79.24,234.11 R7B70.2
PCIE4_M.2_WLAN_TX_C_DN: length 10.4
  TOP w0.1: J7C1.37 71.26,235.32 71.41,235.17 72.45,235.17 74.88,232.74 78.18,232.74 78.58,232.33 78.81,232.33 79.24,232.76 C7B16.2
PCIE4_M.2_WLAN_TX_C_DP: length 10.4
  TOP w0.1: C7B17.2 78.76,232.13 78.5,232.13 78.1,232.54 74.8,232.54 72.36,234.97 71.41,234.97 71.26,234.82 J7C1.35
PCIE4_M.2_WLAN_TX_DN: length 129.2
  TOP w0.1: v1(126.06,159.08) 125.75,158.77 125.75,153.03 121.69,148.97 113.4,148.97 113.26,148.82 112.8,148.82 112.79,148.82 112.39,148.82 U6E1.D20 ; v1(96.46,232.89) 96.21,232.63 94.17,232.63 93.64,232.1 90.98,232.1 90.09,232.99 82.21,232.99 81.76,232.55 80.38,232.55 C7B16.1
  LAY6 w0.115: v1(126.06,159.08) 125.78,159.36 125.78,159.63 124.33,161.08 124.33,162.12 117.72,168.73 117.72,169.74 115.28,172.19 111.98,172.19 111.38,172.79 111.38,174.28 110.81,174.85 106.9,174.85 102.87,178.89 102.87,183.39 101.98,184.28 101.72,184.53 101.06,185.19 101.06,197.45 97.75,200.77 97.75,227.82 97.17,228.4 97.17,232.34 96.89,232.61 96.73,232.61 v1(96.46,232.89)
PCIE4_M.2_WLAN_TX_DP: length 129.2
  TOP w0.1: v1(96.46,232.06) 96.46,232.31 96.33,232.43 94.25,232.43 93.72,231.9 90.9,231.9 90.01,232.79 82.29,232.79 81.85,232.35 80.08,232.35 79.88,232.14 79.88,231.9 C7B17.1 ; v1(125.24,159.08) 125.55,158.77 125.55,153.11 121.6,149.17 113.32,149.17 113.17,149.02 112.8,149.02 U6E1.C20
  LAY6 w0.115: v1(125.24,159.08) 125.43,159.08 125.55,159.19 125.55,159.54 124.1,160.99 124.1,162.03 117.49,168.63 117.49,169.65 115.18,171.96 111.88,171.96 111.15,172.69 111.15,174.19 110.71,174.62 106.8,174.62 104.59,176.83 104.59,176.83 102.64,178.79 102.64,183.29 100.83,185.09 100.83,197.36 97.52,200.67 97.52,227.72 96.94,228.3 96.94,232.24 96.8,232.38 96.62,232.38 96.46,232.22 v1(96.46,232.06)
PCIE5_TR_RX_C_DN: length 5.8
  TOP w0.089: U5A2.Y22 171.2,263.17 171.7,263.17
  TOP w0.1: C4B1.1 173.8,259.89 173.42,259.89 172.46,260.86 172.46,262.73 172.02,263.17 171.7,263.17
PCIE5_TR_RX_C_DP: length 5.8
  TOP w0.089: 171.71,263.53 171.61,263.63 171.37,263.63 171.28,263.54 171.28,263.49 171.37,263.4 U5A2.Y23
  TOP w0.1: 171.71,263.53 171.87,263.37 172.11,263.37 172.66,262.82 172.66,260.94 173.51,260.09 173.73,260.09 C4A35.1
PCIE5_TR_RX_DN: length 148.4
  TOP w0.1: v1(129.16,153.92) 129.16,153.93 R6E3.2 ; v1(176.52,261.11) 176.65,261.11 176.82,261.28 176.82,261.61 176.64,261.79 174.86,261.79 174.76,261.69 174.76,261.52 174.92,261.36 C4A33.1
  LAY6 w0.115: v1(176.52,261.11) 176.8,260.83 176.8,260.66 176.49,260.35 175.51,260.35 173.05,257.88 163.45,257.88 159.26,253.7 148.48,253.7 147.15,252.37 146.19,252.37 142.61,248.79 141.78,248.79 140.23,247.24 140.23,245.26 139.75,244.78 138.79,244.78 135.4,241.39 135.4,236.44 133.88,234.92 133.88,204.7 134.87,203.71 134.87,191.33 134,190.47 134,188.37 134.51,187.86 134.51,176.57 133.95,176.01 133.95,171.35 134.84,170.46 134.84,165.4 132.46,163.01 132.46,157.73 129.81,155.09 129.81,153.64 129.64,153.47 129.27,153.47 129.16,153.58 v1(129.16,153.92)
PCIE5_TR_RX_DP: length 148.4
  TOP w0.1: v1(129.16,152.78) 129.16,152.79 R6E4.2 ; v1(177.32,261.11) 177.02,261.41 177.02,261.69 176.72,261.99 175.27,261.99 C4A32.1
  LAY6 w0.115: v1(129.16,152.78) 129.16,153.12 129.27,153.24 129.74,153.24 130.04,153.54 130.04,154.99 132.69,157.64 132.69,162.92 135.07,165.3 135.07,170.55 134.18,171.44 134.18,175.92 134.74,176.47 134.74,187.96 134.23,188.47 134.23,190.37 135.1,191.24 135.1,203.8 134.11,204.79 134.11,234.82 135.63,236.35 135.63,241.3 138.88,244.55 139.84,244.55 140.46,245.16 140.46,247.14 141.88,248.56 142.71,248.56 146.29,252.14 147.25,252.14 148.58,253.47 159.36,253.47 163.54,257.65 173.14,257.65 175.6,260.12 176.58,260.12 177.03,260.57 177.03,260.83 v1(177.32,261.11)
PCIE5_TR_TX_C_DN: length 5.5
  TOP w0.089: U5A2.V22 171.19,264.09 171.7,264.09
  TOP w0.1: C4A33.2 173.82,261.67 173.44,261.67 173.22,261.89 173.22,263.02 172.74,263.5 172.74,264.02 172.55,264.21 172.13,264.21 172.01,264.09 171.7,264.09
PCIE5_TR_TX_C_DP: length 5.5
  TOP w0.089: U5A2.V23 171.37,264.32 171.28,264.41 171.28,264.46 171.37,264.55 171.61,264.55 171.71,264.45
  TOP w0.1: C4A32.2 173.74,261.87 173.52,261.87 173.42,261.97 173.42,263.1 172.94,263.58 172.94,264.11 172.63,264.41 172.05,264.41 171.93,264.29 171.87,264.29 171.71,264.45
PCIE5_TR_TX_DN: length 146.1
  TOP w0.1: C4B1.2 174.99,259.91 175.09,260.01 176.63,260.01 176.8,259.83 176.8,259.43 176.7,259.33 v1(176.5,259.33) ; v1(133.09,152.79) 133.1,152.79 133.75,152.79 R5E18.2
  LAY6 w0.115: v1(133.09,152.79) 133.09,152.39 133.21,152.27 133.4,152.27 135.76,154.63 135.76,171 134.69,172.06 134.69,175.73 135.25,176.29 135.25,187.04 135.76,187.55 135.76,204.47 135.17,205.05 135.17,235.07 136.26,236.16 136.26,240.54 138.53,242.8 139.8,242.8 140.81,243.81 142.01,243.81 142.36,244.16 142.36,247.52 146.49,251.65 147.45,251.65 148.78,252.98 159.81,252.98 163.98,257.15 173.51,257.15 175.03,258.67 176.58,258.67 176.86,258.96 176.86,259.17 176.7,259.33 v1(176.5,259.33)
PCIE5_TR_TX_DP: length 146.1
  TOP w0.1: v1(177.3,259.33) 177,259.63 177,259.91 176.71,260.21 175.25,260.21 C4A35.2 ; R5E22.2 v1(133.09,151.64)
  LAY6 w0.115: v1(133.09,151.64) 133.09,151.85 133.28,152.04 133.5,152.04 135.99,154.53 135.99,171.09 134.92,172.16 134.92,175.64 135.48,176.2 135.48,186.94 135.99,187.45 135.99,204.57 135.4,205.15 135.4,234.97 136.49,236.07 136.49,240.44 138.62,242.57 139.89,242.57 140.91,243.58 142.11,243.58 142.59,244.07 142.59,247.43 146.59,251.42 147.54,251.42 148.87,252.75 159.91,252.75 164.08,256.92 173.6,256.92 175.13,258.44 176.67,258.44 177.09,258.87 177.09,259.12 v1(177.3,259.33)
PCIE5_TR_U2_RX_DN: length 24
  TOP w0.089: U6E1.F20 v1(111.54,149.82)
  TOP w0.1: R6E2.1 131.03,153.73 131.03,153.46 130.88,153.31 130.59,153.31 130.47,153.44 127.4,153.44 127.17,153.21 127.17,152.91 127.05,152.78 v1(126.88,152.78)
  BOTTOM w0.1: v1(111.54,149.82) 111.54,149.69 111.67,149.56 112.58,149.56 112.77,149.75 114.68,149.75 115.34,149.1 123.28,149.1 125.87,151.69 126.64,151.69 127.18,152.23 127.18,152.48 v1(126.88,152.78)
PCIE5_TR_U2_RX_DP: length 24
  TOP w0.089: U6E1.G20 v1(110.8,149.63)
  TOP w0.1: R6E5.1 130.38,153.24 127.48,153.24 127.37,153.13 127.37,152.91 127.5,152.78 v1(127.68,152.78)
  BOTTOM w0.1: v1(110.8,149.63) 111.09,149.63 111.36,149.37 112.66,149.37 112.85,149.55 114.6,149.55 115.26,148.9 123.36,148.9 125.95,151.49 126.72,151.49 127.38,152.14 127.38,152.48 v1(127.68,152.78)
PCIE5_TR_U2_TX_DN: length 22.9
  TOP w0.1: R5E17.1 134.16,152.3 125.85,152.3 122.21,148.66 113.56,148.66 U6E1.B21
PCIE5_TR_U2_TX_DP: length 23
  TOP w0.1: U6E1.A22 114.06,148.46 122.3,148.46 125.93,152.1 134.24,152.1 134.38,152.24 134.64,152.24 134.74,152.14 134.74,151.74 R5E21.1
PCIE5_U2_R_RX_DN: length 11.5
  TOP w0.1: R5G33.2 151.81,67 152.85,67 153.05,67.2 160.25,67.2 160.71,66.74 J5H1.B5
PCIE5_U2_R_RX_DP: length 11.5
  TOP w0.1: J5H1.B4 159.96,65.93 160.11,65.78 160.36,65.78 160.51,65.93 160.51,66.65 160.16,67 153.14,67 152.94,66.8 151.89,66.8 R5G34.2
PCIE5_U2_R_TX_DN: length 5.4
  TOP w0.1: C5G17.1 159.8,76.87 159.8,76.16 160.85,75.11 160.85,73.6 160.66,73.41 160.66,72.7 J5H1.D5
PCIE5_U2_R_TX_DP: length 5.4
  TOP w0.1: C5G16.1 159.13,77.34 159.6,76.87 159.6,76.08 160.65,75.02 160.65,73.68 160.5,73.53 160.19,73.53 159.96,73.76 J5H1.D4
PCIE5_U2_RX_DN: length 115.2
  TOP w0.1: R5G33.1 150.02,66.96 149.42,66.96 149.32,67.06 149.32,67.23 v1(149.63,67.54) ; R6E2.2 132.19,153.47 135.99,153.47 141.47,147.98 141.47,137.33 134.66,130.52 134.66,127.53 132.61,125.47 131.24,125.47 130.78,125.02 130.78,124.4 v1(131.06,124.12)
  BOTTOM w0.1: v1(131.06,124.12) 130.75,123.82 130.75,119.15 127.38,115.77 127.38,95.91 128.85,94.44 128.85,83.14 131.57,80.41 131.57,78.87 135.56,74.87 137.49,74.87 141.3,71.06 146.34,71.06 148.32,69.08 148.85,69.08 149.29,68.63 149.29,67.88 v1(149.63,67.54)
PCIE5_U2_RX_DP: length 115.2
  TOP w0.1: v1(130.24,124.12) 130.58,124.46 130.58,125.1 131.15,125.67 132.53,125.67 134.46,127.61 134.46,130.61 141.27,137.42 141.27,147.9 135.91,153.27 132.21,153.27 R6E5.2 ; R5G34.1 150.02,66.76 149.34,66.76 149.12,66.98 149.12,67.23 v1(148.81,67.54)
  BOTTOM w0.1: v1(130.24,124.12) 130.55,123.82 130.55,119.23 127.18,115.85 127.18,95.83 128.65,94.36 128.65,83.05 131.37,80.33 131.37,78.78 135.48,74.67 137.41,74.67 141.22,70.86 146.25,70.86 148.24,68.88 148.76,68.88 149.09,68.55 149.09,67.83 v1(148.81,67.54)
PCIE5_U2_TX_DN: length 110.2
  TOP w0.1: v1(133.31,128) 133.54,128.24 133.74,128.24 133.98,128.48 133.98,130.8 140.74,137.56 140.74,147.67 135.89,152.52 135.8,152.52 R5E17.2 ; v1(160.11,78.92) 159.8,78.61 159.8,78.28 159.85,78.23 C5G17.2
  BOTTOM w0.1: v1(160.11,78.92) 159.66,78.47 159.66,78.47 159.44,78.26 144.5,78.26 142.69,80.06 136.44,80.06 133.15,83.35 133.15,96.95 136.83,100.64 136.83,113.34 137.92,114.43 137.92,118.84 134.67,122.09 134.67,127.8 134.23,128.25 133.55,128.25 v1(133.31,128)
PCIE5_U2_TX_DP: length 110.2
  TOP w0.1: R5E21.2 135.29,151.89 135.29,152.2 135.42,152.32 135.81,152.32 140.54,147.59 140.54,137.64 133.78,130.89 133.78,128.56 133.65,128.44 133.46,128.44 133.31,128.59 v1(133.31,128.82) ; v1(159.28,78.92) 159.6,78.61 159.6,78.29 159.53,78.23 C5G16.2
  BOTTOM w0.1: v1(133.31,128.82) 133.31,128.79 133.65,128.45 134.31,128.45 134.87,127.89 134.87,122.17 138.12,118.92 138.12,114.34 137.03,113.25 137.03,100.55 133.35,96.87 133.35,83.44 136.52,80.26 142.77,80.26 144.58,78.46 159.36,78.46 159.46,78.56 159.46,78.75 v1(159.28,78.92)
PCIE6_TR_RX_C_DN: length 4.5
  TOP w0.089: U5A2.T22 171.2,265.01 171.7,265.01
  TOP w0.1: 171.7,265.01 171.98,265.01 172.27,264.72 173.01,264.72 173.28,264.45 173.28,263.85 173.65,263.48 173.99,263.48 174.11,263.36 C4A28.1
PCIE6_TR_RX_C_DP: length 4.5
  TOP w0.089: 171.71,265.37 171.61,265.47 171.37,265.47 171.28,265.38 171.28,265.33 171.37,265.24 U5A2.T23
  TOP w0.1: 171.71,265.37 171.87,265.21 172.06,265.21 172.35,264.92 173.09,264.92 173.48,264.53 173.48,263.93 173.73,263.68 174.01,263.68 174.11,263.78 C4A23.1
PCIE6_TR_RX_DN: length 157.4
  TOP w0.1: R6E9.2 129.16,150.5 v1(129.16,150.49) ; v1(176.52,264.67) 176.82,264.97 176.82,265.17 176.72,265.27 175.35,265.27 C4A18.1
  LAY6 w0.115: v1(176.52,264.67) 176.8,264.38 176.8,264.22 176.46,263.88 175.54,263.88 174.24,262.58 174.24,261.29 172.31,259.36 162.62,259.36 158.4,255.14 147.89,255.14 146.56,253.81 145.59,253.81 142.33,250.54 141.5,250.54 137.05,246.09 137.05,245.13 133.12,241.2 133.12,236.95 132.41,236.24 132.41,203.63 133.24,202.79 133.24,192.75 132.43,191.94 132.43,185.88 132.99,185.32 132.99,181.38 132.4,180.79 132.4,165.14 130.96,163.7 130.96,158.62 127.72,155.38 126.42,155.38 125.44,154.4 125.44,151.85 126.14,151.15 127.84,151.15 128.04,150.95 129.04,150.95 129.16,150.84 v1(129.16,150.49)
PCIE6_TR_RX_DP: length 157.4
  TOP w0.1: C4A17.1 175.35,265.47 176.8,265.47 177.02,265.25 177.02,264.89 177.24,264.67 v1(177.32,264.67) ; R6E6.2 129.16,151.64 v1(129.16,151.64)
  LAY6 w0.115: v1(177.32,264.67) 177.03,264.38 177.03,264.12 176.56,263.65 175.64,263.65 174.47,262.48 174.47,261.19 172.4,259.13 162.72,259.13 158.5,254.91 147.98,254.91 146.65,253.58 145.69,253.58 142.43,250.31 141.6,250.31 137.28,246 137.28,245.04 133.35,241.1 133.35,236.85 132.64,236.14 132.64,203.73 133.47,202.89 133.47,192.66 132.66,191.85 132.66,185.98 133.22,185.42 133.22,181.28 132.63,180.7 132.63,165.05 131.19,163.6 131.19,158.52 127.81,155.15 126.52,155.15 125.67,154.31 125.67,151.94 126.23,151.38 127.94,151.38 128.14,151.18 129.04,151.18 129.16,151.3 v1(129.16,151.64)
PCIE6_TR_TX_C_DN: length 3.7
  TOP w0.089: 171.7,265.93 171.2,265.93 U5A2.P22
  TOP w0.1: C4A18.2 173.81,265.24 173.51,265.24 173.4,265.35 172.64,265.35 172.06,265.93 171.7,265.93
PCIE6_TR_TX_C_DP: length 3.7
  TOP w0.089: U5A2.P23 171.37,266.16 171.28,266.25 171.28,266.3 171.37,266.39 171.61,266.39 171.71,266.29
  TOP w0.1: 171.71,266.29 171.87,266.13 172.14,266.13 172.72,265.55 173.48,265.55 173.6,265.44 173.78,265.44 174.13,265.78 C4A17.2
PCIE6_TR_TX_DN: length 159.8
  TOP w0.1: v1(133.09,149.35) 133.1,149.36 R5E32.2 ; v1(176.5,262.89) 176.8,263.19 176.8,263.39 176.7,263.49 175.33,263.49 C4A28.2
  LAY6 w0.115: v1(133.09,149.35) 133.09,149.57 132.85,149.81 131.93,149.81 129.64,152.09 128.14,152.09 127.94,151.89 126.61,151.89 126.18,152.32 126.18,154 126.84,154.66 128.11,154.66 131.69,158.24 131.69,163.29 134.08,165.68 134.08,170.08 133.14,171.02 133.14,176.22 133.78,176.85 133.78,185.68 133.17,186.29 133.17,191.53 134.11,192.47 134.11,203.25 133.14,204.22 133.14,235.45 133.88,236.19 133.88,240.94 138.07,245.13 138.07,246.09 141.68,249.71 142.51,249.71 145.89,253.09 146.85,253.09 148.18,254.42 158.78,254.42 162.99,258.62 172.61,258.62 175.03,261.03 175.03,261.84 175.41,262.23 176.58,262.23 176.79,262.44 176.79,262.6 v1(176.5,262.89)
PCIE6_TR_TX_DP: length 159.8
  TOP w0.1: C4A23.2 175.33,263.69 176.79,263.69 177,263.47 177,263.11 177.23,262.89 v1(177.3,262.89) ; R5E27.2 133.1,150.5 v1(133.09,150.49)
  LAY6 w0.115: v1(133.09,150.49) 133.09,150.28 132.85,150.04 132.02,150.04 129.74,152.32 128.04,152.32 127.84,152.12 126.71,152.12 126.41,152.42 126.41,153.9 126.94,154.43 128.21,154.43 131.92,158.15 131.92,163.19 134.31,165.58 134.31,170.17 133.37,171.11 133.37,176.12 134.01,176.76 134.01,185.77 133.4,186.38 133.4,191.44 134.34,192.38 134.34,203.35 133.37,204.32 133.37,235.36 134.11,236.09 134.11,240.84 138.3,245.03 138.3,246 141.78,249.48 142.61,249.48 145.99,252.86 146.95,252.86 148.28,254.19 158.88,254.19 163.08,258.39 172.71,258.39 175.26,260.94 175.26,261.75 175.51,262 176.67,262 177.02,262.35 177.02,262.6 v1(177.3,262.89)
PCIE6_TR_U2_RX_DN: length 24.8
  TOP w0.089: U6E1.K21 v1(109.32,149.25)
  TOP w0.1: v1(127.68,150.49) 127.5,150.49 127.37,150.62 127.37,150.84 127.48,150.95 130.38,150.95 R6E9.1
  BOTTOM w0.1: v1(109.32,149.25) 109.6,149.25 109.66,149.19 109.66,149.01 109.88,148.79 113.96,148.79 114.55,148.21 123.72,148.21 125.24,149.73 127.15,149.73 127.4,149.98 127.4,150.22 v1(127.68,150.49)
PCIE6_TR_U2_RX_DP: length 24.8
  TOP w0.089: U6E1.J21 v1(110.06,149.44)
  TOP w0.1: R6E6.1 130.84,151.25 130.74,151.15 127.4,151.15 127.17,150.93 127.17,150.62 127.05,150.49 v1(126.88,150.49)
  BOTTOM w0.1: v1(126.88,150.49) 127.05,150.49 127.2,150.35 127.2,150.06 127.07,149.93 125.16,149.93 123.64,148.41 114.63,148.41 114.05,148.99 109.96,148.99 109.86,149.09 109.86,149.24 v1(110.06,149.44)
PCIE6_TR_U2_TX_DN: length 23.4
  TOP w0.089: 114.49,147.96 114.32,147.96 114.29,147.94 113.65,147.94 113.45,148.15 112.95,148.15 112.59,148.51 U6E1.D21
  TOP w0.1: R5E32.1 134.65,149.45 134.29,149.81 128.09,149.81 127.88,149.6 124.41,149.6 122.77,147.96 114.49,147.96
PCIE6_TR_U2_TX_DP: length 23.4
  TOP w0.089: U6E1.C21 112.96,148.41 113.03,148.34 113.53,148.34 113.73,148.13 114.22,148.13 114.24,148.15 114.41,148.15 114.41,148.16 114.47,148.16 114.48,148.16 114.49,148.16
  TOP w0.1: 114.49,148.16 122.69,148.16 124.33,149.8 127.8,149.8 128,150.01 134.37,150.01 134.48,149.9 134.61,149.9 134.72,150.01 134.72,150.43 R5E27.1
PCIE6_U2_R_RX_DN: length 12
  TOP w0.1: R5H2.2 151.79,62.46 151.88,62.46 151.89,62.45 152.59,62.45 153.71,63.57 160.22,63.57 160.71,63.08 J5H1.A5
PCIE6_U2_R_RX_DP: length 12
  TOP w0.1: J5H1.A4 159.96,62.13 160.06,62.03 160.41,62.03 160.51,62.13 160.51,63 160.14,63.37 153.79,63.37 152.67,62.25 151.89,62.25 151.38,61.75 R5H3.2
PCIE6_U2_R_TX_DN: length 10.4
  TOP w0.1: J5H1.C5 160.71,69.66 162.42,71.37 162.81,71.37 164.41,72.97 164.41,76.91 C5G21.1
PCIE6_U2_R_TX_DP: length 10.4
  TOP w0.1: C5G20.1 164.21,76.83 164.21,73.06 162.73,71.57 162.34,71.57 160.58,69.81 160.14,69.81 159.96,69.98 J5H1.C4
PCIE6_U2_RX_DN: length 118
  TOP w0.1: v1(128.14,125.53) 128.44,125.22 129.3,125.22 131.08,127 132.08,127 132.62,127.55 132.62,129.76 133.02,130.15 133.02,131.1 139.85,137.93 139.85,147.22 136.1,150.96 132.12,150.96 131.99,151.1 131.69,151.1 131.57,150.97 131.57,150.66 R6E8.2 ; R5H2.1 150.02,62.39 149.42,62.39 149.32,62.49 149.32,62.66 v1(149.63,62.97)
  BOTTOM w0.1: v1(149.63,62.97) 149.27,63.34 149.27,64.01 148.84,64.44 146.79,64.44 143.92,67.31 141.73,67.31 138.04,70.99 136.8,70.99 127.45,80.35 127.45,93.68 126.03,95.1 126.03,116.45 128.96,119.39 128.96,124.93 128.67,125.22 128.44,125.22 v1(128.14,125.53)
PCIE6_U2_RX_DP: length 118
  TOP w0.1: R6E7.2 132.21,151.16 136.19,151.16 140.05,147.3 140.05,137.84 139.99,137.78 133.22,131.01 133.22,130.07 132.82,129.68 132.82,127.46 132.16,126.8 131.16,126.8 129.39,125.02 128.44,125.02 v1(128.14,124.71) ; R5H3.1 150.02,62.19 149.34,62.19 149.12,62.41 149.12,62.66 v1(148.81,62.97)
  BOTTOM w0.1: v1(148.81,62.97) 149.07,63.23 149.07,63.93 148.76,64.24 146.71,64.24 143.84,67.11 141.65,67.11 137.96,70.79 136.72,70.79 127.25,80.26 127.25,93.6 125.83,95.02 125.83,116.54 128.76,119.47 128.76,124.85 128.59,125.02 128.44,125.02 v1(128.14,124.71)
PCIE6_U2_TX_DN: length 113.2
  TOP w0.1: v1(164.69,78.89) 164.37,78.58 164.37,78.28 164.42,78.23 C5G21.2 ; R5E31.2 135.91,149.73 136.36,149.73 139.16,146.93 139.16,138.21 132.26,131.3 132.26,130.38 131.94,130.07 131.94,129.28 131.47,128.8 131.47,128.02 v1(131.24,127.79)
  BOTTOM w0.1: v1(164.69,78.89) 164.37,78.58 164.37,78.14 163.12,76.89 143.8,76.89 141.99,78.7 135.88,78.7 131.19,83.39 131.19,96.77 129.59,98.37 129.59,115.22 133.15,118.77 133.15,125.55 131.54,127.15 131.54,127.48 v1(131.24,127.79)
PCIE6_U2_TX_DP: length 113.2
  TOP w0.1: C5G20.2 164.11,78.23 164.17,78.29 164.17,78.58 v1(163.86,78.89) ; R5E28.2 135.54,150.16 135.76,149.93 136.44,149.93 139.36,147.01 139.36,138.12 132.46,131.22 132.46,130.3 132.14,129.99 132.14,129.2 131.67,128.72 131.67,128.17 v1(132.05,127.79)
  BOTTOM w0.1: v1(163.86,78.89) 164.17,78.58 164.17,78.23 163.03,77.09 143.89,77.09 142.08,78.9 135.96,78.9 131.39,83.48 131.39,96.86 129.79,98.45 129.79,115.13 133.35,118.69 133.35,125.63 131.74,127.23 131.74,127.48 v1(132.05,127.79)
PCIE7_TR_RX_C_DN: length 3.4
  TOP w0.089: 171.7,266.85 171.2,266.85 U5A2.M22
  TOP w0.1: 171.7,266.85 172.23,266.85 172.34,266.96 173.52,266.96 173.56,267.01 173.8,267.01 C4A16.1
PCIE7_TR_RX_C_DP: length 3.4
  TOP w0.089: U5A2.M23 171.37,267.08 171.28,267.17 171.28,267.22 171.37,267.31 171.61,267.31 171.71,267.21
  TOP w0.1: C4A15.1 173.73,267.21 173.48,267.21 173.43,267.16 172.26,267.16 172.15,267.05 171.87,267.05 171.71,267.21
PCIE7_TR_RX_DN: length 171.2
  TOP w0.1: C4A13.1 175.35,269.02 176.8,269.02 177.02,268.8 177.02,268.44 177.24,268.22 v1(177.32,268.22) ; R6E14.2 129.16,147.07 v1(129.16,147.06)
  LAY6 w0.115: v1(129.16,147.06) 129.16,146.72 129.04,146.61 128.09,146.61 127.4,147.29 124.99,147.29 124.2,148.08 124.2,155 125.79,156.59 127.12,156.59 129.51,158.98 129.51,165.33 130.56,166.37 130.56,168.72 130.08,169.2 130.08,172.05 128.52,173.61 128.52,176.22 127.99,176.75 127.99,178.66 128.5,179.17 128.5,183.16 130.65,185.32 130.65,197.23 130.27,197.61 130.27,201.4 130.93,202.06 130.93,216.6 130.42,217.11 130.42,226.19 128.14,228.47 128.14,234.13 128.27,234.26 128.27,239.04 141.21,251.99 142.07,251.99 145.09,255.01 146.05,255.01 147.38,256.34 150.24,256.34 151.26,257.37 158.12,257.37 161.48,260.73 171.93,260.73 173,261.8 173,265.11 174.97,267.08 176.43,267.08 177.03,267.68 177.03,267.94 v1(177.32,268.22)
PCIE7_TR_RX_DP: length 171.2
  TOP w0.1: R6E16.2 129.16,145.93 v1(129.16,145.92) ; v1(176.52,268.22) 176.82,268.52 176.82,268.72 176.72,268.82 175.35,268.82 C4A14.1
  LAY6 w0.115: v1(129.16,145.92) 129.16,146.26 129.04,146.38 127.99,146.38 127.3,147.06 124.89,147.06 123.97,147.99 123.97,155.1 125.69,156.82 127.03,156.82 129.28,159.07 129.28,165.42 130.33,166.47 130.33,168.63 129.85,169.1 129.85,171.95 128.29,173.51 128.29,176.12 127.76,176.66 127.76,178.76 128.27,179.27 128.27,183.26 130.42,185.42 130.42,197.13 130.04,197.52 130.04,201.49 130.7,202.15 130.7,216.51 130.19,217.02 130.19,226.09 127.91,228.38 127.91,234.22 128.04,234.35 128.04,239.14 141.12,252.22 141.97,252.22 145,255.24 145.96,255.24 147.29,256.57 150.15,256.57 151.17,257.6 158.03,257.6 161.39,260.96 171.83,260.96 172.77,261.89 172.77,265.2 174.87,267.31 176.34,267.31 176.8,267.78 176.8,267.94 v1(176.52,268.22)
PCIE7_TR_TX_C_DN: length 3.8
  TOP w0.089: 171.68,268.17 171.62,268.23 171.19,268.23 U5A2.K22
  TOP w0.1: 171.68,268.17 171.76,268.08 172.29,268.08 173.32,269.11 173.87,269.11 C4A13.2
PCIE7_TR_TX_C_DP: length 3.8
  TOP w0.089: 171.7,267.82 171.65,267.77 171.39,267.77 171.34,267.82 171.34,267.92 U5A2.K23
  TOP w0.1: C4A14.2 174.13,268.77 173.98,268.91 173.4,268.91 172.38,267.88 171.76,267.88 171.7,267.82
PCIE7_TR_TX_DN: length 167.6
  TOP w0.1: v1(133.09,147.06) 133.1,147.07 R5E36.2 ; C4A16.2 175.33,267.04 176.7,267.04 176.8,266.94 176.8,266.74 v1(176.5,266.44)
  LAY6 w0.115: v1(176.5,266.44) 176.79,266.16 176.79,266 176.58,265.79 174.65,265.79 173.5,264.63 173.5,261.59 172,260.09 162.3,260.09 158.06,255.86 147.59,255.86 146.26,254.53 145.3,254.53 142.23,251.46 141.38,251.46 130.55,240.63 130.55,235.61 130.96,235.2 130.96,217.35 131.54,216.76 131.54,203.28 132.33,202.49 132.33,193.24 131.24,192.14 131.24,188.19 131.67,187.76 131.67,166.19 130.2,164.72 130.2,158.88 127.42,156.1 126,156.1 124.71,154.81 124.71,150.75 125.85,149.6 128.01,149.6 128.21,149.81 129.77,149.81 132.06,147.52 132.85,147.52 133.09,147.28 v1(133.09,147.06)
PCIE7_TR_TX_DP: length 167.5
  TOP w0.1: v1(177.3,266.44) 177.23,266.44 177,266.67 177,267.03 176.79,267.24 175.33,267.24 C4A15.2 ; v1(133.09,148.21) 133.1,148.21 R5E33.2
  LAY6 w0.115: v1(177.3,266.44) 177.02,266.16 177.02,265.9 176.67,265.56 174.75,265.56 173.73,264.54 173.73,261.5 172.1,259.86 162.4,259.86 158.16,255.63 147.68,255.63 146.35,254.3 145.39,254.3 142.32,251.23 141.47,251.23 130.78,240.54 130.78,235.7 131.19,235.3 131.19,217.44 131.77,216.86 131.77,203.38 132.56,202.59 132.56,193.14 131.47,192.05 131.47,188.28 131.9,187.85 131.9,166.1 130.43,164.62 130.43,158.78 127.52,155.87 126.09,155.87 124.94,154.71 124.94,150.84 125.95,149.83 127.92,149.83 128.12,150.04 129.86,150.04 132.15,147.75 132.85,147.75 133.09,147.99 v1(133.09,148.21)
PCIE7_TR_U2_RX_DN: length 24.4
  TOP w0.089: U6E1.L24 v1(109.23,147.81)
  TOP w0.1: v1(126.88,145.92) 127.05,145.92 127.17,146.05 127.17,146.35 127.4,146.58 130.35,146.58 R6E15.1
  BOTTOM w0.1: v1(126.88,145.92) 127.14,146.19 127.14,146.33 127.04,146.43 113.66,146.43 113.03,147.06 109.72,147.06 109.44,147.34 109.44,147.6 v1(109.23,147.81)
PCIE7_TR_U2_RX_DP: length 24.4
  TOP w0.089: U6E1.J24 v1(109.99,147.81)
  TOP w0.1: v1(127.68,145.92) 127.5,145.92 127.37,146.05 127.37,146.27 127.48,146.38 130.67,146.38 130.84,146.22 R6E16.1
  BOTTOM w0.1: v1(127.68,145.92) 127.34,146.26 127.34,146.41 127.12,146.63 113.74,146.63 113.11,147.26 109.81,147.26 109.64,147.43 109.64,147.62 109.84,147.81 v1(109.99,147.81)
PCIE7_TR_U2_TX_DN: length 22.2
  TOP w0.1: U6E1.C23 112.95,147.88 113.36,147.46 128.16,147.46 128.24,147.55 134.17,147.55 R5E36.1
PCIE7_TR_U2_TX_DP: length 22.2
  TOP w0.1: R5E34.1 134.74,148.12 134.74,147.75 134.59,147.6 134.4,147.6 134.25,147.75 128.16,147.75 128.07,147.66 113.45,147.66 113.33,147.78 U6E1.B23
PCIE7_U2_R_RX_DN: length 14.5
  TOP w0.1: J5H1.B8 162.96,66.8 161.7,68.07 156.46,68.07 155.24,69.29 151.81,69.29 R5G29.2
PCIE7_U2_R_RX_DP: length 14.5
  TOP w0.1: R5G30.2 151.89,69.09 155.16,69.09 156.38,67.87 161.61,67.87 162.76,66.72 162.76,65.93 162.66,65.83 162.31,65.83 162.21,65.93 J5H1.B7
PCIE7_U2_R_TX_DN: length 5.4
  TOP w0.1: J5H1.D8 162.91,72.7 162.91,73.41 163.1,73.6 163.1,75.37 162.08,76.39 162.08,76.87 C5G19.1
PCIE7_U2_R_TX_DP: length 5.4
  TOP w0.1: C5G18.1 161.88,76.87 161.88,76.3 162.9,75.29 162.9,73.68 162.75,73.53 162.44,73.53 162.21,73.76 J5H1.D7
PCIE7_U2_RX_DN: length 104.3
  TOP w0.1: R5G29.1 150.02,69.25 149.42,69.25 149.32,69.35 149.32,69.52 v1(149.63,69.83) ; R6E15.2 131.73,146.93 132.06,146.59 136.26,146.59 137.31,145.55 137.31,139.8 129.38,131.87 129.38,129.57 128.74,128.93 128.74,128.47 v1(129.03,128.19)
  BOTTOM w0.1: v1(149.63,69.83) 149.35,70.12 149.35,71.12 147.24,73.22 141.49,73.22 137.17,77.55 135.4,77.55 129.69,83.27 129.69,96.49 128.27,97.92 128.27,115.67 131.91,119.31 131.91,125.16 129.56,127.51 128.87,127.51 128.77,127.61 128.77,127.93 v1(129.03,128.19)
PCIE7_U2_RX_DP: length 104.3
  TOP w0.1: R6E17.2 132.19,146.39 136.18,146.39 137.11,145.47 137.11,139.88 129.18,131.95 129.18,129.65 128.54,129.01 128.54,128.52 v1(128.21,128.19) ; v1(148.81,69.83) 149.12,69.52 149.12,69.27 149.34,69.05 150.02,69.05 R5G30.1
  BOTTOM w0.1: v1(148.81,69.83) 149.15,70.17 149.15,71.04 147.16,73.02 141.41,73.02 137.08,77.35 135.32,77.35 129.49,83.18 129.49,96.41 128.07,97.83 128.07,115.75 131.71,119.4 131.71,125.08 129.48,127.31 128.78,127.31 128.57,127.52 128.57,127.84 v1(128.21,128.19)
PCIE7_U2_TX_DN: length 107.9
  TOP w0.1: v1(162.4,78.92) 162.08,78.61 162.08,78.28 162.14,78.23 C5G19.2 ; v1(129.97,129.89) 130.3,130.22 130.3,132.11 137.79,139.6 137.79,146.05 136.52,147.32 135.79,147.32 R5E35.2
  BOTTOM w0.1: v1(162.4,78.92) 162.21,78.74 162.06,78.74 161.96,78.64 161.96,78.51 161.02,77.57 144.13,77.57 142.33,79.37 136.16,79.37 132.33,83.2 132.33,97.56 134.42,99.65 134.42,108.67 134.74,108.99 134.74,115.95 135.43,116.64 135.43,120.06 133.91,121.58 133.91,125.75 132.61,127.05 132.61,128.78 132.3,129.08 130.49,129.08 130.27,129.3 130.27,129.59 v1(129.97,129.89)
PCIE7_U2_TX_DP: length 107.9
  TOP w0.1: v1(130.78,129.89) 130.5,130.18 130.5,132.03 137.99,139.52 137.99,146.13 136.6,147.52 135.64,147.52 135.5,147.66 135.5,148.18 R5E34.2 ; C5G18.2 161.82,78.23 161.88,78.29 161.88,78.61 v1(161.57,78.92)
  BOTTOM w0.1: v1(161.57,78.92) 161.76,78.74 161.76,78.6 160.93,77.77 144.22,77.77 142.42,79.57 136.24,79.57 132.53,83.29 132.53,97.48 134.62,99.57 134.62,108.58 134.94,108.91 134.94,115.87 135.63,116.56 135.63,120.14 134.11,121.66 134.11,125.83 132.81,127.13 132.81,128.86 132.38,129.28 130.57,129.28 130.47,129.38 130.47,129.58 v1(130.78,129.89)
PCIE8_TR_RX_C_DN: length 4.4
  TOP w0.089: 171.7,268.69 171.19,268.69 170.97,268.92 U5A2.H22
  TOP w0.1: 171.7,268.69 172.17,268.69 173.58,270.1 173.58,270.48 173.68,270.58 173.78,270.58 C4A12.1
PCIE8_TR_RX_C_DP: length 4.4
  TOP w0.089: U5A2.H23 171.37,268.92 171.28,269.01 171.28,269.06 171.37,269.15 171.61,269.15 171.71,269.05
  TOP w0.1: C4A11.1 174.11,271.09 173.8,270.78 173.59,270.78 173.38,270.57 173.38,270.18 172.08,268.89 171.87,268.89 171.71,269.05
PCIE8_TR_RX_DN: length 186.8
  TOP w0.1: v1(177.32,271.27) 177.19,271.27 176.85,271.6 176.85,272.21 176.57,272.5 174.97,272.5 174.87,272.6 174.87,272.79 C4A9.1 ; R6E12.2 129.94,148.21 v1(129.16,148.21)
  LAY6 w0.115: v1(129.16,148.21) 129.16,148.51 129.31,148.66 129.69,148.66 129.81,148.54 129.81,145.8 129.47,145.46 125.5,145.46 123.06,147.9 123.06,149.95 122.15,150.87 122.15,155.3 124.16,157.31 126.73,157.31 128.75,159.33 128.75,167.35 128.24,167.86 128.24,172.84 127.5,173.58 127.5,176.15 126.97,176.68 126.97,182.78 129.56,185.37 129.56,188.87 129.92,189.23 129.92,190.82 128.88,191.86 128.88,195.3 129.54,195.96 129.54,209.04 130.17,209.68 130.17,213.79 129.66,214.29 129.66,225.8 127.38,228.09 127.38,234.57 127.5,234.69 127.5,239.34 140.91,252.75 141.81,252.75 144.8,255.73 145.76,255.73 147.09,257.06 149.82,257.06 151.07,258.32 155.7,258.32 155.98,258.59 158.21,258.59 159.13,259.52 159.13,259.97 161.18,262.02 170.52,262.02 171.93,263.43 171.93,267.49 173.17,268.73 178.43,268.73 178.94,269.24 178.94,270.25 178.56,270.64 177.22,270.64 176.97,270.88 176.97,271.15 177.1,271.27 v1(177.32,271.27)
PCIE8_TR_RX_DP: length 186.8
  TOP w0.1: C4A10.1 175.27,272.3 176.48,272.3 176.65,272.13 176.65,271.4 v1(176.52,271.27) ; v1(129.16,149.35) 129.94,149.35 R6E11.2
  LAY6 w0.115: v1(129.16,149.35) 129.16,149.02 129.28,148.89 129.79,148.89 130.04,148.64 130.04,145.7 129.57,145.23 125.4,145.23 122.83,147.8 122.83,149.86 121.92,150.77 121.92,155.39 124.06,157.54 126.63,157.54 128.52,159.43 128.52,167.26 128.01,167.77 128.01,172.75 127.27,173.49 127.27,176.05 126.74,176.58 126.74,182.88 129.33,185.47 129.33,188.97 129.69,189.33 129.69,190.72 128.65,191.77 128.65,195.4 129.31,196.06 129.31,209.14 129.94,209.77 129.94,213.69 129.43,214.2 129.43,225.71 127.15,228 127.15,234.66 127.27,234.79 127.27,239.44 140.82,252.98 141.72,252.98 144.7,255.96 145.66,255.96 146.99,257.29 149.72,257.29 150.97,258.55 155.6,258.55 155.88,258.82 158.11,258.82 158.9,259.61 158.9,260.06 161.09,262.25 170.43,262.25 171.7,263.52 171.7,267.59 173.07,268.96 178.33,268.96 178.71,269.33 178.71,270.16 178.46,270.41 177.13,270.41 176.74,270.79 176.74,271.05 v1(176.52,271.27)
PCIE8_TR_TX_C_DN: length 5.3
  TOP w0.089: 171.68,270.01 171.62,270.07 171.19,270.07 U5A2.F22
  TOP w0.1: C4A9.2 173.87,272.66 173.47,272.66 172.69,271.89 172.69,270.56 172.05,269.92 171.76,269.92 171.68,270.01
PCIE8_TR_TX_C_DP: length 5.3
  TOP w0.089: 171.7,269.66 171.65,269.61 171.39,269.61 171.34,269.66 171.34,269.76 U5A2.F23
  TOP w0.1: C4A10.2 174.13,272.32 173.98,272.46 173.55,272.46 172.89,271.81 172.89,270.48 172.13,269.72 171.76,269.72 171.7,269.66
PCIE8_TR_TX_DN: length 186.9
  TOP w0.1: v1(176.5,269.49) 176.43,269.57 176.43,269.82 176.55,269.94 177,269.94 177.1,270.04 177.1,270.19 176.85,270.44 175.61,270.44 175.37,270.68 174.83,270.68 174.73,270.58 174.73,270.39 174.86,270.25 C4A12.2 ; v1(133.09,145.92) 133.1,145.93 R5E38.2
  LAY6 w0.115: v1(133.09,145.92) 133.09,145.52 132.98,145.41 132.79,145.41 132.73,145.47 130.66,145.47 129.34,144.14 125.73,144.14 122.17,147.7 122.17,149.73 121.41,150.49 121.41,155.6 123.84,158.03 126.4,158.03 127.99,159.61 127.99,166.9 125.83,169.06 125.83,182.73 128.8,185.7 128.8,188.44 126.87,190.37 126.87,199.26 128.04,200.43 128.04,208.69 129.41,210.06 129.41,213.48 128.93,213.96 128.93,225.27 126.55,227.65 126.55,236.28 125.85,236.98 125.85,237.49 126.74,238.38 126.74,239.6 140.66,253.51 141.56,253.51 144.5,256.45 145.46,256.45 146.79,257.78 149.49,257.78 150.75,259.05 155.35,259.05 155.71,259.4 157.87,259.4 158.36,259.9 158.36,260.35 160.78,262.76 170.12,262.76 171.19,263.83 171.19,268.35 173.1,270.25 176.22,270.25 176.66,269.81 176.66,269.61 176.54,269.49 v1(176.5,269.49)
PCIE8_TR_TX_DP: length 186.9
  TOP w0.1: C4A11.2 175.25,270.88 175.46,270.88 175.7,270.64 176.94,270.64 177.3,270.27 v1(177.3,269.49) ; v1(133.09,144.78) 133.1,144.78 R5E40.2
  LAY6 w0.115: v1(133.09,144.78) 132.64,145.24 130.75,145.24 129.43,143.91 125.63,143.91 121.94,147.6 121.94,149.64 121.18,150.4 121.18,155.7 123.74,158.26 126.31,158.26 127.76,159.71 127.76,166.81 125.6,168.97 125.6,182.82 128.57,185.79 128.57,188.35 126.64,190.28 126.64,199.36 127.81,200.53 127.81,208.78 129.18,210.15 129.18,213.38 128.7,213.87 128.7,225.18 126.32,227.55 126.32,236.19 125.62,236.89 125.62,237.58 126.51,238.47 126.51,239.69 140.56,253.74 141.46,253.74 144.4,256.68 145.36,256.68 146.69,258.01 149.4,258.01 150.66,259.28 155.26,259.28 155.61,259.63 157.77,259.63 158.13,259.99 158.13,260.44 160.68,262.99 170.02,262.99 170.96,263.93 170.96,268.44 173,270.48 176.31,270.48 v1(177.3,269.49)
