# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
C3P21  22uF  [SMC0603ID]  212.19 172.52 90 bottom
C3P22  22uF  [SMC0603ID]  213.48 172.39 90 bottom
C3P23  22uF  [SMC0603ID]  226.98 172.87 90 bottom
C3P24  22uF  [SMC0603ID]  225.71 172.35 90 bottom
C4A1  4.7UF  [SMC0603IA]  203.2 286.26 0 top
C4A2  470pF  [SMC0402IA]  200.4 286 90 top
C4A3  0.1uF  [SMC0402IA]  201.29 286 90 top
C4A4  0.1uF  [SMC0402IA]  202.18 286 90 top
C4A5  470uF  [CPRC68_250PMA]  202.56 283.08 0 top
C4A6  0.1uF  [SMC0402IA]  177.29 279.78 270 top
C4A7  22pF  [SMC0402IA]  173.6 275.21 180 top
C4A8  22pF  [SMC0402IA]  174.49 275.21 0 top
C4A9  0.22uF  [SMC1005MB]  175 272.92 180 top
C4A10  0.22uF  [SMC1005MB]  175 272.03 180 top
C4A11  0.22uF  [SMC1005MB]  174.11 271.14 0 top
C4A12  0.22uF  [SMC1005MB]  174.11 270.25 0 top
C4A13  0.22uF  [SMC1005MB]  175 269.37 180 top
C4A14  0.22uF  [SMC1005MB]  175 268.48 180 top
C4A15  0.22uF  [SMC1005MB]  174.11 267.59 0 top
C4A16  0.22uF  [SMC1005MB]  174.11 266.7 0 top
C4A17  0.22uF  [SMC1005MB]  175 265.81 180 top
C4A18  0.22uF  [SMC1005MB]  175 264.92 180 top
C4A19  470pF  [SMC0402IA]  181.48 264.67 270 top
C4A20  470pF  [SMC0402IA]  182.37 264.67 270 top
C4A21  470pF  [SMC0402IA]  194.05 264.67 180 top
C4A22  0.1uF  [SMC0402IA]  179.7 264.54 0 top
C4A23  0.22uF  [SMC1005MB]  174.11 264.03 0 top
C4A24  0.1uF  [SMC0402IA]  185.29 263.78 90 top
C4A25  0.1uF  [SMC0402IA]  186.69 263.78 90 top
C4A26  0.1uF  [SMC0402IA]  188.08 263.78 90 top
C4A27  470pF  [SMC0402IA]  179.7 263.68 0 top
C4A28  0.22uF  [SMC1005MB]  174.11 263.14 0 top
C4A29  0.1uF  [SMC0402IA]  191.38 262.76 90 top
C4A30  22pF  [SMC0402IA]  192.27 262.76 90 top
C4A31  22pF  [SMC0402IA]  193.16 262.38 270 top
C4A32  0.22uF  [SMC1005MB]  175 262.25 180 top
C4A33  0.22uF  [SMC1005MB]  175 261.36 180 top
C4A34  1uF  [SMC0402IA]  182.37 260.73 180 top
C4A35  0.22uF  [SMC1005MB]  174.11 260.48 0 top
C4A36  10uF  [SMC0603IA]  194.69 259.84 0 top
C4A37  0.1uF  [SMC0402IA]  201.26 259.71 90 top
C4A38  0.1uF  [SMC0402IA]  202.15 259.71 90 top
C4A39  0.33uF  [SMC1005MB]  203.42 259.71 90 top
C4A40  0.33uF  [SMC1005MB]  204.31 259.71 90 top
C4A41  0.1uF  [SMC0402IA]  205.46 259.71 90 top
C4A42  0.1uF  [SMC0402IA]  206.34 259.71 90 top
C4B1  0.22uF  [SMC1005MB]  174.11 259.59 0 top
C4B2  10uF  [SMC0603IA]  194.69 258.57 0 top
C4B3  0.1uF  [SMC0402IA]  173.73 257.68 0 top
C4B4  2200pF  [SMC0402IA]  176.4 256.79 0 top
C4B5  22uF  [SMC0805IA]  179.45 255.01 90 top
C4B6  10uF  [SMC0603IA]  171.95 254.63 180 top
C4B7  0.1uF  [SMC0402IA]  183.51 254.63 270 top
C4B8  0.1uF  [SMC0402IA]  188.84 254.63 270 top
C4B9  0.1uF  [SMC0402IA]  184.4 253.74 90 top
C4B10  0.1uF  [SMC0402IA]  185.29 253.74 90 top
C4B11  0.1uF  [SMC0402IA]  186.18 253.74 90 top
C4B12  0.1uF  [SMC0402IA]  187.07 253.74 90 top
C4B13  0.1uF  [SMC0402IA]  203.2 253.11 270 top
C4B14  0.1uF  [SMC0402IA]  204.08 253.11 270 top
C4B15  0.1uF  [SMC0402IA]  200.66 252.98 0 top
C4B16  0.1uF  [SMC0402IA]  205.58 252.22 90 top
C4B17  0.1uF  [SMC0402IA]  206.47 252.22 90 top
C4B18  0.1uF  [SMC0402IA]  200.66 252.09 0 top
C4B19  22uF  [CPRC55_200PMA]  179.32 249.93 270 top
C4B20  0.1uF  [SMC0603IA]  184.27 246.89 90 top
C4B21  0.1uF  [SMC0603IA]  197.61 246.89 90 top
C4B22  1uF  [SMC0402IA]  199 246.89 0 top
C4B23  10uF  [SMC0603IA]  204.72 246.89 90 top
C4B24  1uF  [SMC0402IA]  185.29 246.63 0 top
C4B25  10uF  [SMC0603IA]  192.78 243.84 270 top
C4B26  10uF  [SMC0603IA]  194.05 243.84 270 top
C4B27  10uF  [SMC0603IA]  180.72 243.58 270 top
C4B28  1uF  [SMC0402IA]  188.46 243.58 270 top
C4B29  10uF  [SMC0603IA]  203.58 243.58 270 top
C4B30  1uF  [SMC0402IA]  201.8 243.58 270 top
C4B31  47uF  [SMC0805IA]  175.76 238 180 top
C4B32  47uF  [SMC0805IA]  177.8 238.12 0 top
C4B33  47uF  [SMC0805IA]  175.76 236.35 180 top
C4B34  470uF  [CPRC34_250PMA]  175.46 231.77 90 top
C4B35  1000pF  [SMC0402IA]  180.34 228.6 90 top
C4B36  1000pF  [SMC0402IA]  175.76 227.33 180 top
C4C1  470uF  [CPRC34_250PMA]  194.69 222.63 90 top
C4C2  470uF  [CPRC34_250PMA]  203.32 222.63 90 top
C4C3  10uF  [SMC0603IA]  170.68 219.2 270 top
C4C4  10uF  [SMC0603IA]  171.95 219.2 270 top
C4C5  1000pF  [SMC0402IA]  175.76 215.64 180 top
C4C6  1uF  [SMC0402IA]  174.62 212.22 270 top
C4C7  0.1uF  [SMC0402IA]  179.83 210.44 180 top
C4C8  1800pF  [SMC0402IA]  178.05 209.78 270 top
C4C9  22uF  [SMC0805MA]  170.94 209.55 270 top
C4C10  1uF  [SMC0402IA]  177.16 208.53 90 top
C4C11  0.1uF  [SMC0402IA]  181.61 205.36 0 top
C4C12  10uF  [SMC0603IA]  178.81 205.23 180 top
C4C13  0.1uF  [SMC0402IA]  186.43 204.85 180 top
C4C14  10uF  [SMC0603IA]  183 203.07 270 top
C4C15  10uF  [SMC0603IA]  171.06 202.94 90 top
C4C16  22uF  [SMC0805MA]  177.29 201.42 90 top
C4C17  10uF  [SMC0603IA]  173.22 201.29 270 top
C4C18  10uF  [SMC0603IA]  171.95 201.04 270 top
C4C19  1uF  [SMC0402IA]  177.92 199.52 270 top
C4C20  1uF  [SMC0402IA]  186.69 196.85 270 top
C4C21  22uF  [SMC0603ID]  174.37 195.71 90 top
C4C22  22uF  [SMC0603ID]  176.4 194.82 0 top
C4D1  22uF  [SMC0603ID]  185.29 194.56 0 top
C4D2  1uF  [SMC0402MA]  176.65 193.8 0 top
C4D3  470uF  [CPRC34_250PMA]  180.21 192.02 90 top
C4D4  22uF  [SMC0603ID]  186.05 191.39 90 top
C4D5  100uF  [SMC1206IA]  178.18 187.7 180 top
C4D6  47uF  [SMC0603IA]  179.57 186.56 0 top
C4D7  47uF  [SMC0805IA]  177.54 185.8 180 top
C4D8  22uF  [SMC0603ID]  179.57 185.29 0 top
C4D9  47uF  [SMC0603IA]  177.41 184.28 180 top
C4D10  470uF  [CPRC34_250PMA]  178.3 181.1 0 top
C4D11  470uF  [CPRC34_250PMA]  178.3 173.23 0 top
C4D12  470uF  [CPRC34_250PMA]  178.3 165.23 0 top
C4E1  12PF  [SMC0402IA]  205.99 133.7 90 top
C4E2  12PF  [SMC0402IA]  200.02 133.6 90 top
C4E3  12PF  [SMC0402IA]  175.51 116.33 0 top
C4F1  2.2pF  [SMC0402IA]  170.05 116.33 180 top
C4F2  2.2pF  [SMC0402IA]  179.07 116.33 180 top
C4F3  2.2pF  [SMC0402IA]  187.19 116.33 180 top
C4F4  12PF  [SMC0402IA]  183.76 116.33 0 top
C4F5  12PF  [SMC0402IA]  193.8 116.33 0 top
C4F6  10uF  [SMC0402MC]  196.21 116.33 0 top
C4F7  10uF  [SMC0402MC]  202.81 116.33 0 top
C4F8  22uF  [SMC0805IA]  199.26 115.95 0 top
C4F9  22uF  [SMC0805IA]  205.53 115.87 0 top
C4F10  1uF  [SMC0402IA]  201.29 106.31 180 top
C4F11  12PF  [SMC0402IA]  237.61 133.48 90 top
C4G1  12PF  [SMC0402IA]  194.94 96.65 0 top
C4G2  10uF  [SMC0402MC]  204.21 96.65 180 top
C4G3  10uF  [SMC0402MC]  206.12 96.65 180 top
C4G4  22uF  [SMC0805IA]  202.05 96.39 180 top
C4G5  22uF  [SMC0805IA]  205.86 94.99 0 top
C4G6  0.1uF  [SMC0402IA]  181.61 94.11 0 top
C4G7  1000uF  [CPRC68_250PMA]  192.82 91.18 90 top
C4G8  1000uF  [CPRC68_250PMA]  200.82 91.18 90 top
C4G9  560uF  [CPRC55_200MA]  203.32 89.18 180 top
C4G10  0.1uF  [SMC0402IA]  198.5 88.26 270 top
C4G12  0.1uF  [SMC0402IA]  194.05 85.34 270 top
C4G13  10uF  [SMC0603IA]  177.41 84.58 270 top
C4G14  100uF  [CPR60X63_25PMA]  171.57 82.8 90 top
C4G16  1uF  [SMC0402IA]  194.05 82.04 90 top
C4G17  0.1uF  [SMC0402IA]  191.77 79.75 0 top
C4G18  0.1uF  [SMC0402IA]  175.89 78.1 90 top
C4G19  0.1uF  [SMC0402IA]  177.03 78.1 90 top
C4G20  1uF  [SMC0402IA]  179.57 77.34 180 top
C4G21  100uF  [CPRC63_250PMA]  187.45 75.06 90 top
C4G22  100uF  [CPRC63_250PMA]  171.57 74.93 90 top
C4G23  1uF  [SMC0603IA]  202.43 74.67 0 top
C4G24  470pF  [SMC0402IA]  202.94 73.28 0 top
C4G25  0.1uF  [SMC0402IA]  182.47 76.06 180 top
C4H1  0.1uF  [SMC0402IA]  185.29 59.18 0 top
C4H2  470pF  [SMC0402IA]  194.18 59.05 270 top
C4H3  0.1uF  [SMC0402IA]  195.32 59.05 270 top
C4H4  0.1uF  [SMC0402IA]  190.73 56.64 90 top
C4H5  0.1uF  [SMC0402IA]  191.88 56.64 90 top
C4H6  0.1uF  [SMC0402IA]  203.83 55.75 90 top
C4H7  0.1uF  [SMC0402IA]  186.42 54.35 180 top
C4H8  0.1uF  [SMC0402IA]  192.13 54.35 0 top
C4H9  0.1uF  [SMC0402IA]  199 54.23 0 top
C4H10  10uF  [SMC0603IA]  182.88 54.1 180 top
C4H11  0.1uF  [SMC0402IA]  205.23 53.47 0 top
C4H12  4.7UF  [SMC0603IA]  182.88 52.83 180 top
C4H13  0.1uF  [SMC0402IA]  192.13 52.07 0 top
C4H14  0.1uF  [SMC0402IA]  205.23 51.18 0 top
C4H15  2.2UF  [SMC0402IA]  182.62 49.53 180 top
C4L1  0.1uF  [SMC0402IA]  172.33 285.64 0 bottom
C4L2  0.1uF  [SMC0402IA]  172.33 284.11 0 bottom
C4L3  1UF  [SMC0201IA]  170.68 270.13 0 bottom
C4M1  0.1uF  [SMC0402IA]  207.01 258.06 0 bottom
C4M2  0.1uF  [SMC0402IA]  202.56 258.06 180 bottom
C4M3  0.1uF  [SMC0402IA]  200.78 258.06 270 bottom
C4M4  0.1uF  [SMC0402IA]  207.01 254.76 0 bottom
C4M5  0.1uF  [SMC0402IA]  202.56 254.76 180 bottom
C4M6  0.1uF  [SMC0402IA]  200.78 254.76 180 bottom
C4M7  0.1uF  [SMC0402IA]  207.01 253.24 0 bottom
C4M8  4.7uF  [SMC0402IA]  189.1 247.01 0 bottom
C4M9  10uF  [SMC0603IA]  194.81 244.23 270 bottom
C4M10  10uF  [SMC0603IA]  193.64 244.23 270 bottom
C4M11  10uF  [SMC0603IA]  204.47 243.58 270 bottom
C4M12  10uF  [SMC0603IA]  203.2 243.58 270 bottom
C4M13  10uF  [SMC0603IA]  180.21 243.58 270 bottom
C4M14  10uF  [SMC0603IA]  181.48 243.58 270 bottom
C4M15  1uF  [SMC0402IA]  186.69 243.33 270 bottom
C4M16  0.1uF  [SMC0402IA]  190.11 241.81 0 bottom
C4M17  0.1uF  [SMC0402IA]  189.35 241.81 180 bottom
C4M18  0.47uF  [SMC0402IA]  191.77 241.55 270 bottom
C4M19  0.1uF  [SMC0402IA]  190.24 239.9 270 bottom
C4M20  0.1uF  [SMC0402IA]  189.35 239.9 270 bottom
C4M21  680pF  [SMC0402IA]  203.07 239.77 0 bottom
C4M22  680pF  [SMC0402IA]  201.54 239.77 180 bottom
C4M23  680pF  [SMC0402IA]  179.45 239.52 90 bottom
C4M24  47uF  [SMC0805IA]  177.54 238.12 0 bottom
C4M25  47uF  [SMC0805IA]  175.76 238 180 bottom
C4M26  47uF  [SMC0805IA]  175.76 236.35 180 bottom
C5A1  0.1uF  [SMC0402IA]  162.17 286.89 90 top
C5A2  0.1uF  [SMC0402IA]  163.06 286.89 0 top
C5A3  100pF  [SMC0402IA]  148.59 286.64 0 top
C5A4  100pF  [SMC0402IA]  161.29 284.1 90 top
C5A5  100pF  [SMC0402IA]  149.47 283.21 180 top
C5A6  100pF  [SMC0402IA]  161.67 281.43 90 top
C5A7  100pF  [SMC0402IA]  154.55 279.78 270 top
C5A8  0.1uF  [SMC0402IA]  156.97 279.78 180 top
C5A9  4.7UF  [SMC0603IA]  155.7 278.64 0 top
C5A10  4.7UF  [SMC0603IA]  148.33 278.38 90 top
C5A11  0.1uF  [SMC0402IA]  149.35 278.38 90 top
C5A12  0.22uF  [SMC1005MB]  167.76 277.24 270 top
C5A13  0.22uF  [SMC1005MB]  168.65 277.24 270 top
C5A14  47uF  [SMC0603IA]  155.06 275.33 0 top
C5A15  10uF  [SMC0402IA]  158.87 275.33 180 top
C5A16  0.22uF  [SMC1005MB]  168.91 274.83 270 top
C5A17  0.22uF  [SMC1005MB]  169.79 274.83 270 top
C5A18  10uF  [SMC0402IA]  158.87 274.32 180 top
C5A19  220pF  [SMC0402IA]  144.52 259.08 270 top
C5A20  220pF  [SMC0402IA]  143.63 259.08 270 top
C5A21  47uF  [SMC0603IA]  155.06 274.06 0 top
C5A22  22uF  [SMC0805IA]  139.7 273.81 0 top
C5A23  10uF  [SMC0402IA]  158.87 273.3 180 top
C5A24  47uF  [SMC0603IA]  155.06 272.79 0 top
C5A25  10uF  [SMC0402IA]  158.87 271.14 180 top
C5A26  10uF  [SMC0402MC]  136.52 268.98 180 top
C5A27  4.7UF  [SMC0603IA]  149.22 268.86 90 top
C5A28  10uF  [SMC0402MC]  136.52 266.95 180 top
C5A29  1uF  [SMC0603IA]  134.11 270 270 top
C5A30  0.1uF  [SMC0402IA]  147.95 261.49 270 top
C5B1  0.22uF  [SMC1005MB]  163.06 259.46 270 top
C5B2  0.22uF  [SMC1005MB]  163.95 259.46 270 top
C5B3  0.22uF  [SMC1005MB]  164.84 259.46 270 top
C5B4  0.22uF  [SMC1005MB]  165.73 259.46 270 top
C5B5  0.22uF  [SMC1005MB]  166.62 259.46 270 top
C5B6  0.22uF  [SMC1005MB]  167.51 259.46 270 top
C5B7  0.22uF  [SMC1005MB]  168.4 259.46 270 top
C5B8  0.22uF  [SMC1005MB]  169.29 259.46 270 top
C5B9  220pF  [SMC0402IA]  144.39 273.18 90 top
C5B10  220pF  [SMC0402IA]  142.62 273.18 90 top
C5B12  0.1uF  [SMC0603IA]  147.32 246.25 90 top
C5B15  0.1uF  [SMC0603IA]  135 243.71 270 top
C5B16  0.1uF  [SMC0603IA]  136.27 243.71 270 top
C5B17  0.1uF  [SMC0402IA]  155.64 236.22 270 top
C5B19  0.1uF  [SMC0402IA]  135.38 239.65 270 top
C5B20  0.1uF  [SMC0402IA]  136.27 239.65 270 top
C5B22  0.1uF  [SMC0402IA]  135.38 237.36 270 top
C5B23  0.1uF  [SMC0402IA]  136.27 237.36 270 top
C5B32  0.22uF  [SMC0402IA]  148.97 231.01 180 top
C5B33  0.22uF  [SMC0402IA]  148.97 230.12 180 top
C5B34  10uF  [SMC0603IA]  165.1 246.51 0 top
C5B35  1uF  [SMC0402MA]  162.3 245.62 180 top
C5B36  0.1uF  [SMC0402IA]  151 244.47 90 top
C5B37  0.47uF  [SMC0402IA]  156.21 244.73 90 top
C5B38  0.1uF  [SMC0402IA]  150.24 243.58 0 top
C5B39  0.1uF  [SMC0402IA]  152.01 243.58 0 top
C5B40  0.22uF  [SMC1005MB]  160.14 244.09 0 top
C5B41  2.2UF  [SMC0402IA]  160.14 243.2 0 top
C5B42  220pF  [SMC0402IA]  152.14 240.92 90 top
C5B43  220pF  [SMC0402IA]  150.62 242.7 0 top
C5B44  100KOHM  [STR0402MA]  164.97 238.89 180 top
C5B45  4.7uF  [SMC0402IA]  154.81 236.22 270 top
C5C1  0.22uF  [SMC0402IA]  148.97 227.07 180 top
C5C2  0.22uF  [SMC0402IA]  148.97 226.19 180 top
C5C3  0.22uF  [SMC0402IA]  148.97 223.14 180 top
C5C4  0.22uF  [SMC0402IA]  148.97 222.25 180 top
C5C5  0.1uF  [SMC0402IA]  151 219.58 270 top
C5C6  0.01uF  [SMC0402IA]  152.14 219.58 270 top
C5C7  0.1uF  [SMC0402IA]  153.79 219.58 270 top
C5C8  0.1uF  [SMC0402IA]  154.68 219.58 270 top
C5C9  0.01uF  [SMC0402IA]  155.57 219.58 270 top
C5C10  0.01uF  [SMC0402IA]  166.37 219.58 270 top
C5C11  0.01uF  [SMC0402IA]  167.25 219.58 270 top
C5C12  0.01uF  [SMC0402IA]  168.14 219.58 270 top
C5C13  10uF  [SMC0603IA]  169.41 219.2 270 top
C5C14  0.22uF  [SMC0402IA]  148.97 219.07 180 top
C5C15  0.22uF  [SMC0402IA]  148.97 218.18 180 top
C5C16  680pF  [SMC0402IA]  165.6 216.79 0 top
C5C17  10uF  [SMC0603IA]  163.32 213.99 180 top
C5C18  0.22uF  [SMC0402IA]  148.97 213.1 180 top
C5C19  10uF  [SMC0603IA]  163.32 212.72 180 top
C5C20  220pF  [SMC0402IA]  157.35 211.71 0 top
C5C21  10uF  [SMC0603IA]  151 212.34 270 top
C5C22  0.22uF  [SMC0402IA]  148.97 212.22 180 top
C5C23  0.01uF  [SMC0402IA]  160.4 211.2 180 top
C5C24  0.1uF  [SMC0402IA]  163.19 211.71 180 top
C5C25  22uF  [SMC0805MA]  169.41 211.33 90 top
C5C26  0.22uF  [SMC0402IA]  148.97 209.04 180 top
C5C27  0.01uF  [SMC0402IA]  166.62 208.91 270 top
C5C28  0.22uF  [SMC0402IA]  148.97 208.15 180 top
C5C29  0.22uF  [SMC0402IA]  148.97 205.1 180 top
C5C30  0.22uF  [SMC0402IA]  148.97 204.21 180 top
C5C31  1uF  [SMC0402MA]  163.57 203.83 0 top
C5C32  1uF  [SMC0402MA]  168.78 203.2 90 top
C5C33  10uF  [SMC0603IA]  169.79 202.94 90 top
C5C34  0.1uF  [SMC0402IA]  155.57 202.44 90 top
C5C35  0.22uF  [SMC0402IA]  148.97 201.04 180 top
C5C36  0.22uF  [SMC0402IA]  148.97 200.15 180 top
C5C37  1uF  [SMC0402MA]  154.81 199.13 270 top
C5C38  0.1uF  [SMC0603IA]  164.33 198.25 270 top
C5C39  0.22uF  [SMC0402IA]  148.97 197.1 180 top
C5C40  0.22uF  [SMC0402IA]  148.97 196.21 180 top
C5C41  680pF  [SMC0402IA]  166.49 195.32 270 top
C5C42  0.1uF  [SMC0402IA]  156.59 218.31 0 top
C5D1  0.1uF  [SMC0402IA]  152.78 193.93 180 top
C5D2  0.22uF  [SMC0402IA]  148.97 193.17 180 top
C5D3  0.22uF  [SMC0402IA]  148.97 192.28 180 top
C5D6  0.22uF  [SMC0402IA]  148.97 189.1 180 top
C5D7  0.22uF  [SMC0402IA]  148.97 188.21 180 top
C5D8  0.1uF  [SMC0402IA]  135.25 186.18 0 top
C5D9  0.22uF  [SMC0402IA]  148.97 185.16 180 top
C5D10  0.22uF  [SMC0402IA]  148.97 184.28 180 top
C5D11  0.22uF  [SMC0402IA]  148.97 181.1 180 top
C5D12  0.22uF  [SMC0402IA]  148.97 180.21 180 top
C5D13  0.1uF  [SMC0402IA]  134.74 177.67 90 top
C5D14  0.22uF  [SMC0402IA]  148.97 177.04 180 top
C5D15  0.22uF  [SMC0402IA]  148.97 176.15 180 top
C5D16  1uF  [SMC0402MA]  156.08 175.89 0 top
C5D17  1uF  [SMC0402MA]  151.51 174.24 270 top
C5D18  0.22uF  [SMC0402IA]  148.97 173.1 180 top
C5D19  10uF  [SMC0603IA]  163.7 172.34 90 top
C5D20  10uF  [SMC0603IA]  164.97 172.34 90 top
C5D21  0.22uF  [SMC0402IA]  148.97 172.21 180 top
C5D22  0.1uF  [SMC0603IA]  156.71 170.69 270 top
C5D23  10uF  [SMC0603IA]  163.83 170.56 270 top
C5D24  10uF  [SMC0603IA]  165.1 170.56 270 top
C5D25  1uF  [SMC0402MA]  166.11 170.43 270 top
C5D26  0.22uF  [SMC0402IA]  148.97 169.16 180 top
C5D27  0.22uF  [SMC0402IA]  148.97 168.27 180 top
C5D28  680pF  [SMC0402IA]  165.73 167.26 180 top
C5D29  22uF  [SMC0603ID]  158.49 163.45 180 top
C5E1  22uF  [SMC0603ID]  158.49 162.05 180 top
C5E2  100uF  [SMC1206IA]  164.08 158.49 180 top
C5E3  1uF  [SMC0402MA]  156.84 158.24 0 top
C5E4  100uF  [SMC1206IA]  164.08 156.46 180 top
C5E5  1uF  [SMC0402MA]  154.94 156.08 180 top
C5E6  22uF  [SMC0603ID]  167.89 155.19 0 top
C5E7  1uF  [SMC0402MA]  154.17 154.56 270 top
C5E8  47uF  [SMC0805IA]  163.44 154.56 180 top
C5E9  22uF  [SMC0603ID]  167.89 153.92 0 top
C5E10  47uF  [SMC0805IA]  163.44 152.91 180 top
C5E11  22uF  [SMC0603ID]  167.89 152.65 0 top
C5E12  22uF  [SMC0603ID]  167.89 151.38 0 top
C5E13  0.1uF  [SMC0402IA]  153.28 133.35 90 top
C5E14  2.2UF  [SMC0402IA]  154.43 133.35 90 top
C5E15  0.1uF  [SMC0402IA]  155.57 133.35 90 top
C5E16  0.1uF  [SMC0402IA]  156.71 133.35 90 top
C5E17  0.1uF  [SMC0402IA]  147.19 132.97 0 top
C5F1  0.1uF  [SMC0402IA]  154.81 116.58 180 top
C5F2  0.1uF  [SMC0402IA]  156.21 116.58 0 top
C5F3  0.1uF  [SMC0402IA]  159 116.46 270 top
C5F4  2.2UF  [SMC0402IA]  160.14 116.46 270 top
C5F5  12PF  [SMC0402IA]  166.37 116.33 0 top
C5F6  2.2pF  [SMC0402IA]  213.36 133.73 90 top
C5F7  680pF  [SMC0402IA]  145.79 112.39 0 top
C5F8  22uF  [SMC0805MA]  146.17 108.84 90 top
C5F9  22uF  [SMC0805MA]  144.27 107.06 270 top
C5F10  10uF  [SMC0603IA]  137.92 106.81 270 top
C5F11  10uF  [SMC0603IA]  139.19 106.81 270 top
C5F12  0.1uF  [SMC0402IA]  140.33 106.55 270 top
C5F13  0.1uF  [SMC0402IA]  155.7 106.68 180 top
C5F14  0.1uF  [SMC0402IA]  156.46 106.04 0 top
C5F15  2.2UF  [SMC0402IA]  159 106.68 180 top
C5F16  0.1uF  [SMC0402IA]  159.76 106.7 0 top
C5F17  22uF  [SMC0805MA]  143.27 99.52 0 top
C5F18  22uF  [SMC0805MA]  139.61 99.35 90 top
C5F19  22uF  [SMC0805MA]  137.71 99.34 90 top
C5F20  47uF  [SMC0805IA]  135.76 99.31 90 top
C5F21  47uF  [SMC0805IA]  141.47 99.31 90 top
C5F22  22uF  [SMC0805MA]  143.26 97.75 0 top
C5G1  2.2UF  [SMC0402IA]  159 97.28 180 top
C5G2  0.1uF  [SMC0402IA]  159.89 97.28 0 top
C5G3  0.1uF  [SMC0402IA]  155.44 97.03 270 top
C5G4  0.1uF  [SMC0402IA]  156.46 97.03 270 top
C5G5  470uF  [CPRC68_250PMA]  134.62 96.14 0 top
C5G6  1uF  [SMC0603IA]  160.27 94.87 90 top
C5G7  4700pF  [SMC0402MA]  166.49 94.49 0 top
C5G8  0.1uF  [SMC0402IA]  166.75 93.47 0 top
C5G9  0.1uF  [SMC0402IA]  159.25 91.57 90 top
C5G10  10uF  [SMC0603IA]  154.17 89.15 90 top
C5G11  10uF  [SMC0603IA]  155.44 89.15 90 top
C5G12  10uF  [SMC0603IA]  156.71 89.15 90 top
C5G13  10uF  [SMC0603IA]  158.36 89.03 0 top
C5G14  470uF  [CPRC68_250PMA]  134.62 88.01 0 top
C5G15  0.1uF  [SMC0402IA]  167.64 81.91 0 top
C5G16  0.22uF  [SMC0402IA]  159.13 77.34 90 top
C5G17  0.22uF  [SMC0402IA]  160.27 77.34 90 top
C5G18  0.22uF  [SMC0402IA]  161.41 77.34 90 top
C5G19  0.22uF  [SMC0402IA]  162.56 77.34 90 top
C5G20  0.22uF  [SMC0402IA]  163.7 77.34 90 top
C5G21  0.22uF  [SMC0402IA]  164.84 77.34 90 top
C5G22  0.22uF  [SMC0402IA]  165.98 77.34 90 top
C5G23  0.22uF  [SMC0402IA]  167.13 77.34 90 top
C5H1  100pF  [SMC0402IA]  147.95 39.24 270 top
C5J1  0.1uF  [SMC0402IA]  145.79 27.05 180 top
C5L1  0.1uF  [SMC0402IA]  169.41 285.76 180 bottom
C5L2  0.1uF  [SMC0402IA]  169.41 284.11 180 bottom
C5L3  1UF  [SMC0201IA]  169.29 271.4 90 bottom
C5L4  1UF  [SMC0201IA]  168.65 271.4 90 bottom
C5L5  1UF  [SMC0201IA]  168.02 271.4 90 bottom
C5L6  1UF  [SMC0201IA]  167.38 271.4 90 bottom
C5L7  1UF  [SMC0201IA]  166.75 271.4 180 bottom
C5L8  1UF  [SMC0201IA]  163.57 271.4 90 bottom
C5L9  10uF  [SMC0402IA]  165.22 271.27 90 bottom
C5L10  10uF  [SMC0402IA]  164.33 271.27 90 bottom
C5L11  10uF  [SMC0402MC]  143.89 270.76 0 bottom
C5L12  1UF  [SMC0201IA]  164.71 270 0 bottom
C5L13  1UF  [SMC0201IA]  166.11 269.75 90 bottom
C5L14  1UF  [SMC0201IA]  167.89 269.11 270 bottom
C5L15  1UF  [SMC0201IA]  166.11 269.11 270 bottom
C5L16  1UF  [SMC0201IA]  164.71 268.86 0 bottom
C5L17  1UF  [SMC0201IA]  170.56 268.6 0 bottom
C5L18  1UF  [SMC0201IA]  170.56 267.97 0 bottom
C5L19  1UF  [SMC0201IA]  166.11 267.97 270 bottom
C5L20  1UF  [SMC0201IA]  163.57 267.97 180 bottom
C5L21  1UF  [SMC0201IA]  168.91 267.46 180 bottom
C5L22  1UF  [SMC0201IA]  170.56 267.33 0 bottom
C5L23  1UF  [SMC0201IA]  167.13 267.33 0 bottom
C5L24  1UF  [SMC0201IA]  165.48 267.33 180 bottom
C5L25  1UF  [SMC0201IA]  164.21 267.33 180 bottom
C5L26  22uF  [SMC0805IA]  137.66 266.95 180 bottom
C5L27  1UF  [SMC0201IA]  170.56 266.7 0 bottom
C5L28  1UF  [SMC0201IA]  166.11 266.32 90 bottom
C5L29  1UF  [SMC0201IA]  168.02 265.43 180 bottom
C5L30  1UF  [SMC0201IA]  164.71 265.43 0 bottom
C5L31  1UF  [SMC0201IA]  166.11 265.17 90 bottom
C5L32  1UF  [SMC0201IA]  168.78 264.79 0 bottom
C5L33  1UF  [SMC0201IA]  166.11 264.41 270 bottom
C5L34  1UF  [SMC0201IA]  167.38 264.16 270 bottom
C5L35  10uF  [SMC0402MC]  143.76 263.9 0 bottom
C5L36  1UF  [SMC0201IA]  164.71 263.02 0 bottom
C5M1  0.1uF  [SMC0402IA]  155.95 242.31 270 bottom
C5M2  680pF  [SMC0402IA]  168.78 241.3 270 bottom
C5M3  0.1uF  [SMC0603IA]  161.29 238.76 180 bottom
C5U1  680pF  [SMC0402IA]  152.01 91.95 0 bottom
C5W1  0.01uF  [SMC0402IA]  146.3 8.38 270 bottom
C5W2  0.01uF  [SMC0402IA]  145.41 8.38 270 bottom
C5W3  0.01uF  [SMC0402IA]  142.49 6.22 270 bottom
C5W4  0.01uF  [SMC0402IA]  141.6 6.22 270 bottom
C6A1  2200pF  [SMC0402IA]  104.52 286.64 180 top
C6A2  10uF  [SMC0402MC]  120.01 286.76 270 top
C6A3  10uF  [SMC0603IA]  118.11 286.51 270 top
C6A4  0.1uF  [SMC0402IA]  105.15 285.24 180 top
C6A5  10uF  [SMC0603IA]  110.23 284.99 0 top
C6A6  2.2UF  [SMC0402IA]  127.76 284.35 270 top
C6A7  0.1uF  [SMC0402IA]  108.96 283.34 180 top
C6A8  2.2UF  [SMC0402IA]  118.11 283.08 0 top
C6A9  2.2UF  [SMC0402IA]  129.03 282.57 0 top
C6A10  2200pF  [SMC0402IA]  113.03 282.45 0 top
C6A11  0.1uF  [SMC0402IA]  118.11 282.19 0 top
C6A12  10uF  [SMC0603IA]  108.83 281.43 180 top
C6A13  10uF  [SMC0603IA]  119.12 281.18 180 top
C6A14  2.2UF  [SMC0402IA]  129.03 280.8 0 top
C6A15  2.2UF  [SMC0402IA]  129.92 279.91 180 top
C6A16  10uF  [SMC0603IA]  119.12 279.14 180 top
C6A17  10uF  [SMC0603IA]  128.77 278.89 0 top
C6A18  0.1uF  [SMC0402IA]  118.99 278.13 180 top
C6A19  10uF  [SMC0603IA]  109.22 277.75 0 top
C6A20  10uF  [SMC0603IA]  128.77 277.62 0 top
C6A21  10uF  [SMC0603IA]  119.12 277.11 180 top
C6A22  10uF  [SMC0402IA]  101.98 276.6 270 top
C6A23  0.1uF  [SMC0402IA]  102.87 276.6 270 top
C6A24  2200pF  [SMC0402IA]  104.64 276.6 180 top
C6A25  0.1uF  [SMC0402IA]  129.03 276.6 0 top
C6A26  100pF  [SMC0402IA]  110.36 275.84 90 top
C6A27  10uF  [SMC0402MC]  129.03 275.33 0 top
C6A28  0.1uF  [SMC0402IA]  107.31 275.21 180 top
C6A29  0.1uF  [SMC0402IA]  123.31 273.56 180 top
C6A30  10uF  [SMC0603IA]  131.69 272.79 270 top
C6A31  10uF  [SMC0402MC]  123.31 272.54 180 top
C6A32  22pF  [SMC0603IA]  130.17 269.75 180 top
C6A33  1uF  [SMC0603IA]  137.28 263.02 270 top
C6A34  0.1uF  [SMC0402IA]  109.85 269.24 180 top
C6A35  22uF  [SMC0805IA]  109.47 267.33 180 top
C6A36  0.1uF  [SMC0402IA]  116.07 266.44 0 top
C6A37  22uF  [SMC0805IA]  109.47 265.56 180 top
C6A38  0.1uF  [SMC0402IA]  102.1 264.29 180 top
C6A39  4.7UF  [SMC0603IA]  109.34 264.03 180 top
C6A40  0.1uF  [SMC0402IA]  129.79 263.78 180 top
C6A41  0.1uF  [SMC0402IA]  102.1 263.4 180 top
C6A42  0.1uF  [SMC0402IA]  102.1 262.51 180 top
C6A43  22uF  [SMC0805IA]  122.3 261.87 90 top
C6A44  22uF  [SMC0805IA]  123.95 261.87 90 top
C6A45  22uF  [SMC0805IA]  125.6 261.87 90 top
C6A46  22uF  [SMC0805IA]  127.25 261.87 90 top
C6A47  0.1uF  [SMC0402IA]  102.1 261.62 180 top
C6A48  0.01uF  [SMC0402IA]  115.18 261.24 270 top
C6A49  0.1uF  [SMC0402IA]  112.77 260.35 90 top
C6A50  4700pF  [SMC0402MA]  113.53 260.35 0 top
C6B1  0.1uF  [SMC0402IA]  129.54 254.51 180 top
C6B2  1uF  [SMC0402IA]  129.54 253.62 180 top
C6B3  1uF  [SMC0402IA]  113.41 251.84 180 top
C6B4  470uF  [CPRC85_350MA]  132.81 247.39 270 top
C6B5  2200pF  [SMC0402IA]  122.17 240.03 180 top
C6B6  100uF  [CPRC63_250PMA]  129.28 238.63 90 top
C6B7  10uF  [SMC0603IA]  124.2 237.36 0 top
C6B8  0.1uF  [SMC0402IA]  119.76 236.98 270 top
C6B9  0.1uF  [SMC0402IA]  110.74 234.82 90 top
C6B10  220uF  [SMC7343_TANT_PMC]  113.91 234.69 90 top
C6C1  0.1uF  [SMC0402IA]  122.8 222.38 180 top
C6C2  0.1uF  [SMC0402IA]  122.8 221.49 180 top
C6C3  0.1uF  [SMC0402IA]  115.82 208.02 90 top
C6C4  10uF  [SMC0603IA]  116.84 207.77 90 top
C6C5  0.1uF  [SMC0402IA]  121.53 207.01 90 top
C6C6  100pF  [SMC0402IA]  123.06 207.01 90 top
C6C7  0.1uF  [SMC0402IA]  106.68 194 180 top
C6C8  1uF  [SMC0402IA]  107.56 194 0 top
C6C9  470uF  [CPRC68_250PMA]  131.31 200.89 0 top
C6C10  100pF  [SMC0402IA]  115.18 197.36 270 top
C6C11  0.1uF  [SMC0402IA]  122.8 197.36 270 top
C6C12  0.1uF  [SMC0402IA]  100.45 184.73 270 top
C6D1  0.33uF  [SMC1005MB]  126.23 189.74 90 top
C6D2  0.33uF  [SMC1005MB]  127.12 189.74 90 top
C6D3  0.33uF  [SMC1005MB]  117.98 189.61 90 top
C6D4  0.33uF  [SMC1005MB]  118.87 189.61 90 top
C6D5  0.1uF  [SMC0402IA]  110.41 183.89 180 top
C6D6  0.1uF  [SMC0402IA]  110.41 184.78 180 top
C6D7  0.1uF  [SMC0402IA]  108.96 197.56 180 top
C6D8  0.1uF  [SMC0402IA]  108.96 196.54 180 top
C6D9  0.1uF  [SMC0402IA]  120.65 188.47 90 top
C6D10  0.1uF  [SMC0402IA]  121.53 188.47 90 top
C6D11  0.1uF  [SMC0402IA]  123.82 188.47 90 top
C6D12  0.1uF  [SMC0402IA]  124.71 188.47 90 top
C6D13  0.1uF  [SMC0402IA]  129.41 188.09 90 top
C6D14  22uF  [SMC0603ID]  101.09 181.23 180 top
C6D15  22uF  [SMC0603ID]  101.09 182.62 180 top
C6D16  0.1uF  [SMC0402IA]  128.65 180.08 180 top
C6D17  0.1uF  [SMC0402IA]  132.96 178.56 270 top
C6D18  0.1uF  [SMC0402IA]  131.19 177.67 90 top
C6D19  0.1uF  [SMC0402IA]  132.08 177.67 90 top
C6D20  0.1uF  [SMC0402IA]  133.85 177.67 90 top
C6D21  18pF  [SMC0402IA]  108.45 174.75 180 top
C6D22  18pF  [SMC0402IA]  109.34 174.75 0 top
C6D23  0.1uF  [SMC0402IA]  112.9 170.31 0 top
C6D24  22uF  [SMC0603ID]  107.56 170.05 0 top
C6D25  22uF  [SMC0603ID]  107.56 168.65 0 top
C6D26  0.1uF  [SMC0402IA]  103.88 165.73 90 top
C6D27  0.1uF  [SMC0402IA]  114.5 164.46 45 top
C6E1  0.1uF  [SMC0402IA]  127.5 154.68 0 top
C6E2  0.1uF  [SMC0402IA]  125.47 148.97 0 top
C6E3  1uF  [SMC0402IA]  122.04 143.25 135 top
C6E4  22uF  [SMC0805MA]  130.17 139.44 0 top
C6E5  0.1uF  [SMC0402IA]  126.14 139.18 315 top
C6E6  0.1uF  [SMC0402IA]  122.3 137.79 270 top
C6E7  1uF  [SMC0402IA]  123.19 137.79 270 top
C6E8  0.1uF  [SMC0402IA]  123.57 134.36 0 top
C6F1  1uF  [SMC0402IA]  114.68 129.67 0 top
C6F2  0.1uF  [SMC0402IA]  101.98 128.52 90 top
C6F3  22uF  [SMC0603ID]  115.69 117.98 180 top
C6F4  22uF  [SMC0603ID]  115.69 116.58 180 top
C6F5  1uF  [SMC0603IA]  132.2 99.44 90 top
C6F6  22uF  [SMC0805MA]  133.9 99.35 90 top
C6G1  0.01uF  [SMC0402IA]  110.61 85.09 270 top
C6G2  0.01uF  [SMC0402IA]  111.5 85.09 270 top
C6G3  0.01uF  [SMC0402IA]  106.8 82.93 90 top
C6G4  0.01uF  [SMC0402IA]  107.95 82.93 90 top
C6G5  0.01uF  [SMC0402IA]  110.74 73.91 270 top
C6G6  0.01uF  [SMC0402IA]  111.63 73.91 270 top
C6G7  0.01uF  [SMC0402IA]  106.93 72.26 270 top
C6G8  0.01uF  [SMC0402IA]  107.95 72.26 270 top
C6G9  0.01uF  [SMC0402IA]  128.9 72.13 270 top
C6G10  0.01uF  [SMC0402IA]  130.42 72.13 270 top
C6G11  0.01uF  [SMC0402IA]  124.96 70.23 270 top
C6G12  0.01uF  [SMC0402IA]  126.49 70.23 270 top
C6J1  2200pF  [SMC0402IA]  104.26 8.38 180 top
C6J2  22uF  [SMC0805IA]  109.72 7.62 270 top
C6J3  10uF  [SMC0603IA]  106.55 5.84 0 top
C6J4  0.1uF  [SMC0402IA]  103.75 4.57 270 top
C6L1  10pF  [SMC0402IA]  127.5 270.38 0 bottom
C6L2  10pF  [SMC0402IA]  127.5 269.49 0 bottom
C6L3  0.1uF  [SMC0402IA]  98.04 262.13 180 bottom
C6L4  0.1uF  [SMC0402IA]  98.04 261.24 180 bottom
C6L5  0.1uF  [SMC0402IA]  98.04 260.35 180 bottom
C6M1  0.1uF  [SMC0402IA]  98.04 259.46 180 bottom
C6M2  22uF  [SMC0603ID]  97.79 256.79 90 bottom
C6R1  0.01uF  [SMC0402IA]  115.57 159.13 270 bottom
C6R2  1000pF  [SMC0402IA]  100.83 141.86 90 bottom
C6R3  1000pF  [SMC0402IA]  99.31 134.87 90 bottom
C6R4  1000pF  [SMC0402IA]  97.86 132.08 180 bottom
C6W1  100uF  [SMC1206IA]  122.04 7.11 270 bottom
C6W2  0.1uF  [SMC0402IA]  124.71 5.97 270 bottom
C6W3  0.1uF  [SMC0402IA]  123.82 5.97 270 bottom
C7A1  470pF  [SMC0402IA]  64.38 285.37 180 top
C7A2  470pF  [SMC0402IA]  63.5 283.21 0 top
C7A3  470pF  [SMC0402IA]  88.9 276.73 0 top
C7A4  470pF  [SMC0402IA]  89.78 274.95 180 top
C7A5  68pF  [SMC0402IA]  88.9 273.18 0 top
C7A6  68pF  [SMC0402IA]  88.9 272.29 0 top
C7A7  20pF  [SMC0402IA]  93.72 270 270 top
C7A8  20pF  [SMC0402IA]  90.55 266.57 0 top
C7A9  68pF  [SMC0402IA]  69.34 263.14 270 top
C7A10  68pF  [SMC0402IA]  70.61 263.14 270 top
C7A11  0.1uF  [SMC0402IA]  72.51 261.49 180 top
C7B1  0.1uF  [SMC0402IA]  69.34 260.35 90 top
C7B2  100uF  [CPRC63_250PMA]  79.62 254.89 90 top
C7B3  0.1uF  [SMC0402IA]  68.83 252.98 180 top
C7B4  22uF  [SMC0603ID]  91.69 250.59 270 top
C7B5  22uF  [SMC0603ID]  92.96 249.81 0 top
C7B6  0.1uF  [SMC0603IA]  66.16 247.01 0 top
C7B7  10uF  [SMC0603IA]  78.74 247.78 90 top
C7B8  10uF  [SMC0603IA]  80.01 247.78 90 top
C7B9  0.1uF  [SMC0603IA]  81.4 247.78 90 top
C7B10  0.1uF  [SMC0402IA]  79.24 246 0 top
C7B11  0.01uF  [SMC0402IA]  79.24 245.11 0 top
C7B12  0.01uF  [SMC0402IA]  79.24 244.22 0 top
C7B13  2.2UF  [SMC0402IA]  91.05 241.55 270 top
C7B14  0.1uF  [SMC0402IA]  95.75 237.36 0 top
C7B15  0.1uF  [SMC0402IA]  85.09 235.46 180 top
C7B16  0.22uF  [SMC0402IA]  80.13 232.79 180 top
C7B17  0.22uF  [SMC0402IA]  80.13 231.65 180 top
C7C1  0.1uF  [SMC0402IA]  79.24 226.57 0 top
C7C2  0.1uF  [SMC0402IA]  92.45 225.8 0 top
C7C3  10uF  [SMC0603IA]  79.24 225.3 0 top
C7C4  10uF  [SMC0603IA]  79.24 224.03 0 top
C7C5  0.1uF  [SMC0402IA]  95.75 223.65 180 top
C7C6  0.01uF  [SMC0402IA]  79.24 223.01 0 top
C7C7  0.01uF  [SMC0402IA]  79.24 222.12 0 top
C7C8  470uF  [CPRC68_250PMA]  83.31 216.79 270 top
C7C9  4.7UF  [SMC0603IA]  78.48 213.36 180 top
C7C10  470pF  [SMC0402IA]  78.1 211.33 180 top
C7D2  1000pF  [SMC0402IA]  81.91 175.39 0 top
C7D4  1uF  [SMC0402IA]  94.48 169.42 90 top
C7D5  0.1uF  [SMC0402IA]  68.07 165.94 180 top
C7E1  1uF  [SMC0603IA]  82.67 161.03 180 top
C7E2  4.7UF  [SMC0603IA]  86.86 160.53 90 top
C7E3  1uF  [SMC0402IA]  82.67 159.76 180 top
C7E4  4.7UF  [SMC0603IA]  82.67 158.49 180 top
C7E5  5pF  [SMC0402IA]  71.62 154.81 0 top
C7E6  5pF  [SMC0402IA]  74.93 154.81 180 top
C7E7  5pF  [SMC0402IA]  74.93 153.8 180 top
C7E8  0.1uF  [SMC0402IA]  61.84 153.03 180 top
C7E9  27pF  [SMC0402IA]  82.67 152.65 180 top
C7E10  0.1uF  [SMC0402IA]  83.31 151.38 180 top
C7E11  1uF  [SMC0402IA]  70.61 145.29 180 top
C7E12  0.1uF  [SMC0402IA]  67.81 145.16 180 top
C7E13  1uF  [SMC0402IA]  70.61 144.4 180 top
C7E14  0.33uF  [SMC1005MB]  80.13 134.87 180 top
C7E15  1uF  [SMC0402IA]  86.23 133.6 270 top
C7E16  1uF  [SMC0402IA]  87.12 133.6 270 top
C7E17  1uF  [SMC0402IA]  85.85 130.81 270 top
C7E18  0.1uF  [SMC0402IA]  86.74 130.81 270 top
C7F1  0.33uF  [SMC1005MB]  74.42 129.79 90 top
C7F2  0.1uF  [SMC0402IA]  96.77 129.67 90 top
C7F3  1000pF  [SMC0402IA]  79.5 125.35 180 top
C7F4  0.1uF  [SMC0402IA]  91.69 124.97 90 top
C7F5  18pF  [SMC0402IA]  77.47 122.68 180 top
C7F6  18pF  [SMC0402IA]  78.74 122.68 0 top
C7F7  1uF  [SMC0402IA]  81.66 115.82 270 top
C7F8  0.33uF  [SMC1005MB]  88.77 114.93 90 top
C7F9  0.1uF  [SMC0402IA]  70.1 111.76 180 top
C7F10  100uF  [SMC1206IA]  62.48 100.71 270 top
C7G1  0.22uF  [SMC0402IA]  82.67 93.98 0 top
C7G2  0.1uF  [SMC0402IA]  82.67 88.9 0 top
C7G3  22uF  [SMC0805IA]  61.21 87.63 0 top
C7G4  22uF  [SMC0805IA]  61.21 85.98 0 top
C7G5  0.1uF  [SMC0402IA]  82.16 82.17 0 top
C7G6  0.1uF  [SMC0402IA]  67.05 80.01 180 top
C7G7  1uF  [SMC0402IA]  86.61 77.21 270 top
C7G8  0.1uF  [SMC0402IA]  87.5 77.21 270 top
C7G9  0.1uF  [SMC0402IA]  92.32 75.94 0 top
C7G10  0.1uF  [SMC0402IA]  92.32 75.06 0 top
C7G11  0.1uF  [SMC0402IA]  83.56 74.55 180 top
C7G12  0.1uF  [SMC0402IA]  68.32 74.04 180 top
C7G13  0.1uF  [SMC0402IA]  83.56 73.66 180 top
C7H1  0.1uF  [SMC0402IA]  74.8 55.37 180 top
C7H2  0.1uF  [SMC0402IA]  77.59 54.35 180 top
C7H3  0.1uF  [SMC0402IA]  96.9 53.08 270 top
C7H4  0.1uF  [SMC0603IA]  64.64 49.02 90 top
C7H5  0.1uF  [SMC0402IA]  61.59 48.39 270 top
C7H6  1uF  [SMC0402IA]  80.51 42.67 180 top
C7H7  1uF  [SMC0402IA]  85.85 42.67 180 top
C7H8  0.1uF  [SMC0402IA]  66.92 38.73 180 top
C7H9  0.1uF  [SMC0402IA]  81.66 36.57 90 top
C7H10  0.1uF  [SMC0402IA]  82.8 36.57 90 top
C7H11  0.01uF  [SMC0402IA]  63.75 36.32 0 top
C7J1  0.01uF  [SMC0402IA]  63.75 30.73 0 top
C7J2  470pF  [SMC0402IA]  74.04 29.59 0 top
C7J3  0.1uF  [SMC0402IA]  64.64 27.3 180 top
C7J4  470pF  [SMC0402IA]  68.45 25.53 270 top
C7J5  470pF  [SMC0402IA]  69.72 25.53 270 top
C7J6  470pF  [SMC0402IA]  70.99 25.53 270 top
C7J7  470pF  [SMC0402IA]  77.97 22.48 90 top
C7J8  1uF  [SMC0603IA]  79.5 22.22 90 top
C7L1  0.1uF  [SMC0402IA]  92.71 265.05 270 bottom
C7L2  10uF  [SMC0402IA]  94.48 263.65 270 bottom
C7L3  0.1uF  [SMC0402IA]  93.59 263.65 270 bottom
C7L4  22uF  [SMC0603ID]  95.5 263.52 270 bottom
C7L5  22uF  [SMC0603ID]  91.18 263.14 0 bottom
C7L6  0.1uF  [SMC0402IA]  91.05 262.13 0 bottom
C7L7  0.1uF  [SMC0402IA]  91.05 261.24 0 bottom
C7L8  0.1uF  [SMC0402IA]  91.05 260.35 0 bottom
C7M1  22uF  [SMC0603ID]  91.18 259.33 0 bottom
C7M2  0.1uF  [SMC0402IA]  91.18 258.32 0 bottom
C7M3  10uF  [SMC0402IA]  91.18 257.43 0 bottom
C7M4  0.1uF  [SMC0402IA]  96.77 256.67 90 bottom
C7M5  10uF  [SMC0402IA]  94.99 256.67 90 bottom
C7M6  0.1uF  [SMC0402IA]  94.1 256.67 90 bottom
C7M7  10uF  [SMC0402IA]  93.21 256.67 90 bottom
C7M8  0.1uF  [SMC0402IA]  91.18 256.54 0 bottom
C7R1  27pF  [SMC0402IA]  87.5 154.68 0 bottom
C7R2  1000pF  [SMC0402IA]  86.48 132.97 180 bottom
C7R3  27pF  [SMC0402IA]  82.55 132.84 45 bottom
C7R4  27pF  [SMC0402IA]  74.54 132.46 180 bottom
C7R5  27pF  [SMC0402IA]  82.42 131.44 180 bottom
C7R6  1000pF  [SMC0402IA]  84.83 131.19 90 bottom
C7R7  27pF  [SMC0402IA]  82.42 130.55 180 bottom
C7R8  27pF  [SMC0402IA]  78.74 130.55 90 bottom
C7R9  1uF  [SMC0402IA]  89.15 129.92 180 bottom
C7R10  1uF  [SMC0402IA]  82.67 160.27 180 bottom
C7T1  0.33uF  [SMC1005MB]  88.77 118.24 270 bottom
C7U1  27pF  [SMC0402IA]  89.53 92.96 90 bottom
C7U2  0.1uF  [SMC0402IA]  73.27 89.03 90 bottom
C7U3  0.1uF  [SMC0402IA]  72.51 82.55 180 bottom
C7W1  0.1uF  [SMC0402IA]  96.13 26.92 90 bottom
C7W2  0.1uF  [SMC0402IA]  88.51 26.67 0 bottom
C8A1  10uF  [SMC0603IA]  30.22 284.35 90 top
C8A2  0.1uF  [SMC0402IA]  33.4 284.35 90 top
C8A3  2200pF  [SMC0402IA]  32.63 279.78 270 top
C8A4  0.1uF  [SMC0402IA]  25.27 270.64 0 top
C8A5  0.1uF  [SMC0402IA]  26.54 267.46 0 top
C8B1  5pF  [SMC0402IA]  25.14 258.7 0 top
C8B2  1uF  [SMC0402IA]  57.65 256.92 90 top
C8B3  5pF  [SMC0402IA]  26.28 256.67 270 top
C8B4  0.1uF  [SMC0402IA]  31.75 254.89 270 top
C8B5  5pF  [SMC0402IA]  25.4 253.87 0 top
C8B6  0.1uF  [SMC0402IA]  29.33 252.73 0 top
C8B7  0.1uF  [SMC0603IA]  34.79 250.82 90 top
C8B8  0.1uF  [SMC0603IA]  36.06 250.82 90 top
C8B9  470uF  [CPRC85_350MA]  32.13 247.39 270 top
C8B10  470uF  [CPRC85_350MA]  48.16 247.39 90 top
C8B11  0.1uF  [SMC0402IA]  24.76 245.11 0 top
C8B12  0.1uF  [SMC0603IA]  45.97 243.46 270 top
C8B13  0.1uF  [SMC0603IA]  53.34 243.08 270 top
C8B14  0.1uF  [SMC0603IA]  54.73 243.08 270 top
C8B15  0.1uF  [SMC0402IA]  33.78 240.54 90 top
C8B16  0.1uF  [SMC0402IA]  34.67 240.54 90 top
C8B17  0.1uF  [SMC0402IA]  54.22 238.76 270 top
C8B18  0.1uF  [SMC0402IA]  55.11 238.76 270 top
C8B19  100uF  [CPRC63_250PMA]  28.32 238.63 90 top
C8B20  100uF  [CPRC63_250PMA]  48.76 238.63 90 top
C8B21  0.1uF  [SMC0402IA]  33.78 236.47 90 top
C8B22  0.1uF  [SMC0402IA]  34.67 236.47 90 top
C8B23  0.1uF  [SMC0402IA]  54.22 236.47 270 top
C8B24  0.1uF  [SMC0402IA]  55.11 236.47 270 top
C8B25  0.1uF  [SMC0402IA]  24.63 236.22 0 top
C8B26  2200pF  [SMC0402IA]  27.55 233.04 90 top
C8B27  2200pF  [SMC0402IA]  49.78 232.66 90 top
C8B28  0.22uF  [SMC0402IA]  46.6 232.28 180 top
C8B29  0.22uF  [SMC0402IA]  54.22 232.28 0 top
C8B30  0.22uF  [SMC0402IA]  46.6 231.14 180 top
C8B31  0.22uF  [SMC0402IA]  54.22 231.14 0 top
C8B32  1uF  [SMC0402IA]  26.77 230.12 90 top
C8B33  10uF  [SMC0603IA]  30.86 230 90 top
C8B34  0.1uF  [SMC0402IA]  49.27 229.87 90 top
C8B35  2200pF  [SMC0402IA]  31.62 228.22 270 top
C8B36  10uF  [SMC0603IA]  51.94 227.96 270 top
C8B37  0.22uF  [SMC0402IA]  46.6 227.71 180 top
C8B38  0.22uF  [SMC0402IA]  54.22 227.71 0 top
C8C1  0.22uF  [SMC0402IA]  46.6 226.57 180 top
C8C2  0.22uF  [SMC0402IA]  54.22 226.57 0 top
C8C3  0.1uF  [SMC0402IA]  34.29 225.68 180 top
C8C4  1uF  [SMC0402IA]  28.95 225.3 270 top
C8C5  0.1uF  [SMC0402IA]  34.29 224.79 180 top
C8C6  10uF  [SMC0603IA]  34.54 223.65 180 top
C8C7  0.22uF  [SMC0402IA]  46.6 223.14 180 top
C8C8  0.22uF  [SMC0402IA]  54.22 223.14 0 top
C8C9  0.1uF  [SMC0402IA]  25.78 222.63 180 top
C8C10  0.22uF  [SMC0402IA]  46.6 221.99 180 top
C8C11  0.22uF  [SMC0402IA]  54.22 221.99 0 top
C8C12  0.22uF  [SMC0402IA]  46.6 218.57 180 top
C8C13  0.22uF  [SMC0402IA]  54.22 218.57 0 top
C8C14  0.22uF  [SMC0402IA]  46.6 217.42 180 top
C8C15  0.22uF  [SMC0402IA]  54.22 217.42 0 top
C8C16  0.1uF  [SMC0402IA]  32.25 210.56 180 top
C8C17  0.1uF  [SMC0402IA]  41.4 208.28 0 top
C8C18  1uF  [SMC0402IA]  36.83 204.85 180 top
C8C19  1uF  [SMC0402IA]  31.24 201.8 180 top
C8C20  0.1uF  [SMC0402IA]  38.86 201.04 90 top
C8C21  0.1uF  [SMC0402IA]  33.65 200.66 180 top
C8C22  10uF  [SMC0603IA]  28.44 199.01 180 top
C8C23  2.2UF  [SMC0402IA]  51.66 198.5 90 top
C8C24  2.2UF  [SMC0402IA]  52.83 198.5 90 top
C8C25  0.1uF  [SMC0402IA]  28.32 197.74 180 top
C8C26  0.1uF  [SMC0402IA]  35.05 197.74 0 top
C8C27  2200pF  [SMC0402IA]  24.76 195.32 0 top
C8C28  220pF  [SMC0402IA]  48.76 195.32 270 top
C8D1  0.1uF  [SMC0402IA]  40.13 194.44 90 top
C8D2  0.1uF  [SMC0402IA]  33.14 189.36 270 top
C8D3  0.1uF  [SMC0402IA]  34.29 189.36 270 top
C8D4  0.1uF  [SMC0402IA]  37.71 189.36 270 top
C8D5  0.1uF  [SMC0402IA]  47.37 188.59 180 top
C8D6  1uF  [SMC0402IA]  47.37 187.45 180 top
C8D7  1uF  [SMC0402IA]  43.3 186.94 0 top
C8D8  1uF  [SMC0402IA]  40.89 186.75 270 top
C8D9  0.1uF  [SMC0402IA]  29.46 186.05 90 top
C8D10  1uF  [SMC0402MA]  30.98 186.05 0 top
C8D11  2.2UF  [SMC0402IA]  33.4 186.05 0 top
C8D12  10uF  [SMC0603IA]  27.43 185.8 90 top
C8D13  1000pF  [SMC0603IA]  37.33 184.91 180 top
C8D14  2.2UF  [SMC0402IA]  42.03 184.91 90 top
C8D16  2200pF  [SMC0402IA]  28.19 181.23 180 top
C8D17  0.01uF  [SMC0402IA]  49.02 181.1 0 top
C8D19  1000pF  [SMC0603IA]  29.71 180.08 90 top
C8D22  0.1uF  [SMC0402IA]  43.81 175.89 90 top
C8D23  100pF  [SMC0402IA]  40.64 173.99 90 top
C8D25  0.1uF  [SMC0402IA]  26.79 173.1 180 top
C8D27  0.1uF  [SMC0402IA]  35.56 172.46 90 top
C8D28  0.1uF  [SMC0402IA]  47.37 170.43 180 top
C8D29  0.1uF  [SMC0402IA]  37.46 169.8 270 top
C8D30  0.1uF  [SMC0402IA]  41.65 169.04 0 top
C8D31  0.01uF  [SMC0402IA]  33.9 166.37 180 top
C8D32  10uF  [SMC0603IA]  46.05 163.44 90 top
C8D33  ý6  [SMC0805MA]  49.98 162.55 270 top
C8D34  22uF  [SMC0805MA]  51.89 162.55 270 top
C8D35  0.1uF  [SMC0402IA]  29.33 162.3 270 top
C8E1  0.1uF  [SMC0402IA]  46.05 161.92 270 top
C8E2  10uF  [SMC0603IA]  45.99 154.3 90 top
C8E3  22uF  [SMC0805MA]  49.93 153.41 270 top
C8E4  22uF  [SMC0805MA]  51.84 153.41 270 top
C8E5  0.1uF  [SMC0402IA]  45.99 152.77 270 top
C8E6  10uF  [SMC0603IA]  46.02 145.15 90 top
C8E7  22uF  [SMC0805MA]  49.96 144.26 270 top
C8E8  22uF  [SMC0805MA]  51.86 144.26 270 top
C8E9  0.1uF  [SMC0402IA]  46.02 143.63 270 top
C8E10  0.1uF  [SMC0402IA]  24.89 142.37 0 top
C8E11  10uF  [SMC0603IA]  45.99 135.86 90 top
C8E12  22uF  [SMC0805MA]  49.93 134.97 270 top
C8E13  22uF  [SMC0805MA]  51.84 134.97 270 top
C8E14  0.1uF  [SMC0402IA]  45.99 134.33 270 top
C8E15  0.1uF  [SMC0402IA]  26.54 133.22 90 top
C8E16  0.1uF  [SMC0402IA]  30.09 133.22 90 top
C8E17  0.1uF  [SMC0402IA]  33.65 133.22 90 top
C8E18  47pF  [SMC0402IA]  35.56 133.22 90 top
C8E19  33pF  [SMC0402IA]  42.03 132.46 180 top
C8F1  33pF  [SMC0402IA]  42.03 127.13 180 top
C8F2  0.1uF  [SMC0402IA]  25.14 127 90 top
C8F3  10uF  [SMC0603IA]  45.97 126.97 90 top
C8F4  22uF  [SMC0805MA]  49.91 126.08 270 top
C8F5  22uF  [SMC0805MA]  51.81 126.08 270 top
C8F6  0.1uF  [SMC0402IA]  45.97 125.44 270 top
C8F7  0.1uF  [SMC0402IA]  25.27 117.73 180 top
C8F8  0.1uF  [SMC0402IA]  27.17 111.38 90 top
C8F9  0.1uF  [SMC0402IA]  40.13 109.83 180 top
C8F10  0.1uF  [SMC0402IA]  28.32 108.96 90 top
C8F11  0.1uF  [SMC0402IA]  30.73 108.96 90 top
C8F12  22uF  [SMC0805IA]  56.64 105.41 90 top
C8F13  22uF  [SMC0805IA]  58.29 105.41 90 top
C8F14  1uF  [SMC0402IA]  52.7 104.65 180 top
C8F15  10pF  [SMC0402IA]  38.35 104.14 0 top
C8F16  22pF  [SMC0402IB]  46.22 103.63 0 top
C8F17  10pF  [SMC0402IA]  38.35 102.87 0 top
C8F18  0.1uF  [SMC0402IA]  35.68 101.6 0 top
C8F19  0.1uF  [SMC0402IA]  35.68 100.46 0 top
C8F20  0.1uF  [SMC0402IA]  35.68 98.42 0 top
C8F21  1uF  [SMC0402IA]  49.91 98.17 0 top
C8F22  2.2UF  [SMC0402IA]  46.99 122.66 270 top
C8G1  10uF  [SMC0603IA]  49.4 97.15 0 top
C8G2  100pF  [SMC0402IA]  41.02 96.65 0 top
C8G3  0.1uF  [SMC0402IA]  35.68 94.23 0 top
C8G4  100pF  [SMC0402IA]  39.37 93.09 180 top
C8G5  22pF  [SMC0402IB]  49.65 90.17 0 top
C8G6  0.1uF  [SMC0402IA]  26.41 88.01 270 top
C8G7  0.1uF  [SMC0402IA]  32.25 88.01 270 top
C8G8  1uF  [SMC0402IA]  50.54 86.99 180 top
C8G9  10uF  [SMC0603IA]  52.07 85.6 0 top
C8G10  100uF  [SMC1206IA]  60.19 84.07 0 top
C8G11  0.1uF  [SMC0402IA]  45.21 80.52 0 top
C8G12  0.1uF  [SMC0402IA]  33.14 78.87 0 top
C8G13  0.1uF  [SMC0402IA]  31.87 71.88 180 top
C8G14  0.1uF  [SMC0402IA]  49.78 69.85 90 top
C8G15  10uF  [SMC0603IA]  47.87 69.59 90 top
C8G16  0.1uF  [SMC0402IA]  31.75 69.34 180 top
C8G17  10uF  [SMC0603IA]  40 65.78 90 top
C8G18  10uF  [SMC0603IA]  41.52 65.78 90 top
C8G19  0.01uF  [SMC0402IA]  25.4 65.66 90 top
C8G20  0.01uF  [SMC0402IA]  38.73 65.66 90 top
C8G21  2200pF  [SMC0402IA]  49.65 65.15 270 top
C8G22  0.01uF  [SMC0402IA]  45.21 65.02 90 top
C8H1  10uF  [SMC0603IA]  46.35 64.77 90 top
C8H2  0.1uF  [SMC0402IA]  54.1 64.01 0 top
C8H3  0.1uF  [SMC0402IA]  54.1 63.12 0 top
C8H4  0.1uF  [SMC0402IA]  45.84 61.72 270 top
C8H5  0.01uF  [SMC0402IA]  47.11 61.72 270 top
C8H6  0.1uF  [SMC0402IA]  48.38 61.72 270 top
C8H7  0.1uF  [SMC0402IA]  53.34 53.47 0 top
C8H8  0.1uF  [SMC0402IA]  53.34 52.58 0 top
C8H9  0.22uF  [SMC0402IA]  29.46 52.07 90 top
C8H10  0.22uF  [SMC0402IA]  30.35 52.07 90 top
C8H11  0.22uF  [SMC0402IA]  32.89 52.07 90 top
C8H12  0.22uF  [SMC0402IA]  33.78 52.07 90 top
C8H13  0.22uF  [SMC0402IA]  36.32 52.07 90 top
C8H14  0.22uF  [SMC0402IA]  37.21 52.07 90 top
C8H15  0.22uF  [SMC0402IA]  39.87 52.07 90 top
C8H16  0.22uF  [SMC0402IA]  40.76 52.07 90 top
C8H17  0.1uF  [SMC0402IA]  55.88 48.13 270 top
C8H18  0.33uF  [SMC1005MB]  45.33 45.97 180 top
C8H19  0.33uF  [SMC1005MB]  45.33 44.7 180 top
C8H20  0.33uF  [SMC1005MB]  45.33 43.43 180 top
C8H21  0.33uF  [SMC1005MB]  45.33 42.04 180 top
C8H22  0.33uF  [SMC1005MB]  45.33 40.64 180 top
C8H23  470pF  [SMC0603IA]  26.67 33.91 90 top
C8H24  470pF  [SMC0603IA]  30.09 33.91 90 top
C8H25  0.01uF  [SMC0402IA]  53.97 33.78 180 top
C8J1  0.01uF  [SMC0402IA]  54.48 28.19 180 top
C8L1  0.1uF  [SMC0402IA]  38.35 267.59 270 bottom
C8L2  0.1uF  [SMC0402IA]  39.37 267.59 270 bottom
C8L3  10uF  [SMC0603IA]  37.21 267.33 270 bottom
C8L4  0.1uF  [SMC0402IA]  60.7 264.54 0 bottom
C8N1  0.1uF  [SMC0402IA]  30.22 208.53 270 bottom
C9A1  0.1uF  [SMC0402IA]  10.16 269.11 0 top
C9A2  0.1uF  [SMC0402IA]  10.16 264.03 0 top
C9A3  0.1uF  [SMC0402IA]  10.16 260.86 0 top
C9B1  0.1uF  [SMC0402IA]  10.16 254.51 0 top
C9B2  33pF  [SMC0402IA]  12.7 253.49 90 top
C9B3  33pF  [SMC0402IA]  12.7 251.2 270 top
C9B4  0.1uF  [SMC0402IA]  12.31 232.15 90 top
C9C1  0.1uF  [SMC0603IA]  10.66 220.98 270 top
C9C2  0.1uF  [SMC0603IA]  11.93 220.98 270 top
C9C3  0.1uF  [SMC0603IA]  13.2 220.98 270 top
C9C4  0.1uF  [SMC0603IA]  14.45 220.98 270 top
C9C5  0.1uF  [SMC0603IA]  11.17 213.36 0 top
C9C6  0.01uF  [SMC0603IA]  14.22 213.36 0 top
C9C7  0.1uF  [SMC0402IA]  23.11 206.75 270 top
C9C8  10uF  [SMC0603IA]  22.96 196.49 270 top
C9C9  0.1uF  [SMC0402IA]  21.81 196.37 270 top
C9D1  5pF  [SMC0402IA]  24.51 189.99 180 top
C9D2  5pF  [SMC0402IA]  24.51 188.72 180 top
C9D3  47pF  [SMC0402IA]  12.44 186.43 0 top
C9D4  47pF  [SMC0402IA]  12.44 183.01 0 top
C9D5  47pF  [SMC0402IA]  17.27 180.08 0 top
C9D6  0.1uF  [SMC0402IA]  13.71 179.2 0 top
C9D7  4.7uF  [SMC0402IA]  13.71 178.18 0 top
C9D8  47pF  [SMC0402IA]  12.82 174.88 180 top
C9D9  47pF  [SMC0402IA]  12.82 173.86 180 top
C9E1  0.1uF  [SMC0402IA]  17.14 147.57 180 top
C9E2  0.1uF  [SMC0402IA]  14.73 136.02 0 top
C9E3  0.1uF  [SMC0402IA]  14.73 134.87 0 top
C9F1  0.1uF  [SMC0402IA]  18.03 113.79 90 top
C9F2  0.1uF  [SMC0402IA]  22.86 108.96 90 top
C9F3  1uF  [SMC0402IA]  23.74 108.96 90 top
C9F4  0.1uF  [SMC0402IA]  15.36 99.95 180 top
C9G1  0.1uF  [SMC0402IA]  15.11 88.01 270 top
C9G2  0.1uF  [SMC0402IA]  16 88.01 270 top
C9G3  1000pF  [SMC0402IA]  23.13 88.01 270 top
C9G4  2.2UF  [SMC0402IA]  11.81 79.88 180 top
C9G5  1000pF  [SMC0603IA]  16.63 73.91 270 top
C9G6  470pF  [SMC0402IA]  11.55 68.58 0 top
C9G7  470pF  [SMC0402IA]  11.55 67.44 0 top
C9G8  470pF  [SMC0402IA]  11.55 66.29 0 top
C9G9  0.01uF  [SMC0402IA]  23.62 65.66 90 top
C9G10  0.1uF  [SMC0402IA]  24.51 65.66 90 top
CP9H1  470PF  [SCCA8_32X16MA]  11.17 64.51 0 top
CR1B1  BAT54C  [SOT23MA]  290.7 253.24 180 top
CR1B2  PMEG4010ER  [SCR28X19MA]  284.35 244.6 90 top
CR1B3  PMEG4010ER  [SCR28X19MA]  286.63 241.93 90 top
CR2A1  -  [TK0_LCC10_1050X2550_500_MA]  246.12 279.14 90 top
CR2A2  BAT54A  [SOT23MJ]  250.57 277.75 270 top
CR2A3  BAT54A  [SOT23MJ]  277.11 270.64 180 top
CR2A4  1N5819HW  [SOD123MA]  276.47 263.78 180 top
CR3A1  BAT54C  [SOT23MA]  231.39 286.26 270 top
CR3A2  -  [TK0_LCC10_1050X2550_500_MA]  238.76 279.14 90 top
CR3A3  20KV  [SCR0603ME]  224.02 267.71 180 top
CR3A4  20KV  [SCR0603ME]  224.53 267.71 0 top
CR3A5  20KV  [SCR0603ME]  226.69 267.71 180 top
CR3A6  20KV  [SCR0603ME]  227.2 267.71 0 top
CR3A7  20KV  [SCR0603ME]  211.58 267.59 180 top
CR3A8  20KV  [SCR0603ME]  213.86 267.59 180 top
CR3A9  20KV  [SCR0603ME]  214.37 267.59 0 top
CR3A10  20KV  [SCR0603ME]  212.09 267.59 0 top
CR4A1  PESD5V0H1BSF  [SOD962MA]  172.84 282.46 180 top
CR4A2  PESD5V0H1BSF  [SOD962MA]  173.48 282.46 0 top
CR4A3  PESD5V0H1BSF  [SOD962MA]  175 282.46 180 top
CR4A4  PESD5V0H1BSF  [SOD962MA]  175.64 282.46 0 top
CR4A5  PESD5V0H1BSF  [SOD962MA]  170.81 281.83 180 top
CR4A6  PESD5V0H1BSF  [SOD962MA]  171.57 281.83 0 top
CR4A7  BAT54C  [SOT23MA]  202.31 275.21 90 top
CR4A8  20KV  [SCR0603ME]  202.18 273.05 90 top
CR4A9  20KV  [SCR0603ME]  202.18 272.54 270 top
CR4A10  20KV  [SCR0603ME]  202.18 270.64 90 top
CR4A11  20KV  [SCR0603ME]  202.18 270.13 270 top
CR4J1  1N5819HW  [SOD123MA]  174.87 4.19 180 top
CR4L1  PESD5V0H1BSF  [SOD962MA]  175.76 279.78 0 bottom
CR4L2  PESD5V0H1BSF  [SOD962MA]  173.99 279.91 90 bottom
CR5A1  PESD5V0H1BSF  [SOD962MA]  167.76 282.46 180 top
CR5A2  PESD5V0H1BSF  [SOD962MA]  168.4 282.46 0 top
CR5A3  20KV  [SCR0603ME]  164.46 282.19 0 top
CR5A4  20KV  [SCR0603ME]  165.73 282.19 180 top
CR5A5  PESD5V0H1BSF  [SOD962MA]  168.91 281.19 180 top
CR5A6  PESD5V0H1BSF  [SOD962MA]  169.54 281.19 0 top
CR5A7  30V  [SOD123IB]  153.67 260.35 90 top
CR5B1  30V  [SOD123IB]  143 255.78 0 top
CR5B2  PMEG4010ER  [SCR28X19MA]  158.11 249.17 90 top
CR5B3  PMEG4010ER  [SCR28X19MA]  160.14 249.68 0 top
CR5C1  1N5819HW  [SOD123MA]  159.51 213.1 180 top
CR5E1  BAT54C  [SOT23MA]  152.27 148.33 270 top
CR6A1  T5V0S5-7  [SOD523MC]  114.93 284.99 90 top
CR6A2  30V  [SOD123IB]  135.12 260.09 0 top
CR6A3  30V  [SOD123IB]  133.47 272.29 90 top
CR6C1  20KV  [SCR0603ME]  105.02 222.76 0 top
CR6C2  20KV  [SCR0603ME]  106.29 222.76 180 top
CR6C3  20KV  [SCR0603ME]  98.55 194.25 180 top
CR6C4  20KV  [SCR0603ME]  99.06 194.25 0 top
CR6C5  20KV  [SCR0603ME]  111.91 185.41 225 top
CR6C6  PESD5V0H1BSF  [SOD962MA]  122.3 207.64 270 top
CR6C7  20KV  [SCR0603ME]  112.27 185.77 45 top
CR6C8  PESD5V0H1BSF  [SOD962MA]  114.42 196.85 90 top
CR6D3  20KV  [SCR0603ME]  114.8 193.04 0 top
CR6D4  20KV  [SCR0603ME]  116.07 193.04 180 top
CR6H1  30V  [SOD123IB]  109.72 58.8 270 top
CR6H2  30V  [SOD123IB]  112.01 58.8 270 top
CR6J1  BAT54C  [SOT23MA]  102.87 11.3 90 top
CR7B1  1N5819HW  [SOD123MA]  70.23 249.3 90 top
CR7C1  -  [SLEDR2012MA]  76.07 222.5 180 top
CR7C2  PESD5V0R1BSF  [SOD962MA]  88.13 221.23 0 top
CR7C3  PESD5V0R1BSF  [SOD962MA]  93.72 221.23 0 top
CR7C4  -  [SLEDR2012MA]  76.07 220.72 180 top
CR7C5  20KV  [SCR0603ME]  86.1 202.56 0 top
CR7C6  20KV  [SCR0603ME]  87.37 202.56 180 top
CR7C7  20KV  [SCR0603ME]  88.51 202.56 0 top
CR7C8  20KV  [SCR0603ME]  89.78 202.56 180 top
CR7F1  30V  [SOD123IB]  70.48 125.86 270 top
CR7G1  30V  [SOD123IB]  77.14 94.39 180 top
CR7G2  30V  [SOD123IB]  77.08 92.2 180 top
CR7H1  -  [SLEDR2012MA]  95.37 41.78 90 top
CR7T1  30V  [SOD123IB]  89.02 111.25 90 bottom
CR8A1  30V  [SOD123IB]  28.95 263.78 270 top
CR8C1  BAT54C  [SOT23MA]  25.27 226.06 0 top
CR8D1  BAT54C  [SOT23MA]  37.46 182.24 270 top
CR8D2  BAT54C  [SOT23MA]  30.48 175 270 top
CR8F1  30V  [SOD123IB]  29.21 112.9 0 top
CR8F2  30V  [SOD123IB]  35.81 112.9 0 top
CR8F3  BAT54A  [SOT23MJ]  37.84 106.42 90 top
CR8F4  BAT54C  [SOT23MA]  50.41 105.41 270 top
CR8F5  -  [SLEDR2012MA]  48.38 117.98 90 top
CR8F6  30V  [SOD123IB]  35.81 115.06 0 top
CR8H1  -  [SLEDR2012MA]  45.46 49.15 270 top
CR8H2  -  [SLEDR2012MA]  58.92 42.16 90 top
CR8H3  30V  [SOD123IB]  34.67 40.77 0 top
CR9C1  PESD5V0R1BSF  [SOD962MA]  10.66 204.47 90 top
CR9C2  ESD102-U1-02ELS  [SCR0603MF]  21.97 201.8 90 top
CR9C3  ESD102-U1-02ELS  [SCR0603MF]  21.97 199.77 270 top
CR9C4  ESD102-U1-02ELS  [SCR0603MF]  21.97 198.25 270 top
CR9D1  ESD102-U1-02ELS  [SCR0603MF]  21.59 194.05 0 top
CR9D2  ESD102-U1-02ELS  [SCR0603MF]  21.59 192.78 0 top
CR9D3  ESD102-U1-02ELS  [SCR0603MF]  21.97 191.51 180 top
CR9D4  30V  [SOD123IB]  17.27 185.04 0 top
CR9D5  30V  [SOD123IB]  20.57 182.62 180 top
CR9E1  30V  [SOD123IB]  20.82 143.64 180 top
CR9G1  -  [SLEDR2012MA]  14.47 77.34 90 top
CR9G2  -  [SLEDR2012MA]  17.14 77.34 90 top
CR9G3  -  [SLEDR2012MA]  19.93 77.34 90 top
CR9G4  -  [SLEDR2012MA]  15.24 69.59 270 top
CR9H1  -  [TK0_SLED4_3400X2900_MA_VR]  6.35 52.96 0 top
CRP7J1  -  [SOT457MA]  73.91 25.14 90 top
DS7H1  -  [SLEDR2012MA]  62.73 42.16 90 top
DS8A1  -  [SLED_24357IA]  31.91 261.87 0 top
DS8A2  -  [SLED_24357IA]  40.17 261.87 0 top
