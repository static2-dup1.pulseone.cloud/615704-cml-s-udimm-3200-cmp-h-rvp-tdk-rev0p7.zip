# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
J64EV_PN3_R697EV_PN1: length 2.6
  TOP w0.1: J8J6.1 32.63,20.57 R8J11.1
KBC_CAPSLOCK: length 31.3
  TOP w0.1: Q9G1.1 13.97,84.07 v1(13.84,83.95) ; U8F6.35 17.01,103.89 16.76,104.14 16.76,105.41 15.87,106.3 13.84,106.3 v1(13.71,106.42)
  LAY5 w0.125: v1(13.71,106.42) 13.08,105.79 13.08,104.37 13.44,104.01 13.44,100.99 14.22,100.2 14.22,96.65 13.71,96.14 13.71,92.48 12.8,91.57 12.8,86.13 13.84,85.09 v1(13.84,83.95)
KBC_DISABLE_N: length 28.1
  TOP w0.1: v1(27.68,151.31) 27.68,152.4 26.94,153.14 U8E3.8 ; J9E4.1 7.11,149.6 R9E19.2 v1(10.92,150.37)
  BOTTOM w0.1: v1(27.68,151.31) 27.16,150.78 24.54,150.78 24,150.24 16.89,150.24 15.74,149.1 15.11,149.1 14.6,149.6 11.68,149.6 v1(10.92,150.37)
KBC_NUMLOCK: length 8
  TOP w0.1: U8F6.70 21.22,90.18 19.55,88.52 19.55,86.1 18.41,84.96 Q9G2.1
KBC_SCANIN6: length 6.1
  TOP w0.1: R5J15.1 146.63,9.7 146.63,14.44 J6J2.221
KBC_SCANIN7: length 7.4
  TOP w0.1: J6J2.229 147.7,14.64 147.7,13.69 147.98,13.41 148.96,13.41 149.73,12.64 149.73,9.65 R5J17.1
KBC_SCANOUT14: length 3.4
  TOP w0.1: R5J8.1 140.05,9.55 140.05,12.12 J6J2.183
KBC_SCANOUT15: length 3.5
  TOP w0.1: R5J10.1 141.32,9.93 141.32,12.12 J6J2.191
KBC_SCANOUT<1>: length 3.4
  TOP w0.1: R5J19.2 136.22,9.73 136.22,12.15 J6J2.159
KBC_SCANOUT<2>: length 4.6
  TOP w0.1: R5J18.2 135.12,13.33 J6J2.158
KBC_SCANOUT<3>: length 4.8
  TOP w0.1: R5J20.2 136.44,9.85 136.44,13.38 J6J2.166
KBC_SCANOUT<4>: length 4.9
  TOP w0.1: R5J22.2 137.71,10.11 137.71,13.38 J6J2.174
KBC_SCANOUT<5>: length 5
  TOP w0.1: J6J2.182 140.28,13.17 140.28,10.21 R5J9.1
KBC_SCANOUT<6>: length 5.2
  TOP w0.1: R5J11.1 141.98,10.03 141.73,10.03 141.55,10.21 141.55,13.17 J6J2.190
KBC_SCANOUT<7>: length 3.6
  TOP w0.1: R5J12.1 142.59,10.18 142.59,12.12 J6J2.199
KBC_SCANOUT<9>: length 4.8
  TOP w0.1: J6J2.222 146.4,13.39 146.4,10.01 R5J14.1
KBC_SCANOUT<10>: length 6.1
  TOP w0.1: J6J2.230 147.88,13.18 148.86,13.18 149.47,12.57 149.47,10.03 R5J16.1
KBC_SCANOUT<12>: length 3.4
  TOP w0.1: J6J2.167 137.49,12.15 137.49,9.57 R5J21.2
KBC_SCANOUT<13>: length 3.5
  TOP w0.1: R5J23.2 138.81,9.9 138.81,12.1 J6J2.175
KBC_SCROLLOCK: length 23.4
  TOP w0.1: v1(30.22,84.07) Q9G3.1 ; v1(34.29,95.68) 34.08,95.89 U8F6.106
  LAY5 w0.125: v1(34.29,95.68) 33.78,95.17 33.78,86.49 31.36,84.07 v1(30.22,84.07)
KBCLK: length 6.3
  TOP w0.1: R7J7.1 69.08,28.45 69.08,29.97 69.34,30.22 R7J3.2 70.92,31.43 U7H4.5
KBCLK_FB: length 32.8
  TOP w0.1: v1(77.08,24.51) 76.45,25.14 CRP7J1.3 75.81,25.78 75.43,26.16 73.4,26.16 72.8,25.56 72.8,23.62 72.51,23.33 70.77,23.33 70.35,23.75 70.35,25.27 70.1,25.53 C7J5.1 R7J7.2
  LAY6 w0.125: J7J6.5 82.29,11.74 J7J4.1 81.15,13.33 79.88,13.33 79.37,13.84 79.37,17.14 80.03,17.8 80.03,21.82 77.85,24 77.59,24 v1(77.08,24.51)
KBDATA: length 6
  TOP w0.1: R7J6.1 67.83,28.43 67.83,29.99 68.07,30.22 R7J2.2 68.45,31.24 68.97,31.76 U7H4.2
KBDATA_FB: length 37.8
  TOP w0.1: R7J6.2 C7J4.1 68.19,25.53 67.94,25.27 67.94,23.62 68.19,23.37 70.06,23.37 70.57,22.86 73.02,22.86 73.27,23.11 73.27,24.51 CRP7J1.1 v1(73.91,24)
  LAY6 w0.125: J7J6.1 77.02,6.09 73.02,6.09 72.13,6.98 J7J4.5 72.13,14.6 72.39,14.86 72.39,20.19 73.91,21.72 v1(73.91,24)
L_BKLTCTL: length 523.2
  TOP w0.089: 93.1,130.37 93.1,130.75 96.25,133.9 96.25,135.24 U6E1.AU48
  TOP w0.1: v1(88.9,101.98) 88.39,102.49 88.39,103.38 87.88,103.88 87.88,106.59 88.95,107.66 88.95,113.9 89.84,114.79 89.84,115.99 90.42,116.57 90.42,118.55 90.98,119.11 90.98,119.71 91.28,120.01 92.03,120.01 92.45,120.43 92.45,123.74 93.1,124.39 93.1,130.37 ; R1B6.1 R1B7.1 292.1,250.82 293.75,252.47 v1(296.16,252.47)
  LAY5 w0.125: v1(89.4,39.11) 92.88,42.59 121.86,42.59 122.01,42.74 125.91,42.74 126.75,41.9 155.36,41.9 161.12,47.66 165,47.66 167.2,49.85 174.55,49.85 174.76,50.06 177.65,52.96 186.05,52.96 188.09,55 194.85,55 195.87,56.02 195.87,58.93 198.43,61.48 212.08,61.48 214.13,59.43 222.75,59.43 229.99,52.2 231.34,52.2 232.96,53.82 234.82,53.82 239.76,58.76 247.72,58.76 248.66,59.7 257.87,59.7 259.89,61.72 273,61.72 274.57,63.29 274.57,63.29 278.6,67.32 280.38,67.32 284.88,71.82 284.88,74.22 292.41,81.75 292.41,90.64 294.32,92.55 294.32,97.15 293.11,98.37 293.11,100.71 293.87,101.47 293.87,103.63 294.39,104.15 294.39,113.43 293.88,113.95 293.88,116.03 294.39,116.55 294.39,121.46 291.98,123.87 291.98,129.86 292.95,130.83 292.95,137.13 293.81,137.99 293.81,155.92 295.38,157.49 295.38,158.31 295.9,158.82 295.9,178.98 294.88,180 294.88,196.48 293.46,197.9 293.46,206.94 294.11,207.59 294.11,214.23 293.02,215.33 293.02,217.21 294.16,218.35 294.98,218.35 297.1,220.47 297.1,243.03 296.41,243.72 295.77,243.72 295.52,243.97 295.52,246.38 296.79,247.65 296.79,250.32 296.16,250.95 v1(296.16,252.47)
  LAY6 w0.125: v1(88.9,101.98) 89.8,101.08 89.8,87.62 89.91,87.5 89.91,81.03 92.15,78.79 92.15,75.64 91.37,74.87 91.37,68.03 91.95,67.46 91.95,56.17 91.94,56.17 91.94,55.12 89.75,52.92 89.75,42.96 89.28,42.49 89.28,39.24 v1(89.4,39.11)
L_BKLTEN: length 519.3
  TOP w0.089: U6E1.AV46 95.63,136.24 95.63,135.89 95.77,135.75 95.77,134.08 92.56,130.87 92.56,130.26
  TOP w0.1: 92.56,130.26 92.56,128.18 91.23,126.85 91.23,121.21 88.77,118.74 R7F24.1 89.28,117.73 89.28,115.44 C7F8.1 88.26,114.43 88.26,113.49 87.75,112.99 87.75,111.76 88.39,111.12 88.39,109.98 87.12,108.71 87.12,105.85 87.65,105.32 87.65,103.79 88.1,103.34 88.1,102.01 v1(88.9,101.22) ; J1B2.37 296.42,244.61 v1(296.03,244.22) 295.4,244.22 R1B16.1 294.76,244.85 292.98,244.85 R1B15.2
  LAY5 w0.125: v1(89.28,38.35) 89.4,38.35 93.39,42.34 121.97,42.34 122.12,42.49 124.25,42.49 125.09,41.65 155.46,41.65 161.22,47.41 165.11,47.41 167.3,49.6 174.65,49.6 177.76,52.71 186.15,52.71 187.3,53.85 194.85,53.85 195.19,54.19 195.19,54.99 196.12,55.92 196.12,58.82 198.53,61.23 211.98,61.23 214.03,59.18 222.65,59.18 229.89,51.94 231.44,51.94 233.07,53.57 234.93,53.57 239.86,58.51 247.82,58.51 248.75,59.43 257.96,59.43 259.48,60.96 259.96,60.96 260.35,60.58 268.6,60.58 269.49,61.47 273.1,61.47 278.7,67.07 280.48,67.07 285.13,71.72 285.13,74.04 289.15,78.06 292.56,78.06 293.43,78.93 293.43,91.3 294.58,92.45 294.58,97.46 295.47,98.35 295.47,107 294.65,107.83 294.65,113.21 295.03,113.6 295.03,117.11 294.65,117.5 294.65,121.56 292.24,123.97 292.24,129.75 293.26,130.77 293.26,137.05 294.32,138.12 294.32,156.07 295.88,157.63 295.88,158.04 296.18,158.34 296.18,179.43 295.27,180.34 295.27,196.59 293.71,198.15 293.71,206.83 294.36,207.49 294.36,214.34 293.75,214.95 293.75,216.03 294.38,216.66 294.38,217.4 297.36,220.38 297.36,243.13 296.27,244.22 v1(296.03,244.22)
  LAY6 w0.125: v1(89.28,38.35) 88.77,38.86 88.77,42.34 89.5,43.07 89.5,53.03 91.69,55.22 91.69,56.27 91.69,56.27 91.69,67.35 90.93,68.12 90.93,74.93 91.69,75.69 91.69,78.89 88.93,81.66 88.93,89.27 89.55,89.89 89.55,100.57 v1(88.9,101.22)
L_BRIGHTNESS: length 78.8
  TOP w0.1: J1B2.36 299.48,244.11 v1(299.72,244.35) ; J1D1.1 298.7,190.75 v1(298.7,192.4) ; R1B4.2 R1B5.2 R1B6.2 290.83,251.97 291,252.14 291.66,252.14 291.99,252.47 293.43,252.47 293.65,252.7 295.62,252.7 v1(296.16,253.24)
  LAY5 w0.125: v1(298.7,192.4) 298.57,192.53 298.57,194.05 297.58,195.04 297.58,208.43 297.14,208.88 297.14,216.66 299.95,219.48 299.95,223.8 300.28,224.13 300.28,238.19 299.35,239.12 299.35,240.12 300.28,241.04 300.28,243.78 v1(299.72,244.35) 300.48,245.11 300.48,249.83 297.07,253.24 v1(296.16,253.24)
L_VDDEN: length 531.9
  TOP w0.089: U6E1.AV44 v1(95,137.39)
  TOP w0.1: v1(301.49,216.28) 301.37,216.15 Q1C3.1 300.73,216.91 299.72,217.93 R1C31.2 R1C26.1
  LAY5 w0.125: v1(301.49,216.28) 301.49,215.7 299.97,214.17 299.97,197.23 300.29,196.91 300.29,156.4 301.39,155.3 301.39,133.88 295.95,128.44 295.95,125.8 299.46,122.29 299.46,117.62 300.35,116.73 300.35,109.73 299.21,108.58 299.21,106.55 300.52,105.24 300.52,95.12 300.1,94.7 300.1,84.38 296.66,80.94 296.66,74.21 290.7,68.25 290.7,65.62 290.32,65.23 288.21,65.23 287.11,64.13 280.92,64.13 280.54,63.75 280.54,60.83 280.14,60.43 278.88,60.43 278.11,59.67 275.85,59.67 273.07,56.9 271.12,56.9 270,55.77 270,55.14 269.11,54.25 265.32,54.25 263.42,52.35 253.45,52.35 251.14,50.04 235.48,50.04 235.32,49.88 233.68,49.88 231.95,48.15 222.74,48.15 219.9,50.99 219.71,50.99 215.19,55.5 213.45,55.5 210.68,58.27 201.75,58.27 200.91,57.43 200.91,57.17 200.66,56.92 200.43,56.92 199.01,55.5 199.01,53.62 194.01,48.61 185.19,48.61 182.88,46.3 168.59,46.3 166.3,44.01 163.57,44.01 159.47,39.91 159.47,36.53 152.54,29.6 137.45,29.6 133.58,25.72 131.85,25.72 130.98,24.86 130.42,24.3 130.42,23.67 129.87,23.11 122.71,23.11 121.17,24.64 112.64,24.64 110.74,22.73 107.83,22.73 106.37,21.28 104.33,21.28 102.38,19.33 89.15,19.33 v1(88.5,18.68)
  LAY6 w0.125: v1(88.5,18.68) 88.5,20.56 88.87,20.93 88.87,23.54 87.75,24.66 87.75,31.49 87.37,31.88 87.37,38.73 86.99,39.11 86.99,41.27 88.99,43.28 88.99,53.78 90.04,54.83 90.04,62.74 90.42,63.12 90.42,76.65 89.33,77.74 89.33,80.54 88.42,81.45 88.42,89.53 89.04,90.15 89.04,98.4 88.39,99.06 88.39,99.82 v1(88.9,100.33)
  BOTTOM w0.089: v1(95,137.39) 95,137.07 95.35,136.73 95.35,136.38 94.84,135.87 94.84,135.25
  BOTTOM w0.1: 94.84,135.25 94.84,134.83 93.7,133.68 93.7,131.02 88.77,126.09 C7T1.1 R7T10.1 86.99,117.35 86.99,117.09 86.08,116.18 86.08,105.78 88.13,103.72 88.13,101.09 v1(88.9,100.33)
LAD_ESPI_IO_0: length 69.5
  BOTTOM w0.1: R6U3.1 97.4,94.23 95.06,94.23 91.84,97.45 87.65,97.45 87.39,97.71 83.99,97.71 83.56,97.28 81.71,97.28 79.45,99.54 78.58,99.54 75.56,102.55 75.56,107.19 74.42,108.33 74.42,112.14 71.99,114.57 71.99,119.57 75.6,123.19 77.59,123.19 82.16,127.76 82.16,130.3 C7R7.1 82.7,130.55 83.94,131.8 83.94,132.62 84.96,133.64 84.96,134.11 86.1,135.25 87.12,135.25 R7R57.2
LAD_ESPI_IO_0_EC: length 125
  TOP w0.1: U8F6.59 18.91,94.29 19.49,94.87 23.79,94.87 25.7,96.77 v1(27.68,96.77)
  LAY3 w0.1: v1(64.38,117.35) 64.84,117.35 70.23,111.96 70.23,107.31 77.97,99.57 80.13,99.57 82.16,97.53 85.44,97.53 90.06,92.91 94.86,92.91 95.6,92.17 95.6,91.08 v1(97.15,89.53)
  BOTTOM w0.1: v1(27.68,96.77) 27.94,96.52 29.33,96.52 30.65,97.84 31.44,97.84 31.49,97.79 32.25,97.79 35.05,100.58 35.05,103.63 35.27,103.85 38.36,103.85 41.38,106.87 45.35,106.87 50.52,112.04 60.1,112.04 62.1,114.04 62.24,114.04 62.94,113.35 63.08,113.35 63.22,113.49 63.22,113.63 62.53,114.32 62.53,114.47 62.67,114.61 62.81,114.61 63.5,113.91 63.64,113.91 63.79,114.06 63.79,114.2 63.09,114.89 63.09,115.03 63.23,115.17 63.38,115.17 65.25,113.29 65.4,113.29 65.54,113.44 65.54,113.58 63.66,115.46 63.66,115.6 63.8,115.74 63.94,115.74 66.28,113.4 66.42,113.4 66.56,113.54 66.56,113.68 64.22,116.02 64.22,116.16 64.38,116.32 v1(64.38,117.35) ; R6U5.2 98.04,88.64 v1(97.15,89.53)
LAD_ESPI_IO_0_EC_AIC: length 125.5
  TOP w0.1: J6J2.227 146.6,18.28 146.6,21.53 145.78,22.35 141.96,22.35 138.96,25.35 137.39,25.35 136.81,25.93 136.37,25.93 134.87,27.43 116.84,27.43 114.17,30.1 114.17,34.84 112.64,36.36 108.67,36.36 106.29,38.73 v1(105.79,38.73)
  LAY8 w0.1: v1(99.69,90.42) 99.69,90.3 101.6,88.39 101.6,84.53 101.7,84.43 103.36,84.43 103.46,84.33 103.46,84.13 103.36,84.03 101.7,84.03 101.6,83.93 101.6,83.73 101.7,83.63 102.95,83.63 103.05,83.53 103.05,83.33 102.95,83.23 101.7,83.23 101.6,83.13 101.6,82.93 101.7,82.83 103.77,82.83 103.87,82.73 103.87,82.53 103.77,82.43 101.7,82.43 101.6,82.33 101.6,81.5 101.7,81.4 103.76,81.4 103.86,81.3 103.86,81.1 103.76,81 101.7,81 101.6,80.9 101.6,78.36 103.99,75.96 103.99,63.77 106.83,60.93 106.83,44.8 106.15,44.12 106.15,39.1 v1(105.79,38.73)
  BOTTOM w0.1: R6U6.2 v1(99.69,90.42)
LAD_ESPI_IO_0_HDR: length 126.4
  TOP w0.1: v1(100.96,37.46) 100.45,37.97 100.05,37.97 99.72,37.64 99.72,36.73 99.06,36.07 93.07,36.07 92.2,35.2 92.2,30.99 91.05,29.84 J7J1.11
  LAY8 w0.1: v1(100.96,37.46) 101.72,38.23 101.72,40.77 101.47,41.02 101.47,66.22 98.54,69.15 98.54,69.29 98.66,69.42 98.84,69.42 101.68,66.57 101.82,66.57 101.96,66.72 101.96,66.86 98.54,70.28 98.54,85.81 98.64,85.91 98.84,85.91 98.94,85.81 98.94,71.58 99.04,71.48 99.24,71.48 99.34,71.58 99.34,83.7 99.44,83.8 99.88,83.8 99.98,83.9 99.98,84.1 99.88,84.2 99.44,84.2 99.34,84.3 99.34,84.5 99.44,84.6 100.12,84.6 100.22,84.7 100.22,84.9 100.12,85 99.44,85 99.34,85.1 99.34,85.3 99.44,85.4 100.12,85.4 100.22,85.5 100.22,85.7 100.12,85.8 99.44,85.8 99.34,85.9 99.34,86.21 99.24,86.31 98.64,86.31 98.54,86.41 98.54,86.73 98.64,86.83 99.12,86.83 99.22,86.93 99.22,87.13 99.12,87.23 98.64,87.23 98.54,87.33 98.54,87.53 98.64,87.63 99.12,87.63 99.22,87.73 99.22,87.93 99.12,88.03 98.64,88.03 98.54,88.13 98.54,88.33 98.64,88.43 100.48,88.43 100.58,88.53 100.58,88.73 100.48,88.83 98.64,88.83 98.54,88.93 98.54,89.13 98.64,89.23 99.79,89.23 99.89,89.33 99.89,89.53 99.79,89.63 98.64,89.63 98.54,89.73 98.54,90.03 v1(99.69,91.18)
  BOTTOM w0.1: R6U4.2 v1(99.69,91.18)
LAD_ESPI_IO_0_PCH: length 8.5
  TOP w0.089: U6E1.BB39 v1(93.85,139.28)
  BOTTOM w0.1: v1(93.85,139.28) 93.85,138.94 93.47,138.56 93.16,138.56 92.99,138.39 91.27,138.39 90.29,137.41 90.29,136.46 88.58,134.75 R7R57.1
LAD_ESPI_IO_0_R: length 3.7
  BOTTOM w0.1: R6U6.1 97.91,90.42 R6U4.1 R6U3.2
LAD_ESPI_IO_1: length 65.3
  BOTTOM w0.1: R7R55.2 84.33,133.74 83.43,132.84 C7R3.1 82.37,132.67 81.24,132.67 81.01,132.89 80.51,132.89 80.13,132.51 80.13,130.17 79.75,129.79 78.29,129.79 77.59,129.09 77.59,125.82 72.92,121.15 71.88,121.15 71.4,120.66 71.4,114.52 73.71,112.21 73.71,104.43 74.52,103.62 74.52,102.45 77.34,99.63 77.34,98.46 78.91,96.89 79.25,96.89 79.84,96.29 81.33,96.29 81.86,96.83 83.75,96.83 84.18,97.25 87.21,97.25 87.46,97 91.21,97 R7U4.1
LAD_ESPI_IO_1_EC: length 126.3
  TOP w0.1: U8F6.60 18.83,93.89 19.59,94.64 23.89,94.64 25.5,96.25 27.92,96.25 v1(28.7,97.03)
  LAY3 w0.1: v1(94.74,90.42) 93.98,91.18 93.98,91.82 93.34,92.45 89.88,92.45 85.25,97.08 81.98,97.08 79.94,99.12 77.78,99.12 69.77,107.13 69.77,111.77 64.93,116.61 64.04,116.61 63.65,117 63.65,118.14 v1(64.38,118.87)
  BOTTOM w0.1: R7U23.2 94.48,90.17 v1(94.74,90.42) ; v1(28.7,97.03) 29.52,97.03 31.36,98.87 31.36,100.56 31.64,100.84 32.13,100.84 33.32,102.03 33.32,102.85 34.78,104.31 38.17,104.31 42.38,108.51 45.22,108.51 45.31,108.6 45.31,108.81 45.21,108.91 43.18,108.91 43.08,109.01 43.08,109.21 43.18,109.31 45.8,109.31 49.15,112.67 49.52,112.67 49.66,112.53 49.66,112.38 47.87,110.6 47.87,110.46 48.02,110.32 48.16,110.32 51.48,113.64 55.8,113.64 56.8,114.64 57.33,114.64 57.43,114.54 57.43,113.81 57.53,113.71 57.73,113.71 57.83,113.81 57.83,114.54 57.93,114.64 58.13,114.64 58.23,114.54 58.23,113.81 58.33,113.71 58.53,113.71 58.63,113.81 58.63,114.54 58.73,114.64 58.93,114.64 59.03,114.54 59.03,113.81 59.13,113.71 59.33,113.71 59.43,113.81 59.43,114.54 59.53,114.64 59.73,114.64 59.83,114.54 59.83,113.81 59.93,113.71 60.13,113.71 60.23,113.81 60.23,114.54 60.33,114.64 60.53,114.64 60.63,114.54 60.63,113.81 60.73,113.71 60.93,113.71 61.03,113.81 61.03,114.54 61.13,114.64 62.06,114.64 63.68,116.26 63.68,118.16 v1(64.38,118.87)
LAD_ESPI_IO_1_EC_AIC: length 125.5
  TOP w0.1: v1(102.48,36.98) 103.33,36.13 112.55,36.13 113.94,34.74 113.94,30 116.74,27.2 134.78,27.2 137.63,24.35 139.64,24.35 141.86,22.12 145.68,22.12 146.37,21.44 146.37,18.22 J6J2.219
  LAY8 w0.1: v1(94.74,91.18) 95.18,91.18 95.53,90.84 95.53,89.19 95.93,88.78 95.93,88.64 95.25,87.97 95.25,87.83 95.39,87.68 95.54,87.68 96.21,88.36 96.35,88.36 97.63,87.08 97.63,62.68 100.53,59.78 100.53,51.7 99.31,50.48 99.31,48.75 99.21,48.65 98.73,48.65 98.63,48.55 98.63,48.35 98.73,48.25 99.21,48.25 99.31,48.15 99.31,46.86 98.64,46.19 98.5,46.19 98.12,46.56 97.98,46.56 97.84,46.42 97.84,46.28 98.21,45.91 98.21,45.77 97.48,45.03 97.48,41.72 98.45,40.75 98.45,37.54 99.03,36.96 101.11,36.96 101.78,37.63 102.17,37.63 102.48,37.31 v1(102.48,36.98)
  BOTTOM w0.1: R7U24.2 v1(94.74,91.18)
LAD_ESPI_IO_1_HDR: length 126.3
  TOP w0.1: v1(99.23,37.46) 98.07,36.3 91.16,36.3 90.32,35.46 88.92,35.46 88.51,35.05 J7J1.10
  LAY8 w0.1: v1(94.74,91.95) 95.04,91.95 95.25,92.16 95.25,92.82 95.11,92.96 93.76,92.96 93.62,93.1 93.62,93.34 93.71,93.44 95.68,93.44 95.75,93.36 95.75,93.03 95.85,92.93 96.47,92.93 96.57,92.83 96.57,92.63 96.47,92.53 95.85,92.53 95.75,92.43 95.75,92.23 95.85,92.13 96.47,92.13 96.57,92.03 96.57,91.83 96.47,91.73 95.85,91.73 95.75,91.63 95.75,91.43 95.85,91.33 96.47,91.33 96.57,91.23 96.57,91.03 96.47,90.93 95.85,90.93 95.75,90.83 95.75,89.28 97.86,87.17 97.86,67.3 100.76,64.4 100.76,64.25 100.63,64.11 100.48,64.11 98.15,66.45 97.99,66.45 97.86,66.31 97.86,66.17 100.76,63.27 100.76,63.13 100.63,63 100.47,63 98.14,65.32 98,65.32 97.86,65.18 97.86,65.04 100.73,62.16 100.73,62.02 100.59,61.88 100.45,61.88 98.15,64.18 97.99,64.18 97.86,64.05 97.86,63.91 100.76,61.01 100.76,60.87 100.62,60.72 100.48,60.72 98.15,63.05 97.99,63.05 97.86,62.92 97.86,62.78 100.76,59.88 100.76,51.61 99.54,50.38 99.54,46.77 99.38,46.61 99.38,46.47 99.65,46.2 99.65,46.05 99.5,45.91 99.36,45.91 99.09,46.18 98.95,46.18 98.81,46.04 98.81,45.9 99.12,45.59 99.12,45.45 98.98,45.31 98.84,45.31 98.53,45.62 98.39,45.62 97.7,44.94 97.7,41.94 97.8,41.84 98,41.84 98.1,41.94 98.1,44.15 98.2,44.25 98.4,44.25 98.5,44.15 98.5,42.01 98.6,41.91 98.8,41.91 98.9,42.01 98.9,44.13 99,44.23 99.2,44.23 99.3,44.13 99.3,41.61 99.2,41.51 98.44,41.51 98.34,41.41 98.34,41.18 98.67,40.84 98.67,38.02 v1(99.23,37.46)
  BOTTOM w0.1: R7U15.2 v1(94.74,91.95)
LAD_ESPI_IO_1_PCH: length 12.9
  TOP w0.089: v1(95.15,140.05) U6E1.AW37
  BOTTOM w0.089: 92.83,139.82 93.5,139.82 93.58,139.91 94.14,139.91 94.36,140.13 95.08,140.13 v1(95.15,140.05)
  BOTTOM w0.1: R7R55.1 86.8,137.1 87.81,137.1 89.56,138.85 91.86,138.85 92.83,139.82 92.83,139.82
LAD_ESPI_IO_1_R: length 3.6
  BOTTOM w0.1: R7U4.2 93.09,94.23 R7U15.1 93.54,92.25 93.54,91.49 R7U24.1
LAD_ESPI_IO_2: length 56.7
  BOTTOM w0.1: R7R61.2 C7R8.1 77.37,129.18 77.37,125.91 72.83,121.37 71.79,121.37 70.35,119.94 70.35,115.24 73.48,112.11 73.48,104.33 74.29,103.52 74.29,102.35 77.11,99.54 77.11,98.37 78.81,96.66 79.15,96.66 79.75,96.06 81.42,96.06 81.95,96.6 83.84,96.6 84.27,97.03 87.11,97.03 87.37,96.77 90.34,96.77 91.44,95.68 R7U5.1
LAD_ESPI_IO_2_EC: length 126.1
  TOP w0.1: U8F6.61 18.75,93.49 19.68,94.41 23.98,94.41 25.6,96.03 28.46,96.03 29.21,96.77 29.21,97.28 v1(28.7,97.79)
  LAY3 w0.1: v1(63.11,116.58) 63.31,116.38 64.84,116.38 69.55,111.68 69.55,107.03 77.69,98.89 79.84,98.89 81.88,96.85 85.16,96.85 90.32,91.69 92.58,91.69 v1(93.09,91.18)
  BOTTOM w0.1: v1(28.7,97.79) 29.28,97.79 30.48,98.99 30.48,100.65 34.36,104.53 38.08,104.53 43.08,109.54 44.57,109.54 48.9,113.86 49.04,113.86 49.18,113.72 49.18,113.58 45.49,109.89 45.49,109.75 45.63,109.61 45.78,109.61 50.01,113.85 50.16,113.85 50.3,113.71 50.3,113.57 49.7,112.97 49.7,112.8 49.83,112.67 49.97,112.67 51.16,113.86 55.7,113.86 58.43,116.58 58.71,116.58 58.81,116.48 58.81,115.51 58.91,115.41 59.11,115.41 59.21,115.51 59.21,116.48 59.31,116.58 59.51,116.58 59.61,116.48 59.61,115.09 59.71,114.99 59.91,114.99 60.01,115.09 60.01,116.48 60.11,116.58 60.31,116.58 60.41,116.48 60.41,115.01 60.51,114.91 60.71,114.91 60.81,115.01 60.81,116.48 60.91,116.58 61.11,116.58 61.21,116.48 61.21,115.07 61.31,114.97 61.51,114.97 61.61,115.07 61.61,116.48 61.71,116.58 v1(63.11,116.58) ; R7U26.2 v1(93.09,91.18)
LAD_ESPI_IO_2_EC_AIC: length 125.6
  TOP w0.1: v1(101.8,36.98) 102.87,35.91 112.46,35.91 113.71,34.65 113.71,29.91 116.65,26.98 134.68,26.98 137.54,24.12 139.54,24.12 141.77,21.9 142.87,21.9 144.11,20.66 144.11,18.22 J6J2.211
  LAY8 w0.1: v1(101.8,36.98) 101.52,36.7 98.96,36.7 98.22,37.44 98.22,40.65 97.25,41.62 97.25,46.33 98.29,47.37 98.29,49.78 100.2,51.69 100.2,59.8 97.4,62.59 97.4,85.34 96.43,86.32 96.43,86.46 97.11,87.14 97.11,87.28 96.97,87.42 96.83,87.42 96.15,86.74 96,86.74 94.86,87.88 94.86,88.02 95.52,88.68 95.52,88.83 95.38,88.97 95.24,88.97 94.58,88.31 94.44,88.31 94.3,88.45 94.3,88.59 94.96,89.25 94.96,89.39 94.82,89.53 94.67,89.53 94.01,88.87 93.87,88.87 93.73,89.01 93.73,89.16 94.39,89.82 94.39,89.96 94.25,90.1 94.11,90.1 93.45,89.44 93.31,89.44 93.09,89.66 v1(93.09,90.42)
  BOTTOM w0.1: R7U25.2 92.83,90.17 v1(93.09,90.42)
LAD_ESPI_IO_2_HDR: length 126.2
  TOP w0.1: J7J1.8 85.97,35.3 86.58,35.91 90.13,35.91 90.97,36.76 95.46,36.76 95.56,36.86 95.56,37.36 95.66,37.46 95.86,37.46 95.96,37.36 95.96,36.86 96.06,36.76 97.08,36.76 97.53,37.21 v1(97.66,37.21)
  LAY8 w0.1: v1(93.09,91.95) 92.94,92.09 92.94,93.43 92.74,93.63 92.42,93.63 92.17,93.38 92.17,93.16 92.07,93.06 90.76,93.06 90.66,92.96 90.66,92.76 90.76,92.66 92.07,92.66 92.17,92.56 92.17,92.36 92.07,92.26 90.76,92.26 90.66,92.16 90.66,91.96 90.76,91.86 92.07,91.86 92.17,91.76 92.17,90.25 97.15,85.27 97.15,62.52 99.86,59.82 99.86,59.67 99.72,59.53 99.57,59.53 97.42,61.69 97.27,61.69 97.15,61.57 97.15,61.39 99.97,58.57 99.97,54.04 96.57,50.65 96.57,50.5 96.71,50.36 96.86,50.36 99.69,53.2 99.84,53.2 99.97,53.07 99.97,52.91 96.53,49.47 96.53,49.32 96.67,49.18 96.81,49.18 99.7,52.08 99.84,52.08 99.97,51.95 99.97,51.78 98.07,49.88 98.07,47.46 97.97,47.36 97.8,47.36 97.67,47.5 97.67,49.08 97.57,49.18 97.37,49.18 97.27,49.08 97.27,48.76 97.17,48.66 96.85,48.66 96.75,48.56 96.75,48.36 96.85,48.26 97.17,48.26 97.27,48.16 97.27,47.96 97.17,47.86 96.63,47.86 96.53,47.76 96.53,47.56 96.63,47.46 97.17,47.46 97.27,47.36 97.27,46.66 96.92,46.32 96.63,46.32 96.53,46.22 96.53,46.02 96.63,45.92 96.92,45.92 97.02,45.82 97.02,45.62 96.92,45.52 96.63,45.52 96.53,45.42 96.53,45.22 96.63,45.12 96.92,45.12 97.02,45.02 97.02,44.82 96.92,44.72 96.63,44.72 96.53,44.62 96.53,44.42 96.63,44.32 96.92,44.32 97.02,44.22 97.02,44.02 96.92,43.92 96.63,43.92 96.53,43.82 96.53,43.62 96.63,43.52 96.92,43.52 97.02,43.42 97.02,43.22 96.92,43.12 96.63,43.12 96.53,43.02 96.53,42.82 96.63,42.72 96.92,42.72 97.02,42.62 97.02,42.42 96.92,42.32 96.63,42.32 96.53,42.22 96.53,42.02 96.63,41.92 96.92,41.92 97.02,41.82 97.02,41.53 97.66,40.89 97.66,40.41 97.56,40.31 96.96,40.31 96.86,40.21 96.86,37.79 96.96,37.69 97.16,37.69 97.26,37.79 97.26,39.81 97.36,39.91 97.56,39.91 97.66,39.81 v1(97.66,37.21)
  BOTTOM w0.1: R7U16.2 v1(93.09,91.95)
LAD_ESPI_IO_2_PCH: length 21.4
  TOP w0.089: U6E1.AV37 v1(95.89,140.4)
  BOTTOM w0.089: 92,139.53 92.49,140.02 93.39,140.02 93.46,140.1 94.06,140.1 94.34,140.38 94.78,140.38 94.99,140.59 95.69,140.59 v1(95.89,140.4)
  BOTTOM w0.1: 92,139.53 91.55,139.08 89.47,139.08 87.8,137.41 86.42,137.41 81.9,132.89 81.33,132.89 81.11,133.12 80.39,133.12 79.62,132.35 R7R61.1
LAD_ESPI_IO_2_R: length 3.6
  BOTTOM w0.1: R7U25.1 91.44,91.95 R7U16.1 R7U5.2
LAD_ESPI_IO_3: length 71.2
  BOTTOM w0.1: R7U9.1 95.25,93.72 91.75,97.23 87.55,97.23 87.3,97.48 84.08,97.48 83.66,97.05 81.58,97.05 79.32,99.31 78.48,99.31 75.33,102.46 75.33,107.09 74.19,108.24 74.19,112.05 71.62,114.61 71.62,120.57 71.98,120.92 73.01,120.92 75.51,123.42 77.5,123.42 81.28,127.19 81.28,129.67 80.39,130.55 80.39,132.45 80.61,132.67 80.92,132.67 81.15,132.44 81.66,132.44 82.42,131.68 C7R5.1 83.18,131.44 83.72,131.98 83.72,132.72 84.73,133.73 84.73,134.2 86.42,135.89 R7R54.2
LAD_ESPI_IO_3_EC: length 123.3
  TOP w0.1: U8F6.62 18.68,93.09 19.77,94.19 24.08,94.19 25.69,95.8 28.61,95.8 31.11,98.3 31.11,98.69 31.41,99 v1(31.86,99)
  LAY3 w0.1: v1(64.38,118.11) 63.88,117.6 63.88,117.09 64.13,116.84 65.03,116.84 70,111.87 70,107.22 77.87,99.35 80.03,99.35 82.07,97.31 85.34,97.31 89.97,92.68 94.76,92.68 95.37,92.07 95.37,90.42 v1(97.15,88.64)
  BOTTOM w0.1: v1(31.86,99) 32.32,99 32.51,99.19 32.51,100.07 32.61,100.17 33.68,100.17 33.78,100.27 33.78,100.47 33.68,100.57 32.61,100.57 32.51,100.67 32.51,100.9 33.58,101.97 33.72,101.97 34.16,101.52 34.3,101.52 34.44,101.67 34.44,101.81 34,102.25 34,102.39 34.16,102.55 34.48,102.55 34.82,102.9 34.82,103.72 35.17,104.08 38.26,104.08 42.47,108.28 44.52,108.28 44.62,108.18 44.62,107.21 44.72,107.11 44.92,107.11 45.02,107.21 45.02,108.18 45.12,108.28 46.45,108.28 46.64,108.48 46.64,108.62 46.21,109.06 46.21,109.2 46.35,109.34 46.49,109.34 46.93,108.91 47.07,108.91 47.21,109.05 47.21,109.19 46.77,109.63 46.77,109.77 46.91,109.91 47.06,109.91 47.49,109.47 47.63,109.47 51.57,113.41 52,113.41 52.1,113.31 52.1,112.62 52.2,112.52 52.4,112.52 52.5,112.62 52.5,113.31 52.6,113.41 52.8,113.41 52.9,113.31 52.9,112.62 53,112.52 53.2,112.52 53.3,112.62 53.3,113.31 53.4,113.41 53.6,113.41 53.7,113.31 53.7,112.75 53.8,112.65 54,112.65 54.1,112.75 54.1,113.31 54.2,113.41 61.15,113.41 63.9,116.16 63.9,117.63 v1(64.38,118.11) ; R7U29.2 v1(97.15,88.64)
LAD_ESPI_IO_3_EC_AIC: length 122.9
  TOP w0.1: v1(100.2,37.46) 101.98,35.68 112.36,35.68 113.49,34.56 113.49,29.82 116.55,26.75 134.59,26.75 137.44,23.9 139.45,23.9 141.67,21.67 142.78,21.67 143.88,20.56 143.88,18.28 J6J2.203
  LAY8 w0.1: v1(100.2,37.46) 99.69,37.97 99.69,38.22 99.58,38.33 99.19,38.33 99.1,38.42 99.1,38.74 99.22,38.86 100.29,38.86 100.39,38.76 100.39,38.04 100.49,37.94 100.69,37.94 100.79,38.04 100.79,38.76 100.89,38.86 101.32,38.86 101.42,38.96 101.42,39.16 101.32,39.26 99.79,39.26 99.69,39.36 99.69,40.13 100.17,40.61 100.17,40.84 100.07,40.94 99.73,40.94 99.63,41.04 99.63,41.24 99.73,41.34 100.07,41.34 100.17,41.44 100.17,41.64 100.07,41.74 99.73,41.74 99.63,41.84 99.63,42.04 99.73,42.14 100.07,42.14 100.17,42.24 100.17,42.44 100.07,42.54 99.73,42.54 99.63,42.64 99.63,42.84 99.73,42.94 100.07,42.94 100.17,43.04 100.17,43.24 100.07,43.34 99.73,43.34 99.63,43.44 99.63,43.64 99.73,43.74 100.07,43.74 100.17,43.84 100.17,50.7 100.99,51.51 100.99,64.8 98.09,67.7 98.09,90.64 97.97,90.75 97.83,90.75 97.66,90.58 97.66,90.46 97.56,90.36 97.21,90.36 v1(97.15,90.42)
  BOTTOM w0.1: R7U28.2 v1(97.15,90.42)
LAD_ESPI_IO_3_HDR: length 123.2
  TOP w0.1: J7J1.7 85.97,30.35 86.99,31.37 86.99,34.54 88.13,35.69 90.23,35.69 91.07,36.53 97.64,36.53 99.72,38.61 99.94,38.61 v1(101.21,39.88)
  LAY8 w0.1: v1(101.21,39.88) 101.21,50.35 101.11,50.45 100.91,50.45 100.81,50.35 100.81,40.43 100.71,40.33 100.51,40.33 100.41,40.43 100.41,50.62 101.21,51.42 101.21,65.02 98.31,67.92 98.31,68.07 98.45,68.21 98.59,68.21 100.97,65.83 101.11,65.83 101.24,65.96 101.24,66.13 98.31,69.06 98.31,91.04 98.41,91.14 99.03,91.14 99.13,91.24 99.13,91.44 99.03,91.54 98.41,91.54 98.31,91.64 98.31,91.84 98.41,91.94 99.03,91.94 99.13,92.04 99.13,92.24 99.03,92.34 98.41,92.34 98.31,92.44 98.31,92.64 98.41,92.74 99.37,92.74 99.47,92.84 99.47,93.04 99.37,93.14 98.41,93.14 98.31,93.24 98.31,94.04 97.98,94.38 94.74,94.38 94.53,94.16 94.53,93.99 94.7,93.83 97.56,93.83 97.79,93.6 97.79,91.44 97.53,91.18 v1(97.15,91.18)
  BOTTOM w0.1: R7U20.2 v1(97.15,91.18)
LAD_ESPI_IO_3_PCH: length 9.5
  TOP w0.089: U6E1.BA38 v1(94.51,139.66)
  BOTTOM w0.089: 92.79,139.4 92.83,139.44 93.41,139.44 93.67,139.7 94.02,139.7 94.07,139.66 v1(94.51,139.66)
  BOTTOM w0.1: 92.79,139.4 92.01,138.62 89.72,138.62 87.37,136.27 R7R54.1
LAD_ESPI_IO_3_R: length 3.7
  BOTTOM w0.1: R7U29.1 95.5,90.42 R7U20.1 R7U9.2
LAN_DISABLE_R_N: length 214.8
  TOP w0.1: v1(44.19,212.47) 45.21,211.45 46.1,211.45 R8C32.2 ; R4B13.1 R4B18.2 v1(192.02,255.4) 192.02,255.78 R4B7.2 191.26,256.16 190.6,256.82 190.6,257.33 190.18,257.74 EU4B1.3
  LAY5 w0.125: v1(47.87,253.24) 48.79,254.15 52.55,254.15 52.93,254.53 59.55,254.53 59.94,254.15 62.91,254.15 63.32,253.74 65.53,253.74 66.42,254.64 70.57,254.64 71.33,255.4 74.3,255.4 77.73,251.96 81.3,251.96 83.61,249.65 85.37,249.65 86.86,248.16 90.32,248.16 91.21,247.27 93.49,247.27 94.51,248.28 96.64,248.28 97.5,247.43 108.7,247.43 110,246.13 110.84,246.13 111.05,246.34 116.79,246.34 117.22,246.76 118.74,246.76 119.59,245.91 124.99,245.91 128.08,249 130.11,249 131.46,250.35 134.28,250.35 137.29,253.36 146.69,253.36 147.29,253.96 174.36,253.96 174.92,253.4 179.59,253.4 182.34,256.16 191.26,256.16 v1(192.02,255.4)
  BOTTOM w0.1: v1(44.19,212.47) 45.08,213.36 45.08,231.9 44.45,232.54 44.19,232.54 43.43,233.3 43.43,234.57 45.21,236.35 50.41,236.35 52.19,238.12 52.19,239.14 49.14,242.19 49.14,251.97 v1(47.87,253.24)
LAN_DISALBE_N: length 147.8
  TOP w0.1: CR7F1.2 v1(70.48,123.49) ; R7B22.1 89.25,249.58 84.81,249.58 v1(83.56,250.82)
  LAY5 w0.125: v1(70.48,123.49) 70.94,123.95 73.91,123.95 76.2,126.24 76.2,136.14 79.62,139.57 79.62,144.96 78.48,146.1 78.48,148.74 79.88,150.14 79.88,152.68 81.55,154.35 81.55,159.35 81.91,159.71 81.91,164.59 81.14,165.35 81.14,172.98 83.2,175.03 83.2,183.55 79.5,187.25 79.5,201.04 v1(79.31,201.23)
  LAY6 w0.125: v1(83.56,250.82) 83.31,250.82 79.37,246.89 79.37,218.93 77.86,217.42 77.86,202.68 v1(79.31,201.23)
LAN_FOX_ON: length 5.1
  TOP w0.2: U6A3.2 108.07,276.86 109.09,275.84 R6A35.2 R6A40.2 R6A41.2 C6A26.1
LAN_FOX_TRCT1: length 7.7
  TOP w0.1: J7A1.7 70.35,263.4 C7A10.1
LAN_FOX_TRCT2: length 11.3
  TOP w0.1: J7A1.1 68.96,270.88 68.96,267.33 69.34,266.95 C7A9.1
LAN_FOX_TRCT3: length 7.5
  TOP w0.1: J7A1.6 81.78,273.05 88.13,273.05 88.26,273.18 C7A5.1
LAN_FOX_TRCT4: length 7
  TOP w0.1: C7A6.1 88.13,272.29 88.01,272.16 83.95,272.16 J7A1.12
LAN_LED0: length 3.4
  TOP w0.1: R4A18.2 183.54,263.5 183.54,261.08 183.68,260.94 EU4B1.26
LAN_LED0_R: length 8.8
  TOP w0.1: J4A2.32 181.5,268.35 183.76,268.35 184.15,267.97 184.15,267.08 183.13,266.06 183.13,264.79 R4A18.1 C4A20.1
LAN_LED1: length 21.9
  TOP w0.1: EU4B1.27 183.7,260.54 183.31,260.93 183.31,261.95 182.88,262.38 182.37,262.38 181.48,263.27 181.22,263.27 181.05,263.45 181.05,264.23 C4A19.1 181.48,265.05 182.24,265.81 v1(182.62,265.81)
  BOTTOM w0.1: J4A2.29 194.05,268.35 192.04,268.35 190.23,266.54 183.35,266.54 v1(182.62,265.81)
LAN_LED2: length 18.8
  TOP w0.1: EU4B1.25 184.12,261.77 183.76,262.13 v1(183.76,265.81) ; v1(193.8,267.33) 193.8,267.08 195.83,265.05 R4A19.2
  BOTTOM w0.1: v1(183.76,265.81) 184.27,266.31 190.67,266.31 190.9,266.55 192.76,266.55 193.54,267.33 v1(193.8,267.33)
LAN_LED2_R: length 4.3
  TOP w0.1: R4A19.1 C4A21.1 194.05,265.8 J4A2.30
LAN_MDI0_DN: length 20.3
  TOP w0.09: v1(190.45,268.98) 190.75,268.69 190.75,267.71 189.1,266.06 189.1,262.71 188.74,262.35 EU4B1.14
  BOTTOM w0.09: v1(190.45,268.98) 190.6,268.98 190.75,268.83 190.75,268.37 189.85,267.47 186.05,267.47 184.72,268.79 184.72,270.57 184.02,271.27 184.02,272.23 J4A2.21
LAN_MDI0_DN_FOX: length 44.5
  TOP w0.09: EU7A2.9 v1(84.19,262.5) ; v1(87.85,261.28) 88.11,261.54 88.38,261.54 88.45,261.6 89.7,261.6 89.78,261.53 90.54,261.53 90.58,261.49 EU7A3.46
  BOTTOM w0.09: J7A1.9 73.79,270.13 73.53,270.13 73.31,270.35 73.31,271.75 72.51,272.54 72.51,274.06 74.5,276.06 82.84,276.06 85.47,273.43 85.47,262.89 84.74,262.16 84.53,262.16 v1(84.19,262.5) 84.18,262.51 83.49,262.51 82.99,262.01 82.99,261.23 83.62,260.6 85.34,260.6 86.02,261.28 v1(87.85,261.28)
LAN_MDI0_DP: length 20.3
  TOP w0.09: EU4B1.13 189.14,262.3 189.42,262.57 189.42,265.93 191.07,267.58 191.07,268.69 v1(191.37,268.98)
  BOTTOM w0.09: J4A2.20 183.33,270.83 183.51,271.02 183.82,271.02 184.4,270.44 184.4,268.66 185.91,267.15 189.98,267.15 191.07,268.24 191.07,268.69 v1(191.37,268.98)
LAN_MDI0_DP_FOX: length 44.5
  TOP w0.09: EU7A3.45 90.57,261.89 90.52,261.85 89.91,261.85 89.83,261.92 88.32,261.92 88.25,261.86 88.11,261.86 v1(87.85,262.11) ; EU7A2.7 v1(84.19,261.5)
  BOTTOM w0.09: J7A1.8 72.45,270.75 72.99,271.29 72.99,271.61 72.19,272.41 72.19,274.2 74.37,276.38 82.97,276.38 85.79,273.56 85.79,262.76 84.87,261.84 84.53,261.84 v1(84.19,261.5) 84.19,261.86 83.86,262.19 83.62,262.19 83.31,261.87 83.31,261.36 83.75,260.92 85.21,260.92 85.89,261.6 87.24,261.6 87.37,261.73 87.37,262.13 87.5,262.25 87.71,262.25 v1(87.85,262.11)
LAN_MDI1_DN: length 14.8
  TOP w0.09: v1(187.85,268.98) 188.14,268.69 188.14,267.83 187.17,266.85 187.17,261.99 EU4B1.18
  BOTTOM w0.09: J4A2.23 186.56,272.23 186.56,271.27 187.13,270.7 187.13,269.74 186.62,269.23 186.62,268.56 186.79,268.39 187.98,268.39 188.18,268.6 188.18,268.84 188.04,268.98 v1(187.85,268.98)
LAN_MDI1_DN_FOX: length 40.2
  TOP w0.09: EU7A2.3 v1(80.39,262) ; v1(89.35,260.08) 89.61,260.34 90.62,260.34 90.67,260.29 EU7A3.49
  BOTTOM w0.09: v1(89.35,260.08) 89.08,260.35 86.68,260.35 85.92,259.59 82.8,259.59 81.02,261.36 81.02,262.13 80.86,262.29 80.69,262.29 80.4,262 v1(80.39,262) 80.13,262.25 80.13,262.38 79.5,263.02 79.5,264.03 84.45,268.98 84.45,273.05 82.37,275.13 75.48,275.13 74.45,274.1 74.45,273.5 74.65,273.29 J7A1.3
LAN_MDI1_DP: length 14.8
  TOP w0.09: EU4B1.17 187.49,262.02 187.49,266.72 188.46,267.69 188.46,268.69 v1(188.76,268.98)
  BOTTOM w0.09: v1(188.76,268.98) 188.5,268.73 188.5,268.47 188.11,268.07 186.66,268.07 186.3,268.43 186.3,269.37 186.81,269.87 186.81,270.56 186.36,271.02 186.05,271.02 185.87,270.83 J4A2.22
LAN_MDI1_DP_FOX: length 40.2
  TOP w0.09: EU7A3.48 90.64,260.69 90.61,260.66 89.57,260.66 89.35,260.88 v1(89.35,260.91) ; EU7A2.1 v1(80.4,263)
  BOTTOM w0.09: v1(89.35,260.91) 89.12,260.67 86.55,260.67 85.79,259.91 82.93,259.91 81.34,261.5 81.34,262.26 80.99,262.61 80.79,262.61 v1(80.4,263) 79.97,263 79.82,263.15 79.82,263.9 84.77,268.85 84.77,273.18 82.5,275.45 75.35,275.45 74.13,274.23 74.13,273.4 74.03,273.29 J7A1.2
LAN_MDI2_DN: length 13
  TOP w0.09: J4A2.25 188.9,272.03 188.01,272.03 186.94,270.96 186.94,270.07 185.8,268.93 185.8,263.07 185.92,262.95 185.92,261.99 EU4B1.21
LAN_MDI2_DN_FOX: length 41.2
  TOP w0.09: EU7A3.52 90.66,259.09 90.63,259.12 87.82,259.12 87.6,258.91 v1(87.6,258.88) ; EU7A1.9 v1(77.97,262.5)
  BOTTOM w0.09: J7A1.5 78.95,272.74 78.5,272.74 78.35,272.88 78.35,273.73 78.81,274.19 81.91,274.19 83.43,272.67 83.43,269.75 78.54,264.85 78.54,262.39 78.34,262.19 78.28,262.19 v1(77.97,262.5) 77.13,262.5 76.76,262.13 76.76,259.84 78.41,258.19 85.85,258.19 86.54,258.88 v1(87.6,258.88)
LAN_MDI2_DP: length 13
  TOP w0.09: EU4B1.20 186.34,262.43 186.24,262.53 186.24,263.08 186.12,263.2 186.12,268.8 187.26,269.94 187.26,270.83 188.14,271.71 188.71,271.71 188.97,271.45 188.97,270.83 J4A2.24
LAN_MDI2_DP_FOX: length 41.2
  TOP w0.09: EU7A1.7 v1(77.97,261.5) ; v1(87.6,259.71) 87.86,259.44 90.66,259.44 90.71,259.49 EU7A3.51
  BOTTOM w0.09: J7A1.4 78.68,274.51 82.04,274.51 83.75,272.8 83.75,269.61 78.86,264.72 78.86,262.25 78.48,261.87 78.34,261.87 v1(77.97,261.5) 77.71,261.5 77.59,261.62 77.59,261.76 77.75,261.92 77.75,262.05 77.61,262.18 77.26,262.18 77.08,262 77.08,259.97 78.54,258.51 85.72,258.51 86.41,259.2 87.24,259.2 87.6,259.56 v1(87.6,259.71)
LAN_MDI3_DN: length 21.7
  TOP w0.09: EU4B1.24 184.74,262.37 184.43,262.67 184.43,266.1 184.84,266.51 184.84,268.85 184.33,269.36 184.33,270.51 185.6,271.78 185.6,273.31 186.43,274.13 190.63,274.13 191.2,273.56 191.2,272.09 191.38,271.91 191.71,271.91 192.22,272.41 J4A2.27
LAN_MDI3_DN_FOX: length 38.7
  TOP w0.09: v1(89.35,257.68) 89.61,257.94 90.62,257.94 90.66,257.89 EU7A3.55 ; EU7A1.3 v1(74.16,262)
  BOTTOM w0.09: v1(89.35,257.68) 89.17,257.86 87.11,257.86 86.43,257.17 78.03,257.17 74.93,260.28 74.93,262.25 74.76,262.42 74.58,262.42 v1(74.16,262) 73.87,262.29 73.17,262.29 72.55,262.91 72.55,264.14 76.26,267.85 76.26,271.28 76.95,271.97 79.3,271.97 J7A1.11
LAN_MDI3_DP: length 21.7
  TOP w0.09: J4A2.26 191.77,271.09 191.77,271.4 191.58,271.59 191.25,271.59 190.88,271.96 190.88,273.43 190.5,273.81 186.56,273.81 185.92,273.18 185.92,271.65 184.65,270.38 184.65,269.49 185.16,268.98 185.16,266.37 184.75,265.97 184.75,262.81 185.14,262.42 EU4B1.23
LAN_MDI3_DP_FOX: length 38.7
  TOP w0.09: EU7A1.1 v1(74.16,263) ; EU7A3.54 90.65,258.29 90.62,258.26 89.6,258.26 v1(89.35,258.51)
  BOTTOM w0.09: J7A1.10 78.91,270.33 79.56,270.33 79.7,270.47 79.7,271.11 79.16,271.65 77.08,271.65 76.58,271.14 76.58,267.71 72.87,264.01 72.87,263.04 73.3,262.61 73.77,262.61 v1(74.16,263) 74.42,262.74 74.89,262.74 75.25,262.39 75.25,260.41 78.16,257.49 86.29,257.49 86.98,258.18 89.02,258.18 v1(89.35,258.51)
LAN_RBIAS_R2GND: length 2.8
  TOP w0.2: EU4B1.12 189.77,262.16 190.39,262.79 190.39,263.63 R4A22.1
LAN_TESTEN: length 2
  TOP w0.1: R4A25.2 182.87,259.34 EU4B1.30
LAN_XTAL1_FOX: length 6
  TOP w0.1: 90,268.15 90,268.13 91.44,266.7 C7A8.2 92.58,265.43 92.58,264.41 92.28,264.12 EU7A3.41
LAN_XTAL2_FOX: length 3.4
  TOP w0.1: EU7A3.40 92.68,264.19 92.81,264.31 92.81,266.22 R7A7.2
LAN_XTAL2_FOX_C: length 4.7
  TOP w0.1: R7A7.1 93.34,267.08 93.98,267.71 93.98,268.86 C7A7.2 92.83,269.11 Y7A1.1
LAN_XTL_DN: length 2.9
  TOP w0.1: EU4B1.9 190.42,260.14 190.99,260.72 192.01,260.72 R4A24.1
LAN_XTL_DN_M3LN: length 3.1
  TOP w0.1: Y4A2.3 194,261.54 C4A31.1 192.78,262.38 R4A24.2
LAN_XTL_DP: length 9.3
  TOP w0.1: Y4A2.1 196.18,262.36 193.95,262.36 193.42,262.89 192.4,262.89 C4A30.1 191.77,262.25 191.77,261.27 191.5,261 190.89,261 190.43,260.54 EU4B1.10
LANPHYPC: length 247.8
  TOP w0.089: 86.96,137.39 86.99,137.39 88.47,138.87 90.89,138.87 91.04,139.02 91.63,139.02 91.75,138.91 U6E1.BF41
  TOP w0.1: R7B26.1 v1(92.45,247.9) ; 86.96,137.39 85.7,137.39 81.91,133.6 v1(81.61,133.6) ; v1(192.78,255.4) 192.78,255.9 R4B7.1
  LAY5 w0.125: v1(192.78,255.4) 191.77,256.41 182.27,256.41 179.5,253.63 175.01,253.63 174.43,254.21 147.18,254.21 146.59,253.62 137.18,253.62 134.17,250.61 131.35,250.61 130,249.26 127.98,249.26 124.88,246.16 119.69,246.16 118.84,247.01 117.11,247.01 116.69,246.59 110.95,246.59 110.74,246.38 110.1,246.38 108.8,247.68 97.75,247.68 96.77,248.66 94.53,248.66 93.77,247.9 v1(92.45,247.9) ; v1(93.21,195.96) 92.71,195.45 92.71,194.82 92.58,194.69 91.48,194.69 87.24,190.45 87.24,177.8 90.7,174.34 90.7,161.78 88.59,159.67 88.14,159.67 86.45,157.98 86.45,154.67 86.83,154.29 86.83,150.84 84.32,148.33 84.32,147.17 85.34,146.16 85.34,144.04 84.19,142.9 84.19,136.65 82.42,134.87 82.42,134.64 81.61,133.83 v1(81.61,133.6)
  LAY6 w0.125: v1(93.21,195.96) 94.23,196.97 94.23,197.93 93.08,199.07 93.08,208.09 91.43,209.74 91.43,243.46 92.45,244.47 v1(92.45,247.9)
LANWAKE_N: length 109.9
  TOP w0.1: EU4B1.2 190.11,257.34 190.37,257.09 190.37,256.28 v1(191.26,255.4) R4B17.2 ; R7B15.1 R7B19.2 97.71,250.77 97.71,249.6 97.02,248.92 97.02,248.03 96.77,247.78 v1(96.39,247.78)
  LAY5 w0.125: v1(96.39,247.78) 96.99,247.18 108.59,247.18 109.9,245.87 110.95,245.87 111.16,246.09 116.79,246.09 117.22,245.66 125.09,245.66 128.19,248.75 130.21,248.75 131.56,250.1 134.38,250.1 137.39,253.11 146.79,253.11 147.39,253.71 174.29,253.71 174.83,253.17 179.72,253.17 182.45,255.9 190.75,255.9 v1(191.26,255.4)
LANWAKE_N_FOX: length 4.7
  TOP w0.1: EU7A3.12 96.28,256.29 97.28,255.29 R7B15.2 R6B10.2
LANWAKE_R_N: length 3.2
  TOP w0.1: R7B24.1 95.42,250.11 R7B23.2 95.63,250.19 R7B18.2 97.02,250.32 R7B19.1
LANWAKE_SMC_WAKE_SCI_N: length 462.2
  TOP w0.089: 86.99,135.89 87.14,135.89 88.98,137.73 90.89,137.73 U6E1.BG44
  TOP w0.1: v1(83.18,132.21) 83.56,132.21 85.11,133.75 85.11,134.52 86.48,135.89 86.99,135.89 ; R8B19.2 v1(33.04,238.89) ; v1(10.16,99.44) 10.79,100.07 R9F35.2 11.55,99.69 11.34,99.48 11.34,98.82 ; R7B30.1 93.98,247.01 v1(94.74,247.78) 95.25,247.27 95.65,247.27 95.93,247.55 95.93,249.48 96.39,249.93 R7B23.1
  LAY5 w0.125: v1(83.18,132.21) 82.95,132.43 82.95,135.02 84.45,136.52 84.45,142.79 85.59,143.94 85.59,146.28 84.7,147.17 84.7,148.33 89.15,152.78 89.15,159.87 90.95,161.68 90.95,175.23 88.01,178.18 88.01,190.86 91.59,194.44 92.71,194.44 v1(93.21,194.94) ; v1(31.36,274.7) 32.63,273.43 32.63,259.46 35.05,257.05 35.05,252.58 35.91,251.71 39.61,251.71 41.13,253.24 43.68,253.24 v1(44.19,252.73) 48.13,252.73 49.3,253.9 52.66,253.9 53.04,254.28 59.45,254.28 59.83,253.9 62.81,253.9 63.22,253.49 65.63,253.49 66.52,254.38 70.68,254.38 71.44,255.15 74.19,255.15 77.63,251.71 81.2,251.71 83.51,249.4 85.24,249.4 87.62,247.02 93.85,247.02 94.61,247.78 v1(94.74,247.78)
  LAY6 w0.125: v1(33.04,238.89) 33.92,239.76 33.92,242.48 36.57,245.13 36.57,245.97 43.33,252.73 v1(44.19,252.73) ; v1(93.21,194.94) 93.59,194.94 94.73,196.08 94.73,198.14 93.59,199.28 93.59,208.41 91.94,210.06 91.94,239.77 94.74,242.57 v1(94.74,247.78) ; v1(31.36,274.7) 30.2,274.7 27.7,277.2 23.11,277.2 22.59,276.67 20.87,276.67 19.87,275.67 18.7,275.67 15.63,272.6 15.63,271.92 14.6,270.89 14.6,268.35 13.32,267.07 13.32,256.78 13.97,256.13 13.97,254.13 12.95,253.11 12.95,241.93 16.25,238.63 16.25,234.21 18.41,232.05 18.41,225.53 15.49,222.6 15.49,215.52 14.85,214.88 14.85,195.15 9.51,189.81 9.51,173.77 10.66,172.62 10.66,159.01 12.31,157.35 12.31,148.97 10.92,147.57 10.92,141.9 10.16,141.14 10.16,134.75 8.82,133.41 8.82,120.05 9.72,119.15 9.72,108.68 9.01,107.97 9.01,102.13 9.9,101.24 9.9,99.69 v1(10.16,99.44)
LATCH_BKFEEDCUT_BASE_DRV1: length 19.8
  TOP w0.1: Q8D5.1 30.73,191.26 31.24,191.77 31.62,191.77 32.13,192.28 32.13,193.8 v1(32.38,194.05) ; Q8C13.6 44.29,197.86 43.94,197.51 v1(43.94,196.09) R8D4.2
  LAY5 w0.125: v1(32.38,194.05) 33.52,195.2 37.21,195.2 37.52,195.51 41.71,195.51 42.29,196.09 v1(43.94,196.09)
LATCHED_BACKFEED_CUT: length 569.2
  TOP w0.1: v1(125.47,8.13) 125.73,8.13 R6J19.2 ; R9H10.2 v1(21.59,45.08) 22.35,45.85 R9H7.1 ; v1(173.35,55.37) 173.35,56.26 173.6,56.51 R4H21.1 ; Q8D5.3 30.6,192.91 30.22,192.53 30.22,189.86 R8D15.2 29.68,189.32 27.13,189.32 25.84,188.03 22.79,188.03 21.97,188.85 16.2,188.85 v1(15.69,189.36) ; R7B3.1 v1(60.96,257.43)
  LAY5 w0.125: v1(60.96,257.43) 59.71,257.43 58.44,258.7 55.06,258.7 53.64,257.28 39.64,257.28 34.16,262.76 34.16,265.81 v1(34.29,265.94) ; v1(173.35,55.37) 172.84,54.86 168.57,54.86 163.76,50.05 149.16,50.05 145.81,46.7 142.13,46.7 140.64,45.21 128.71,45.21 128.16,45.76 124.07,45.76 123.34,46.49 121.45,46.49 118.58,49.36 114.89,49.36 114.04,48.51 114.04,48 113.05,47.01 104.58,47.01 103.55,48.04 96.02,48.04 95.35,47.37 93.42,47.37 88.4,42.35 84.01,42.35 83.33,41.66 76.85,41.66 76.47,42.04 76,42.04 75.14,41.19 71.94,41.19 71.09,42.04 61.34,42.04 60.49,41.19 54.71,41.19 53.9,40.37 47.04,40.37 46.22,41.19 45.59,41.19 44.39,40 42.93,40 42.53,40.39 36.65,40.39 35.56,41.49 29.6,41.49 28.32,42.77 23.9,42.77 v1(21.59,45.08) 20.32,45.08 19.93,44.7 14.73,44.7 13.08,46.35 13.08,59.7 14.72,61.35 14.72,70.54 14.34,70.92 14.34,83.34 14.72,83.71 14.72,85.2 14.21,85.7 14.21,91.18 14.98,91.95 14.98,92.84 14.85,92.96 14.85,103.63 14.22,104.27 14.22,106.68 13.31,107.59 13.31,115.21 v1(12.7,115.82)
  LAY6 w0.125: v1(34.29,265.94) 30.68,265.94 29.21,264.46 27.73,264.46 24.7,261.43 24.7,245.12 22.86,243.28 22.86,241.43 23.24,241.04 23.24,240.03 22.61,239.4 21.58,239.4 20.82,238.64 20.82,233.71 21.2,233.33 21.2,224.91 23.11,223 23.11,217.97 23.86,217.22 23.86,213.26 23.17,212.56 23.17,204.86 22.14,203.83 21.33,203.83 19.81,202.31 19.81,196.21 15.69,192.09 v1(15.69,189.36) 15.69,188.42 14.84,187.57 14.84,169.54 15.72,168.67 15.72,158.27 16,157.99 16,144.91 15.87,144.78 15.87,139 14.47,137.61 14.47,137.03 12.7,135.25 12.7,133.22 10.7,131.23 10.7,121.1 11.66,120.14 11.66,116.86 v1(12.7,115.82) ; v1(173.35,55.37) 173.35,54.48 170.94,52.07 161.03,52.07 159.63,50.67 159.63,20.45 154.24,15.05 154.24,10.48 152.14,8.38 147.62,8.38 144.96,5.73 127.11,5.73 125.47,7.36 v1(125.47,8.13)
LATCHED_BACKFEED_CUT_EC: length 5.9
  TOP w0.1: R6J19.1 126.23,14.6 J6J2.101
LED_CAPS: length 2.8
  TOP w0.38: CR9G1.2 14.47,80.26 14.03,80.71 Q9G1.3
LED_DRIVE: length 150.6
  TOP w0.1: R9H12.2 21.97,43.94 20.95,44.96 20.95,45.46 21.78,46.29 21.78,48.7 R9H5.1 22.35,49.91 v1(22.22,50.04) ; R6F22.2 98.55,106.17 98.42,106.04 98.42,101.22 v1(99.06,100.58)
  LAY5 w0.125: v1(22.22,50.04) 24.63,47.62 25.4,47.62 27.08,45.94 31.02,45.94 32.38,44.57 35.6,44.57 36.86,45.83 42.28,45.83 43.19,46.73 44.17,46.73 44.43,46.47 54.75,46.47 55.64,47.36 57.8,47.36 58.56,48.13 61.1,48.13 61.74,48.76 72.15,48.76 73.3,49.91 77.11,49.91 78.39,51.18 81.94,51.18 84.18,53.43 86.12,53.43 86.66,52.88 90.09,52.88 90.82,53.62 92.76,53.62 93.43,54.29 95.38,54.29 97.61,56.51 v1(103.75,56.51)
  LAY6 w0.125: v1(103.75,56.51) 103.75,60.12 100.42,63.46 100.42,69.59 101.12,70.29 101.12,73.72 100.44,74.4 100.44,84.28 101.23,85.07 101.23,94.31 99.82,95.73 99.82,99.82 v1(99.06,100.58)
LED_DRIVE_BRD: length 3.1
  TOP w0.1: R9H10.1 R9H12.1 23.62,43.94 24.11,44.43 Q8H5.2
LED_DRIVE_HDR: length 3.1
  TOP w0.1: R9H5.2 R9H7.2 24,48.13 24.36,48.5 Q8H1.2
LED_NUM: length 2.8
  TOP w0.38: Q9G2.3 17.46,80.83 17.14,80.52 CR9G2.2
LED_SCROLL: length 3.2
  TOP w0.38: CR9G3.2 19.93,80.71 Q9G3.3
LED_SEG0: length 67.9
  TOP w0.1: v1(48.64,268.86) 48.64,268.87 48.42,269.08 DS8A3.10 48.42,272.2 ; DS8A4.10 56.68,271.87 55.75,272.79 49.02,272.79 48.42,272.2 ; 48.42,272.2 47.83,272.2 47.57,272.46 47.57,272.89 47.29,273.18 42.19,273.18 41.78,272.77 39.53,272.77 39.19,272.43 39.19,269.38 38.66,268.86 35.81,268.86 34.79,269.87 DS8A1.8 ; DS8A2.5 45.93,260.82 44.6,259.49 36.54,259.49 34.79,261.24 DS8A1.3 v1(34.79,263.52)
  BOTTOM w0.1: v1(34.79,263.52) 35.3,263.02 42.29,263.02 43.18,263.9 43.18,264.54 45.08,266.44 U8L1.4 48.13,266.44 48.38,266.7 48.38,268.6 v1(48.64,268.86) 49.27,268.86 49.78,268.35 R8L2.2
LED_SEG1: length 46.2
  TOP w0.1: DS8A2.8 43.05,269.75 45.13,267.66 48.46,267.66 v1(49.02,268.22) 49.86,269.07 DS8A3.9 49.86,272.14 50.29,272.57 55.34,272.57 55.75,272.16 55.75,269.62 56,269.37 57.65,269.37 58.12,269.83 DS8A4.9 ; v1(43.45,263.52) 43.43,263.52 43.05,263.14 DS8A2.3 43.05,260.35 42.64,259.94 38.1,259.94 37.67,260.36 DS8A1.5
  BOTTOM w0.1: R8L4.2 49.78,267.21 49.14,267.84 49.14,268.1 v1(49.02,268.22) 48.64,267.84 48.64,266.32 48.13,265.81 45.08,265.81 43.94,264.67 43.94,264.03 43.45,263.55 v1(43.45,263.52)
LED_SEG2: length 54.8
  TOP w0.1: DS8A4.5 62.44,263.18 62.1,263.52 v1(60.45,263.52) ; 40.17,269.62 40.37,269.62 40.76,269.23 40.76,268.98 42.03,267.71 44.7,267.71 44.98,267.43 48.89,267.43 v1(49.12,267.21) 51.3,269.39 DS8A3.8 ; 40.17,269.62 40.17,269.53 38.98,268.35 35.68,268.35 34.89,269.14 32.48,269.14 31.91,269.71 DS8A1.10 ; 40.17,269.62 DS8A2.10 ; DS8A3.3 v1(51.3,263.52)
  BOTTOM w0.1: v1(49.12,267.21) 49.14,267.18 49.14,266.44 R8L6.2 49.14,265.17 U8L1.6 45.84,265.17 45.72,265.05 45.72,263.52 45.84,263.4 51.18,263.4 v1(51.3,263.52) 51.81,263.02 59.94,263.02 v1(60.45,263.52)
LED_SEG3: length 70.8
  TOP w0.1: 59.56,261.87 v1(59.56,263.52) 59.56,263.78 60.96,265.17 62.48,265.17 62.99,265.68 62.99,269.11 63.37,269.49 63.37,272.29 63.11,272.54 59.81,272.54 59.56,272.29 59.56,269.49 v1(59.69,269.37) ; DS8A3.5 54.18,263.48 v1(54.22,263.52) ; v1(42.29,269.42) 41.98,269.42 41.61,269.79 DS8A2.9 41.61,272.2 41.27,272.54 39.62,272.54 39.42,272.34 39.42,269.29 38.7,268.58 35.77,268.58 34.98,269.37 33.78,269.37 33.35,269.79 DS8A1.9
  BOTTOM w0.1: U8L1.7 49.65,264.54 R8L7.2 50.29,264.16 51.56,264.16 52.19,263.52 v1(54.22,263.52) v1(59.56,263.52) ; v1(59.69,269.37) 59.69,269.49 57.4,271.78 44.65,271.78 v1(42.29,269.42)
LED_SEG4: length 37.6
  TOP w0.1: DS8A4.1 56.68,262.98 55.17,264.49 50.11,264.49 48.42,262.8 DS8A3.1 47.87,262.42 47.87,263.14 47.29,263.72 44.82,263.72 44.29,264.26 41.75,264.26 40.17,262.68 DS8A2.1 39.62,262.42 39.62,263.02 v1(39.11,263.52) 38.22,264.41 33.14,264.41 31.91,263.18 DS8A1.1
  BOTTOM w0.1: U8L1.11 40.51,265.17 39.24,263.9 39.24,263.65 v1(39.11,263.52)
LED_SEG5: length 48.3
  TOP w0.1: DS8A1.2 33.35,263.23 34.16,264.03 36.7,264.03 v1(37.21,263.52) 38.22,263.52 38.48,263.27 38.48,260.73 38.86,260.35 41.51,260.35 41.61,260.45 DS8A2.2 41.61,262.87 42.77,264.03 44.19,264.03 44.73,263.5 46.84,263.5 47.23,263.11 47.23,260.62 47.62,260.22 49.53,260.22 49.86,260.56 DS8A3.2 49.86,263 51.12,264.26 54.76,264.26 55.75,263.27 55.75,260.73 56,260.48 57.91,260.48 58.12,260.69 DS8A4.2
  BOTTOM w0.1: v1(37.21,263.52) 37.21,263.55 37.59,263.93 38.63,263.93 40.51,265.81 41.65,265.81
LED_SEG6: length 48.3
  TOP w0.1: v1(36.23,263.48) DS8A1.4 36.23,260.31 36.83,259.71 43.94,259.71 44.49,260.26 DS8A2.4 44.49,263.06 44.7,263.27 46.74,263.27 47,263.02 47,260.52 47.53,259.99 52.35,259.99 52.74,260.39 DS8A3.4 52.74,263.37 53.41,264.03 54.67,264.03 55.52,263.18 55.52,260.64 55.91,260.25 60.09,260.25 61,261.15 DS8A4.4
  BOTTOM w0.1: v1(36.23,263.48) 36.91,264.16 38.22,264.16 40.51,266.44 U8L1.13
LED_SEG7: length 47.5
  TOP w0.1: DS8A1.6 v1(37.67,269.37) ; DS8A3.6 54.18,269.41 v1(54.22,269.37) 55.36,269.37 55.81,268.91 59,268.91 59.43,268.48 61.08,268.48 62.44,269.83 DS8A4.6 ; DS8A2.6 45.93,269.61 v1(46.1,269.44)
  BOTTOM w0.1: U8L1.14 42.67,267.08 44.32,268.73 47.56,268.73 48.25,269.42 51.78,269.42 52.32,268.88 53.74,268.88 v1(54.22,269.37) 53.36,270.23 48.16,270.23 47.93,270 46.66,270 v1(46.1,269.44) 45.31,270.23 43.85,270.23 42.57,268.96 38.08,268.96 v1(37.67,269.37)
LED_SEG8: length 40.2
  TOP w0.1: v1(52.74,269.41) DS8A3.7 52.74,271.88 53.21,272.34 55.25,272.34 55.52,272.07 55.52,269.53 55.91,269.14 59.09,269.14 59.53,268.7 60.17,268.7 61,269.54 DS8A4.7 ; v1(44.06,269.44) 44.49,269.86 DS8A2.7 ; DS8A1.7 v1(36.23,269.41)
  BOTTOM w0.1: v1(36.23,269.41) 36.91,268.73 42.67,268.73 43.38,269.44 v1(44.06,269.44) ; U8L1.15 42.92,267.71 44.06,268.86 v1(44.06,269.44) ; v1(52.74,269.41) 52.51,269.65 48.16,269.65 47.47,268.96 44.72,268.96 44.24,269.44 v1(44.06,269.44)
LEDD1: length 1.6
  TOP w0.38: CR9G1.1 14.47,76.83 14.98,76.33 R9G26.2
LEDD2: length 1.7
  TOP w0.38: CR9G3.1 19.93,76.83 19.3,76.2 R9G28.2
LEDD3: length 1.4
  TOP w0.38: CR9G2.1 17.14,76.71 17.01,76.58 R9G27.2
LFRAME_ESPI_CS0_EC_AIC_N: length 127.1
  TOP w0.1: J6J2.187 140.3,18.22 140.3,22.68 139.31,23.67 137.35,23.67 134.49,26.52 116.46,26.52 113.26,29.72 113.26,34.46 112.27,35.45 104.92,35.45 v1(103.25,33.78)
  LAY8 w0.1: v1(87.8,92.84) 88.9,91.74 88.9,90.34 91.31,87.93 91.31,78.23 91.94,77.6 91.94,68.14 93.09,66.99 93.09,59.97 94.7,58.36 94.7,54.69 94.8,54.59 96.3,54.59 96.4,54.49 96.4,54.29 96.3,54.19 94.8,54.19 94.7,54.09 94.7,52.49 94.8,52.39 95.25,52.39 95.35,52.29 95.35,52.09 95.25,51.99 94.8,51.99 94.7,51.89 94.7,51.69 94.8,51.59 95.25,51.59 95.35,51.49 95.35,51.29 95.25,51.19 94.8,51.19 94.7,51.09 94.7,50.89 94.8,50.79 95.25,50.79 95.35,50.69 95.35,50.49 95.25,50.39 94.8,50.39 94.7,50.29 94.7,50.09 94.8,49.99 95.25,49.99 95.35,49.89 95.35,49.69 95.25,49.59 94.8,49.59 94.7,49.49 94.7,49.09 95.32,48.47 95.32,39.06 95.58,38.8 95.58,37.24 98.01,34.82 102.2,34.82 v1(103.25,33.78)
  BOTTOM w0.1: R7U10.2 87.8,93.29 v1(87.8,92.84)
LFRAME_ESPI_CS0_EC_N: length 127.7
  TOP w0.1: U8F6.58 18.99,94.69 19.4,95.09 23.7,95.09 25.89,97.28 27.94,97.28 28.19,97.53 28.19,99.02 28.48,99.31 v1(28.73,99.31)
  LAY3 w0.1: v1(62.73,120.39) 61.95,119.61 61.95,115.95 68.37,109.52 68.37,106.25 80.53,94.09 84.56,94.09 v1(85.06,93.6)
  BOTTOM w0.1: v1(28.73,99.31) 29.21,99.78 29.21,101.04 32.53,104.37 32.53,105.31 34.41,107.19 35.91,107.19 36.26,106.84 38.72,106.84 45.08,113.2 45.08,113.92 47.62,116.46 55.64,116.46 64.81,125.62 64.95,125.62 65.12,125.45 65.12,125.3 61.41,121.59 61.41,121.45 61.55,121.31 61.7,121.31 65.66,125.27 65.8,125.27 65.94,125.13 65.94,124.99 61.99,121.03 61.99,120.89 62.13,120.75 62.27,120.75 64.48,122.96 64.62,122.96 64.89,122.69 64.89,122.55 v1(62.73,120.39) ; R7U11.2 v1(85.06,93.6)
