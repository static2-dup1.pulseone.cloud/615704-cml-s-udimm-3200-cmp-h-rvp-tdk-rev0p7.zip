# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+V3P3S_ALS: length 42.4
  TOP w0.2: 253.49,268.86 253.54,268.81 EU2A7.24 253.9,269.33 253.49,269.75 ; EU2A7.1 259.46,263.73 259.58,263.61 259.58,263.14
  TOP w0.35: 251.2,270.25 C2A11.1 250.57,270.25 250.19,270.64 R2A34.1
  TOP w0.38: 252.22,270.25 C2A12.1 251.2,270.25 ; v1(247.62,268.86) R2A38.1 R2A39.1 R2A41.1 R2A44.1 ; R2A34.1 249.8,269.75 ; R2A61.1 v1(249.93,262.25) ; R2A45.1 R2A52.1 v1(262.76,264.67) ; 259.58,263.14 259.58,262.76 v1(258.95,262.13) C2A27.1
  LAY6 w0.5: v1(247.62,268.86) 247.65,268.83 247.65,267.08 248.66,266.06 ; 248.66,266.06 250.57,266.06 251.4,265.23 258.26,265.23 259.2,264.29 261.36,264.29 261.74,264.67 v1(262.76,264.67) ; 248.66,266.06 248.41,265.81 248.41,262.76 248.92,262.25 v1(249.93,262.25)
  BOTTOM w0.5: v1(262.76,264.67) 261.49,264.67 v1(258.95,262.13)
+V3P3S_DP1_PWR: length 1.1
  TOP w0.3: R2A6.2 276.35,277.24
+V3P3S_PCIE_SLOT2: length 37.9
  TOP w0.38: R8B32.2 51.68,235.71 ; R8C20.1 Q8C2.1 v1(32.25,219.58)
  BOTTOM w0.38: C8B20.1 46.48,238.63 44.57,236.73 43.43,236.73 42.54,237.62 39.11,237.62 37.97,236.47 37.08,236.47 36.32,235.71 36.32,220.47 35.43,219.58 v1(32.25,219.58)
+V3P3S_PCIE_SLOT2_R: length 1.6
  TOP w0.38: U8B2.5 51.68,230.81 R8B32.1
+V3P3S_PCIE_SLOT3: length 22.7
  TOP w0.38: 29.21,235.46 29.18,235.43 R8B31.2 ; v1(28.82,219.84) Q8C1.1 R8C19.1
  BOTTOM w0.5: v1(30.73,236.85) 31.11,236.47 31.11,231.27 29.46,229.61 29.46,228.22 30.22,227.46 30.22,224.28 28.82,222.88 v1(28.82,219.84)
+V3P3S_PCIE_SLOT3_R: length 1.5
  TOP w0.3: U8B1.5 29.18,230.83 R8B31.1
+V3P3S_PCON: length 54.3
  TOP w0.305: U3A5.E3 241.59,267.99 v1(241.19,267.59) 241.6,267.19 U3A5.D3
  TOP w0.38: v1(276.35,264.67) 276.47,264.54 CR2A4.1 276.09,263.4 R2A65.1
  TOP w0.5: U2B1.8 247.65,256.28 248.41,257.05 248.41,260.6 247.65,261.36 R2A62.1 247.49,261.87 246.86,262.51 R2A60.1 v1(246.63,263.27) ; v1(246.12,268.22) 246.12,269.24 R2A35.1
  LAY5 w0.38: v1(276.35,264.67) 275.59,263.9 271.52,263.9 271.01,264.41 269.87,264.41 268.09,262.63 v1(265.04,262.63)
  BOTTOM w0.1: v1(241.19,267.59) 241.2,267.59
  BOTTOM w0.38: v1(265.04,262.63) 264.92,262.76 261.49,262.76 259.2,260.48 249.42,260.48 v1(246.63,263.27)
  BOTTOM w0.5: v1(246.63,263.27) 247.77,264.41 247.77,265.81 246.76,266.83 R2L1.1
+V3P3S_PCON_AVDD: length 13
  TOP w0.305: v1(241.19,265.99) 240.81,266.38 240.81,266.39 ; U3A5.G2 242.41,269.59 v1(242.79,269.98) ; U3A5.B2 242.41,265.59 v1(242.81,265.99) ; v1(241.19,269.98) 240.81,269.59 240.81,269.59
  LAY6 w0.38: v1(242.81,265.99) 243.33,266.51 243.33,269.44 v1(242.79,269.98) v1(241.19,269.98)
  BOTTOM w0.38: v1(242.81,265.99) 242.82,265.97 C3L10.1 C3L11.1 241.93,265.56 241.49,265.99 v1(241.19,265.99) ; v1(241.19,269.98) 241.34,270.13 C3L3.1 242.64,270.13 v1(242.79,269.98)
+V3P3S_PEG_SLOT: length 117.7
  TOP w0.38: C6B6.1 128.9,239.01 R6B24.2 ; v1(148.08,165.73) R5D37.1 148.08,164.34 148.14,164.27 Q5D2.1 ; v1(128.77,228.75) 127.66,228.75 127.35,228.45 127.35,223.03 127.73,222.66 128.62,222.66 Q6C1.1 ; Q5B1.1 149.35,238.94 149.09,238.68 149.09,236.7 v1(148.61,236.22) 148.08,236.22 R5B39.1 R5B38.1 147.19,236.25 J5B2.A10 144.78,238.65 J5B2.A9 142.78,239.65 J5B2.B8
  LAY6 w0.38: v1(148.61,236.22) 149.22,235.61 149.22,235.2 150.36,234.06 150.74,234.06 151.24,233.56 151.24,232.66 150.77,232.19 150.77,227.56 152.78,225.55 152.78,217.3 151.89,216.41 151,216.41 150.36,215.77 150.36,207.52 151.51,206.37 151.51,203.58 150.49,202.56 150.49,199.39 149.6,198.5 148.84,198.5 148.46,198.12 148.46,197.61 148.71,197.36 148.71,196.21 148.56,196.06 148.56,191.24 148.2,190.88 148.2,189.86 148.71,189.36 148.71,186.43 148.56,186.28 148.56,166.22 v1(148.08,165.73) ; C6B6.1 129.54,238.38 129.54,229.49 128.8,228.75 v1(128.77,228.75)
+V3P3S_PEG_SLOT_R: length 1.8
  TOP w0.3: EU6B3.5 122.88,239.01 R6B24.1
+V3P3S_R: length 11.5
  TOP w1: R4G21.1 205.74,72.64 207.51,70.86 210.31,70.86 212.97,68.2 212.97,66.29
+V3P3S_V1P8S_GSP1: length 10.5
  TOP w0.508: R9H17.1 R9H16.1 R9H14.1 R9H11.1 R9H9.1 R9H8.1 R9H6.1
+V3P3S_V1P8S_GSPI0: length 9.4
  TOP w0.508: R9J6.1 R9J9.1 R9J12.1 R9J13.1 R9J15.1 R9J17.1 R9J19.1
+V3P3S_V1P8S_UART0: length 6.5
  TOP w0.508: R9H21.1 R9J1.1 R9J3.1 R9J5.1 R9J8.1 R9J11.1
+V3P3S_VAL: length 609.4
  TOP w0.38: v1(68.19,65.28) 68.58,64.9 R7H1.1 ; R2A8.1 277.52,273.53 v1(275.84,273.53) ; v1(58.92,38.86) R8H62.1 R8H63.1
  TOP w0.508: v1(224.15,59.69) 222.12,57.66 R3H18.1
  LAY5 w0.5: v1(237.49,83.82) 237.51,83.84 247.49,83.84 v1(247.52,83.82) ; v1(224.15,59.69) 223.92,59.92 214.65,59.92 212.21,62.36 212.21,63.12 211.31,64.02 197.62,64.02 195.43,61.83 195.43,56.2 194.67,55.44 186.75,55.44 185.74,54.42 178.5,54.42 174.37,50.29 166.91,50.29 164.72,48.1 160.93,48.1 155.18,42.34 150.89,42.34 150.72,42.51 126.77,42.51 126.09,43.18 121.83,43.18 121.68,43.03 92.18,43.03 86.71,37.56 80.89,37.56 80.39,38.07 75.89,38.07 74.97,38.99 65.4,38.99 v1(65.27,38.86) 64.6,38.18 59.6,38.18 v1(58.92,38.86)
  LAY6 w0.38: v1(68.19,65.28) 67.31,64.39 67.31,59.21 67.81,58.7 67.81,52.35 69.17,50.99 69.17,40.1 68.58,39.5 65.91,39.5 v1(65.27,38.86) ; v1(245.99,53.97) 248.92,53.97 251.26,51.62 262.65,51.62 264.68,49.59 281.68,49.59 282.95,50.86 282.95,51.9 283.61,52.55 285.09,52.55 287.27,54.74 287.27,65.53 293.74,72 293.74,88.98 295.17,90.4 295.17,96.11 292.41,98.87 292.41,100.95 286.79,106.57 286.79,135.54 286.39,135.93 286.39,145.83 285.36,146.86 285.36,149.22 286.89,150.75 286.89,156.34 287.52,156.97 287.52,163.7 286.63,164.59 286.63,165.71 287.04,166.11 288.79,166.11 290.96,168.28 290.96,173.06 291.97,174.07 291.97,190.45 286.76,195.66 286.76,198.25 285.11,199.9 285.11,217.17 289.43,221.49 291.59,221.49 v1(293.75,223.65)
  BOTTOM w0.38: 227.71,80.39 226.69,81.41 v1(226.69,81.79) ; v1(275.84,273.53) 280.28,269.09 280.28,267.97 284.86,263.4 284.86,257.94 287.14,255.65 287.14,255.27 293.24,249.17 293.24,246.38 294.51,245.11 294.51,242.06 296.62,239.95 296.62,223.47 296.03,222.88 294.51,222.88 v1(293.75,223.65)
  BOTTOM w0.5: v1(58.92,38.86) 52.45,32.38 49.65,32.38 J8J1.1 ; v1(247.52,83.82) 247.52,79.25 249.42,77.34 249.42,75.56 247.52,73.66 247.52,58.42 245.99,56.89 v1(245.99,53.97) ; 227.71,80.39 227.71,75.18 231.52,71.37 231.52,66.67 234.31,63.88 234.31,61.59 233.42,60.7 225.29,60.7 224.51,59.92 224.38,59.92 v1(224.15,59.69)
  vias: v1(205.23,80.52) v1(205.74,86.74) v1(206.24,80.52) v1(206.5,82.29) v1(214.24,83.56) v1(217.29,85.6) v1(221.74,82.55) v1(222.5,86.36)
+V3P.3A_WWAN_SAR: length 2.7
  TOP w0.275: R7H47.1 62.46,52.85 J8H2.37
+V5.0DX_SSD: length 0.9
  TOP w0.38: 108.96,7.49 108.83,7.36 R6J31.2
  vias: v1(109.85,8.53) v1(110.87,8.13) v1(110.87,7.42) v1(123.52,7.49) v1(124.25,7.49) v1(124.96,7.49)
+V5_AUDIO: length 142
  TOP w0.5: R8A24.2 27.3,269.62 v1(27.55,269.37) ; R9A25.2 12.19,259.84 12.7,260.35 v1(12.7,260.86) ; 112.52,286.38 R6A4.1 ; 112.52,286.38 R6A3.2 ; 112.52,286.38 112.39,286.51 ; R8B14.1 v1(27.05,244.09)
  LAY5 w0.75: v1(100.33,287.27) 98.42,289.18 63.91,289.18 61.08,286.35 61.08,285.75 56.76,281.43 50.03,281.43 48.76,282.7 46.1,282.7 40.66,277.26 26.31,277.26 23.49,274.45
  BOTTOM w0.5: v1(27.05,244.09) 27.55,244.6 27.55,248.03 28,248.47 28,250.82 27.71,251.11 27.71,254.3 27.17,254.84 27.17,255.9 25.65,257.43 25.65,267.33 27.55,269.24 v1(27.55,269.37) ; v1(12.7,260.86) 13.15,261.31 13.15,269.11 14.09,270.05 14.09,270.64 14.75,271.3 15.46,271.3 16.12,270.64 16.12,269.24 17.52,267.84 18.66,267.84 19.05,268.22 22.98,268.22 23.49,268.73 v1(23.49,269.72)
  vias: v1(100.96,286.76)
+V5_AUDIO_I2S1: length 6.3
  TOP w0.5: R8A24.1 C8A4.1 24.69,270.64 24.19,270.14 24.19,269.3 22.22,267.33 J9A5.4
+V5_AUDIO_R: length 1.4
  TOP w0.5: R6A3.1 108.83,286.38
+V5_AUDIO_SDW: length 3.7
  TOP w0.5: J9B1.8 22.47,245.11 C8B11.1 24.76,244.09
+V5_V12S_AUDIO_JA: length 16.1
  TOP w0.5: v1(8.63,258.7) R9B2.1 R9A25.1 C9A3.1 9.27,260.86 9.01,260.6 J9A4.10 ; J9A4.14 8.89,255.52 9.65,254.76 9.9,254.76 C9B1.1 10.16,254.43 v1(9.47,253.74)
  BOTTOM w0.5: v1(8.63,258.7) 8.63,254.58 v1(9.47,253.74)
+V5A: length 696.5
  TOP w0.25: 28.89,184.72 28.69,184.52 U8D2.1 ; U8B1.1 27.95,229.48 27.7,229.23 ; EU6B3.1 121.16,237.12 v1(120.65,236.6)
  TOP w0.3: C8B4.1 EU8B4.1
  TOP w0.38: 288.41,242.57 288.41,242.7 287.78,243.33 287.78,245.87 287.52,246.12 287.52,252.09 288.54,253.11 289.3,253.11 289.87,252.54 291.54,252.54 291.84,252.84 292.73,252.84 293.24,253.35 R1B2.1 v1(294,254.13) ; 288.41,242.57 288.41,237.87 289.14,237.14 289.14,234.28 288.16,233.3 R1B36.2 ; 288.41,242.57 289.3,242.57 v1(290.06,241.81) ; R8H33.1 v1(30.09,49.4) ; C6B8.1 120.26,236.98 v1(120.65,236.6) ; v1(82.14,89.84) 82.67,89.3 C7G2.1 82.67,88.77 U7G1.14 ; R4C15.2 178.94,209.17 179.83,208.28 179.83,206.88 181.35,205.36 C4C11.1 181.61,205.87 182.75,207.01 186.18,207.01 186.81,206.37 186.81,204.72 ; v1(271.9,236.09) 271.9,235.84 272.28,235.46 R2B39.2 ; v1(58.42,256.92) C8B2.1 57.4,256.67 EU8B1.1 ; v1(108.83,251.84) 108.83,251.97 109.6,252.73 112.9,252.73 113.41,252.22 C6B3.1 113.53,251.71 EU6B1.1 ; v1(31.75,255.65) C8B4.1 ; v1(56.13,83.95) 55.55,83.95 R8G35.2 55.55,84.71 v1(56.13,84.71) ; v1(276.47,213.74) 273.68,216.53 R2C22.1 ; R8H48.2 v1(30.09,43.56) ; v1(30.09,47.12) R8H36.1 R8H41.1 ; v1(27.43,230.5) 27.4,230.5 27.02,230.12 C8B32.1 26.77,229.64 v1(27.05,229.36) 27.17,229.23 27.7,229.23 ; EU1E2.1 C1E11.1 293.62,137.16 293.24,136.78 v1(291.71,136.78) ; U8B2.1 50.15,229.63 49.91,229.87 C8B34.1 v1(49.27,229.11) ; v1(154.58,234.57) R5B89.1 153.54,234.03 v1(153.16,233.64) ; v1(285.75,250.7) 285.87,250.57 R1B3.1 ; v1(83.04,80.71) 82.86,80.71 82.24,81.33 82.24,82.09 C7G5.1 U7G2.14 ; 28.89,184.72 29.46,185.29 C8D9.1
  TOP w0.5: v1(248.76,211.2) 248.76,212.32 251.2,214.76 268.6,214.76 272.92,210.44 274.32,210.44 274.82,210.94 274.82,212.09 v1(276.47,213.74) ; R6A18.1 v1(114.93,281.56) ; v1(59.43,76.02) 59.43,76.2 57.91,77.72 57.91,83.06 v1(57.02,83.95)
  TOP w0.508: v1(30.98,186.82) C8D10.1 C8D9.1 ; v1(161.69,242.97) 161.69,242.6 R5B72.1
  LAY5 w0.5: v1(57.65,281.18) 61.03,284.55 63.44,284.55 67.19,288.3 97.9,288.3 101.15,285.05 101.15,281.02 101.65,280.52 104.7,280.52 105.36,281.18 114.55,281.18 v1(114.93,281.56)
  LAY5 w0.508: 156.38,233.88 158.11,233.88 158.62,234.39 158.62,235.71 160.65,237.74 160.65,241.93 v1(161.69,242.97) ; 210.56,248.03 193.04,248.03 v1(192.53,248.54)
  LAY5 w1: 188.46,207.23 188.46,208.79 180.45,216.8 180.45,219.19 181.35,220.09 181.35,224 179.13,226.22 179.13,227.01 178.18,227.96 176.4,227.96 174.74,226.3 170.82,226.3 165.86,231.27 156.82,231.27 156.15,231.94 156.15,233.01 ; 106.68,237.23 106.68,238.63 v1(105.53,239.77) 100.82,239.77 99.53,238.48 97.79,238.48 97.4,238.1 90.67,238.1 90.19,238.58 87.57,238.58 86.73,237.74 85.35,237.74 83.84,239.24 81.63,239.24 81.28,238.89 79.62,238.89 77.47,241.04 72.5,241.04 ; 138.08,244.6 133.76,240.28 129.03,240.28 127.63,238.89 127.63,236.98 126.22,235.57 121.29,235.57
  LAY6 w0.38: v1(285.75,250.7) 288.16,250.7 290.7,253.24 293.11,253.24 v1(294,254.13) ; v1(290.06,241.81) 290.57,241.81 292.22,240.16 292.22,238.78 295.42,235.58 295.42,223.29 293.49,221.36 292.98,221.36 291.14,219.52 291.14,217.61 288.16,214.63 v1(287.29,214.63) 287.29,199.11 291.08,195.32 291.08,192.06 292.48,190.66 292.48,173.86 291.47,172.85 291.47,168.07 291.04,167.64 291.04,166.03 291.31,165.76 291.31,158.9 292.83,157.38 292.83,147.32 292.48,146.97 292.48,140.6 291.84,139.95 291.84,138.68 291.08,137.92 291.08,137.16 291.46,136.78 v1(291.71,136.78) ; v1(108.83,251.84) 108.83,249.47 106.15,246.79 106.15,245.1 105.41,244.35 105.41,239.9 v1(105.53,239.77) ; v1(83.04,80.71) 82.77,80.71 82.39,81.09 82.39,84.19 82.6,84.4 82.6,85.06 82.21,85.44 82.21,86.15 82.67,86.61 82.67,89.3 v1(82.14,89.84) ; v1(271.9,236.09) 270.25,237.74 270.25,241.55 269.74,242.06 269.74,243.2 v1(270.51,243.97)
  LAY6 w0.5: v1(58.42,256.92) 58.68,256.92 59.18,257.42 59.18,259.59 63.05,263.46 63.05,266.27 66.6,269.82 66.6,273.15 63.47,276.28 58.61,276.28 57.65,277.24 v1(57.65,281.18)
  BOTTOM w0.38: v1(49.27,229.11) 51.05,230.88 51.05,234.06 52.79,235.8 52.79,240.61 53.7,241.53 53.7,247.01 54.26,247.57 v1(54.86,247.57) ; v1(234.44,249.43) R3M9.1 R3M10.1 ; R4M10.1 R4M9.1 189.1,249.3 191.77,249.3 v1(192.53,248.54) ; v1(33.14,245.24) 33.14,254.51 32,255.65 v1(31.75,255.65) ; 210.05,248.28 R3M11.1 ; 210.05,248.28 v1(210.05,249.3) ; 210.05,248.28 R3M12.1
  BOTTOM w0.5: v1(82.14,89.84) 81.92,90.05 80.36,90.05 79.22,91.19 75.54,91.19 75.18,91.55 70.47,91.55 69.7,90.78 69.7,88.37 66.04,84.71 60.19,84.71 59.56,85.34 57.65,85.34 v1(57.02,84.71) ; v1(287.29,214.63) 282.14,214.63 281.13,213.61 276.6,213.61 v1(276.47,213.74) ; v1(58.42,256.92) 58.42,252.6 54.86,249.05 v1(54.86,247.57) ; v1(257.68,249.43) R2M1.1 R2M2.1 ; v1(30.09,43.56) 29.33,44.32 29.33,46.35 v1(30.09,47.12) v1(30.09,49.4) 28.57,50.93 28.57,53.85 29.21,54.48 29.21,60.83 29.97,61.59 32.63,61.59 33.42,60.81 41.68,60.81 41.91,60.58 43.81,60.58 46.99,63.75 46.99,64.64 51.81,69.47 53.69,69.47 54.58,70.36 55.37,70.36 56.76,71.75 57.91,71.75 59.94,73.79 59.94,75.51 v1(59.43,76.02)
  vias: v1(31.81,186.75) v1(48,177.16) v1(48,176.27) v1(49.65,171.7) v1(186.43,204.14) v1(190.24,207.52) v1(248.15,210.56) v1(258.44,249.43)
+V5A_R: length 1.8
  TOP w0.3: 52.83,84.33 R8G35.1 53.72,83.44
+V5A_VAL: length 338.4
  TOP w0.38: J6J2.67 v1(122.38,18.37)
  TOP w0.5: C7H9.1 C7H10.1 83.43,35.94 J7J1.6 83.18,33.15 v1(82.04,32) ; v1(110.1,30.73) 111.37,29.46 J7J1.27 ; 298.57,93.09 298.57,92.84 296.54,90.8 287.78,90.8 v1(287.4,91.18)
  TOP w0.508: R7H71.2 81.02,36.57 C7H9.1 ; v1(303.27,92.45) 303.02,92.2 299.46,92.2 298.57,93.09
  LAY5 w0.5: v1(82.04,32) 102.74,32 103.96,30.78 v1(105.02,30.78) 110.05,30.78 v1(110.1,30.73) ; v1(287.4,91.18) 282.3,86.09 282.3,81.3 278.63,77.63 278.63,73 275.87,70.23 264.92,70.23 264.16,69.47 244.09,69.47 240.5,73.06 198.07,73.06 197.08,72.07 178.62,72.07 168.78,62.23 168.78,59.83 163.26,54.31 148.8,54.31 144.2,49.71 135.83,49.71 134.9,50.65 129.59,50.65 128.48,51.76 127.02,51.76 126.26,51 123.89,51 121.94,52.95 v1(106.29,52.95)
  LAY6 w0.38: v1(105.02,30.78) v1(105.02,22.99)
  LAY6 w0.5: v1(105.02,30.78) 105.99,31.75 105.99,34.87 107.06,35.94 107.06,52.16 106.29,52.93 v1(106.29,52.95)
  BOTTOM w0.38: v1(303.27,92.45) 302.26,93.47 302.26,106.3 v1(301.75,106.81) ; v1(122.38,18.37) 121.67,17.65 118.49,17.65 117.6,18.54 117.6,21.97 114.92,24.65 113.29,24.65 112,23.35 107.41,23.35 106.41,22.35 105.41,22.35 105.02,22.73 v1(105.02,22.99)
+V5DSW: length 557.6
  TOP w0.25: C6A28.1 107.42,275.32 U6A3.1 ; U8G3.1 49.52,68.44 49.78,68.71
  TOP w0.38: C6A28.1 107.56,275.21 v1(108.07,275.72) ; v1(45.21,97.92) 45.84,97.92 R8F54.1 ; R3G34.2 213.1,76.33 ; R8G16.1 54.73,90.8 54.07,91.46 v1(53.84,91.46) ; R8G37.1 49.4,83.69 50.92,82.17 50.92,81.53 51.43,81.02 52.7,81.02 ; Q8G4.2 54.48,81.53 54.48,81.4 54.1,81.02 52.7,81.02 ; 52.7,81.02 52.7,80.01 53.08,79.63 54.86,79.63 55.75,78.74 55.75,76.96 54.99,76.2 54.99,74.55 54.1,73.66 54.1,71.5 53.59,70.99 51.18,70.99 50.03,69.85 C8G14.1 49.78,68.71 ; 48.79,85.85 R8G28.1 49.27,84.96 ; R4H5.1 196.72,59.94 v1(194.18,59.94) ; EU4B2.1 173.62,257.57 C4B3.1 171.95,257.68 170.94,256.67 170.94,256.41 170.2,255.67 169.18,255.67 168.5,254.99 163.6,254.99 162.43,256.16 155.06,256.16 153,254.1 147.91,254.1 145.46,251.64 127.01,251.64 125.93,252.73 v1(120.39,252.73) ; Q4G4.2 182.88,77.98 183.26,78.36 183.26,80.52 182.75,81.02 v1(180.97,81.02) ; v1(48.89,197.1) 48.64,196.85 48.13,196.85 46.6,195.32 R8C83.1 ; R8D34.1 32.13,183.77 32.63,184.27 v1(32.63,186.05) C8D11.1 ; R4G8.1 v1(174.11,92.2) ; R8D38.1 v1(44.85,183.51)
  TOP w0.5: R5G5.1 158.11,96.29 v1(158.06,96.34)
  TOP w0.508: 182.88,52.96 C4H12.1 ; 182.88,52.96 C4H10.1 ; 182.88,52.96 182.85,52.96 182.62,52.73 182.62,51.81 ; R4H47.1 175.26,50.16 175.13,50.29 v1(175.13,52.07) ; 182.62,51.81 183.26,51.81 184.02,52.58 184.02,55.24 v1(184.15,55.37) ; 182.62,51.81 R4H34.1 ; R4H26.1 v1(174.24,55.37) ; C4G25.1 182.88,76.46 Q4G4.2
  LAY5 w0.38: v1(45.21,97.92) v1(45.21,98.68) ; v1(194.18,59.94) 194.87,59.26 194.87,56.44 194.43,56.01 186.52,56.01 185.88,55.37 v1(184.15,55.37)
  LAY5 w0.5: v1(44.85,183.51) 43.94,182.6 43.94,170.05 45.23,168.76 45.23,137.06 44.57,136.4 44.57,119.25 47.11,116.71 47.11,101.47 45.21,99.57 v1(45.21,98.68) ; v1(48.89,197.1) 48.64,196.85 48,196.85 R8C83.1 42.9,195.32 42.54,194.97 38.24,194.97 37.08,193.8 33.4,193.8 v1(32.63,193.04) ; v1(58.29,84.58) 60.09,84.58 63.78,88.26 66.29,88.26 66.7,87.86 68.96,87.86 69.62,88.52 71.95,88.52 v1(72.51,89.08)
  LAY6 w0.38: v1(108.07,275.72) 110.1,277.75 110.1,278.84 108.78,280.16 100.96,280.16 99.69,278.89 86.74,278.89 85.59,277.75 64.51,277.75 63.37,278.89 v1(60.96,278.89)
  LAY6 w0.5: v1(73.53,82.73) 73.91,83.11 73.91,87.68 v1(72.51,89.08) ; v1(158.06,96.34) 158.62,96.9 170.94,96.9 171.95,95.88 171.95,94.36 v1(174.11,92.2)
  BOTTOM w0.38: U7U2.14 73.78,82.17 73.66,82.04 73.02,82.04 C7U3.1 72.55,82.55 72.66,82.65 73.45,82.65 v1(73.53,82.73) ; v1(108.07,275.72) 109.85,273.94 109.85,268.71 108.07,266.93 108.07,263.52 108.45,263.14 109.47,263.14 109.85,262.76 109.85,260.17 108.58,258.9 108.58,255.14 109.98,253.74 119.76,253.74 120.39,253.11 v1(120.39,252.73) ; v1(72.51,89.08) 72.72,89.08 72.77,89.03 C7U2.1 73.53,88.77 U7U1.14
  BOTTOM w0.5: v1(179.45,82.55) 179.45,83.06 178.68,83.82 178.68,87.63 v1(174.11,92.2) ; v1(32.63,186.05) 34.92,186.05 37.59,183.39 44.73,183.39 v1(44.85,183.51) ; v1(48.89,197.1) 51.05,197.1 51.94,197.99 51.94,202.56 55.88,206.5 55.88,236.22 55.24,236.85 55.24,242.06 55.88,242.7 55.88,244.47 55.57,244.78 55.57,246.58 61.89,252.9 61.89,260.36 64.47,262.94 64.47,267.95 60.7,271.72 60.7,277.62 60.96,277.87 v1(60.96,278.89) ; v1(174.24,55.37) 175,56.13 175,58.67 173.48,60.2 173.48,70.61 175.76,72.9 175.76,77.47 177.72,79.42 177.72,80.31 v1(178.43,81.02)
  BOTTOM w0.508: v1(174.24,55.37) 175.13,54.48 v1(175.13,52.07) 175.13,49.4 175.89,48.64 176.91,48.64 181.22,52.96 182.24,52.96 184.15,54.86 v1(184.15,55.37)
  vias: v1(44.45,98.68) v1(44.45,97.92) v1(44.45,97.2) v1(45.21,97.2) v1(46.73,86.36) v1(46.73,85.6) v1(47.49,86.36) v1(47.49,85.6) v1(48.26,86.36) v1(48.26,85.6) v1(178.43,82.55) v1(178.43,81.79) v1(179.45,81.79) v1(179.45,81.02) v1(180.21,82.55) v1(180.21,81.79) v1(180.21,81.02) v1(180.97,82.55) v1(180.97,81.79) v1(207.26,77.85) v1(207.26,77.09) v1(207.26,76.33) v1(208.02,77.85) v1(208.02,77.09) v1(208.02,76.33) v1(208.78,77.85) v1(208.78,77.09) v1(208.78,76.33) v1(211.45,77.85) v1(211.45,77.09) v1(211.45,76.33) v1(212.21,77.85) v1(212.21,77.09) v1(212.21,76.33)
+V5DSW_R: length 142.1
  TOP w0.38: 211.96,73.28 211.96,73.66 v1(211.7,73.91) ; R3G34.1 213.1,72.26 ; v1(270.25,74.17) R2G40.1 C2G27.1 C2G26.1 267.97,73.28 267.46,72.77 U2G3.1 ; R7H63.1 v1(77.34,42.92)
  LAY5 w0.38: v1(270.25,74.17) 268.6,74.17 266.82,72.39 254.1,72.39 253.34,71.63 248.83,71.63 243.88,76.58 226.27,76.58 225.51,75.83 212.86,75.83 211.7,74.67 v1(211.7,73.91)
  BOTTOM w0.38: J9J4.1 24,20.7 26.67,23.37 27.81,23.37 29.23,24.79 32.66,24.79 35.17,27.3 41.14,27.3 43.81,24.64 47.75,24.64 49.21,23.17 52.59,23.17 53.48,24.06 57.46,24.06 60.57,27.18 60.57,30.35 69.46,39.24 69.46,41.78 72.51,44.83 75.43,44.83 v1(77.34,42.92)
  vias: v1(43.1,138.56) v1(43.1,137.79) v1(43.43,165.81) v1(43.45,165.05) v1(43.45,164.11) v1(43.81,157.48) v1(43.81,156.68) v1(43.81,155.54) v1(43.81,147.54) v1(43.81,146.52) v1(43.81,138.56) v1(43.81,137.79) v1(43.81,137) v1(43.81,129.51) v1(43.81,128.78) v1(43.81,128.01) v1(44.57,147.54) v1(211.96,71.12) v1(212.85,71.12) v1(213.74,71.12) v1(214.5,71.12) v1(216.28,68.58) v1(216.28,67.69)
+V5DSW_R1: length 2.5
  TOP w0.3: 51.94,85.85 R8G28.2 50.72,87.07 50.67,87.12
+V5DSW_R2: length 2.3
  TOP w0.3: 48.76,98.68 48.05,98.68 R8F54.2 47.8,98.17 48.64,98.17
+V5DSW_VAL: length 15.1
  TOP w0.38: R7H63.2 78.61,41.15 79.88,41.15
  TOP w0.508: J7H1.10 78.96,50.77 77.9,49.71 77.9,45.26 76.44,43.8 76.44,42.43 77.34,41.53 R7H63.2
+V5DUAL: length 137.4
  TOP w0.38: v1(135.72,276.96) v1(135.72,276.25) ; Q4G4.3 182.24,79.5 v1(182.62,79.88) ; C4G12.1 191.58,85.34 EU4G2.5 ; R2G21.1 v1(267.97,78.48) ; v1(147.06,133.65) 147.19,133.53 C5E17.1 ; R5A19.1 135.12,274.93 135.12,275.59 v1(135,275.72) ; R6J2.1 116.83,23.37 116.2,22.73 v1(116.2,22.35) ; 161.03,215.14 161.67,215.14 R5C14.1 161.67,215.64 161.03,215.64 ; v1(276.6,257.43) 276.6,257.81 R2B3.1 ; v1(110.61,242.06) v1(111.37,242.06) ; v1(110.61,242.06) v1(110.61,242.82) v1(111.37,242.82) ; v1(110.61,242.06) 110.61,241.3 RT6B1.1 109.72,240.66 v1(109.72,242.06) v1(109.72,242.82) ; v1(106.55,4.82) 106.55,3.05 105.66,2.16 103.37,2.16 102.87,2.67 R6J33.1 ; U6A1.1 105.39,285 C6A4.1 105.15,285.59 104.77,285.97 v1(104.77,285.97) ; v1(138.43,110.74) 137.92,110.23 R5F12.1 ; 276.6,82.29 R2G12.2 ; R7C7.1 v1(83.05,222.12)
  TOP w0.5: v1(57.78,25.27) 57.78,22.73 58.54,21.97 61.21,21.97 66.67,16.51 66.67,6.98 65.4,5.71 65.4,3.68
  TOP w0.508: C4H15.1 183.26,49.53 v1(183.38,49.4)
  LAY5 w0.38: v1(91.69,208.79) 91.69,211.2 83.05,219.84 v1(83.05,222.12) ; v1(116.2,22.35) 116.2,21.84 114.92,20.57 110.64,20.57 110.27,20.94 108.06,20.94 105.91,18.79 v1(105.53,18.79)
  BOTTOM w0.38: v1(268.09,75.69) 267.97,75.82 v1(267.97,78.48) ; 105.53,17.27 v1(105.53,18.79)
  BOTTOM w0.5: 63.75,39.62 58.42,39.62 54.73,35.94 52.7,35.94 50.41,33.65 J8H6.1 ; 63.75,39.62 63.75,35.3 59.69,31.24 59.69,27.18 v1(57.78,25.27) ; 63.75,39.62 65.78,39.62 66.92,38.48 v1(66.92,37.97)
  vias: v1(1.77,7.49) v1(1.77,5.08) v1(2.92,2.54) v1(3.93,289.56) v1(3.93,288.54) v1(3.93,287.4) v1(5.33,1.65) v1(5.46,289.56) v1(5.46,288.54) v1(5.46,287.4) v1(6.73,289.56) v1(6.73,288.54) v1(6.73,287.4) v1(7.87,289.56) v1(7.87,288.54) v1(7.87,287.4) v1(8.89,1.65) v1(57.78,2.54) v1(58.54,2.54) v1(59.3,2.54) v1(60.19,2.54) v1(62.73,2.54) v1(63.62,2.54) v1(64.51,2.54) v1(65.27,2.54) v1(82.14,20.09) v1(83.11,20.09) v1(105.02,4.82) v1(105.79,4.82) v1(109.22,2.03) v1(109.47,284.1) v1(110.1,2.03) v1(110.23,284.1) v1(110.87,2.03) v1(111.63,2.03) v1(135,276.48) v1(136.9,207.64) v1(136.9,206.75) v1(136.9,205.87) v1(137.66,111.5) v1(137.66,110.74) v1(138.43,111.5) v1(160.52,217.3) v1(161.29,217.3) v1(161.29,216.53) v1(162.05,216.53) v1(162.56,87.76) v1(162.56,86.99) v1(163.32,87.76) v1(163.32,86.99) v1(164.74,273.94) v1(165.5,276.73) v1(165.48,275.46) v1(165.48,274.7) v1(165.48,273.94) v1(166.24,277.75) v1(166.24,276.73) v1(166.24,275.46) v1(166.24,274.7) v1(166.24,273.94) v1(166.37,4.44) v1(166.37,3.3) v1(166.37,2.28) v1(167.38,4.44) v1(167.38,3.3) v1(167.38,2.28) v1(168.4,4.44) v1(168.4,3.3) v1(168.4,2.28) v1(169.41,4.44) v1(169.41,3.3) v1(169.41,2.28) v1(187.83,88.26) v1(187.83,87.37) v1(188.72,88.26) v1(188.72,87.37) v1(189.61,88.26) v1(189.61,87.37) v1(190.5,88.26) v1(190.5,87.37) v1(191.38,88.26) v1(191.38,87.37) v1(192.27,88.26) v1(192.27,87.37) v1(193.16,88.26) v1(193.16,87.37) v1(194.05,88.26) v1(194.05,87.37) v1(199.77,276.22) v1(199.77,275.46) v1(200.53,275.46) v1(230.37,279.14) v1(230.37,278.13) v1(230.37,276.99) v1(231.26,278.13) v1(232.28,278.13) v1(274.57,76.96) v1(274.57,75.82) v1(274.57,74.67) v1(275.33,76.96) v1(275.84,257.43) v1(276.09,76.96) v1(276.98,76.96) v1(277.87,76.96) v1(277.87,75.82) v1(277.87,74.67)
+V5DUAL_USB2_BP1: length 17.2
  TOP w0.38: 229.36,272.79 229.1,272.54 229.1,265.46 229.61,264.95 229.61,259.14 Q3B1.3 228.98,257.68 229.23,257.43 R3B11.1
  vias: v1(223.52,275.46) v1(224.4,275.46)
+V5DUAL_USB2_FP: length 14
  TOP w0.38: R7C13.1 78.48,216.28 C7C9.1 ; J7C7.9 83.31,209.8 ; J7C7.9 84.45,210.69 ; J7C7.9 J7C7.10 ; J7C7.9 83.31,212.34 ; J7C7.10 79.37,210.69 ; J7C7.10 80.77,212.22 ; J7C7.10 80.77,209.68
+V5DUAL_USB31_BP0:
  vias: v1(225.55,282.32) v1(225.55,281.43)
+V5DUAL_USB31_BP2: length 3.9
  LAY5 w0.38: 191.26,282.83 191.26,282.82 J4A2.1 ; 192.78,281.56 192.74,281.6 J4A2.1 ; 190.75,280.67 190.75,281.08 J4A2.1
  vias: v1(200.02,285.11) v1(201.42,285.11)
+V5DUAL_USB31_FP1: length 5.5
  TOP w0.38: 129.15,201.17 127.76,199.77 R6C20.1
  vias: v1(99.56,185.49) v1(100.33,185.49) v1(106.76,193.11) v1(107.56,193.11) v1(112.77,205.1) v1(113.53,205.1) v1(113.53,204.21) v1(124.07,206.25) v1(124.07,205.48) v1(124.07,204.72) v1(124.84,206.25) v1(124.84,205.48) v1(124.84,204.72)
+V5DUAL_USB31_FP2:
  vias: v1(109.98,232.81) v1(110.74,232.81) v1(111.5,232.81)
+V5DUAL_USBC: length 24.3
  TOP w0.2: EU5A1.25 v1(143.76,262.96) ; v1(143.89,271.65) 143.76,271.53 EU5A1.46
  TOP w0.38: R5A19.2 139.59,273.91 C5A22.1
  BOTTOM w0.38: v1(138.04,265.73) 139.87,263.9 143.77,263.9 143.77,263.02 143.76,263.02 v1(143.76,262.96) ; v1(138.3,271.65) 138.3,271.02 138.81,270.51 138.81,268.1 C5L26.1 137.28,266.57 v1(137.28,265.73) ; v1(139.06,271.65) 139.06,271.27 139.57,270.76 C5L11.1 143.89,271.64 v1(143.89,271.65)
  vias: v1(137.32,265.01) v1(139.06,272.41)
+V5DX_AUDIO_FIL: length 21.3
  TOP w0.2: EU6A1.43 119.3,278.44 C6A18.1
  TOP w0.38: v1(118.99,287.27) 118.87,287.27 C6A3.1 ; C6A3.1 FB6A1.2 ; C6A3.1 v1(118.99,286.51) ; R6A1.1 v1(122.17,287.53) ; C6A18.1 119.12,278 C6A21.1 119.38,277.11 119.76,276.73 v1(119.76,276.35) ; R6A37.1 v1(117.09,275.33) ; R6A42.1 v1(117.09,273.81)
  BOTTOM w0.38: 120.39,286.51 v1(118.99,286.51) 118.99,277.11
+V5DX_SSD_LS: length 1.2
  TOP w0.25: 105.28,7.49 105.41,7.36 R6J31.1
+V5DX_SSD_VDD: length 2.5
  TOP w0.18: R6J33.2 C6J4.1 103.88,4.7 U6J1.1
+V5S: length 541.2
  TOP w0.2: v1(155.42,175.79) 155.28,175.66 EU5D2.9 ; EU5C3.9 162.78,203.6 v1(162.9,203.72)
  TOP w0.25: J1B2.34 299.37,243.11 v1(299.72,243.46)
  TOP w0.38: C5D16.1 155.52,175.89 v1(155.42,175.79) ; CR3A1.1 v1(230.25,286.26) 229.48,286.26 ; CR4A7.1 v1(203.32,275.21) CR4A7.2 ; R1C16.1 v1(297.84,220.98) 298.19,220.98 298.57,221.36 R1C15.1 C1C9.1 299.59,220.98 Q1C2.1 ; v1(162.9,203.72) 163.01,203.83 C5C31.1 ; Q1A1.1 282.19,268.86 282.19,270.38 R1A3.1 281.68,271.14 279.52,273.3 279.52,275.84 ; Q2A1.1 253.87,280.67 v1(254,280.8) ; v1(125.47,8.89) 125.34,8.89 125.09,8.63 R6J29.1 ; Q2A2.1 278.76,275.84 279.52,275.84 ; Q3B1.1 v1(231.14,258.44) Q3B1.2 ; 279.52,275.84 280.28,276.6 281.68,276.6 282.82,277.75 282.82,283.34 280.92,285.24 ; R9H1.1 R9H2.1 16.38,63.88 16.76,63.5 16.76,61.47 16,60.7 13.33,60.7 7.87,55.24 7.23,55.24 6.35,54.35 6.35,51.05 R9H4.1 3.42,50.54 ; R1B45.2 v1(288.83,228.85) ; v1(254,281.56) 253.49,281.56 R2A1.1 253.49,282.32 v1(254,282.32) ; v1(277.11,214.37) 277.11,214.5 275.33,216.28 R2C23.1
  TOP w0.5: 194.56,75.69 196.46,75.69 Q4G3.2 ; v1(170.3,60.2) 170.3,60.45 170.68,60.83 R4H2.1 ; Q1C2.1 300.99,220.09 v1(301.39,220.09) ; J9H1.9 5.33,67.18 3.42,65.28 3.42,51.43
  TOP w0.508: 3.42,51.43 3.42,15.49 14.09,4.82 62.99,4.82 65.78,7.62 v1(65.78,9.4) ; R4G25.1 R4H1.1 R4H2.1
  LAY5 w0.38: v1(288.83,228.85) 288.67,228.85 288.21,228.4 288.21,223.35 284.6,219.74 284.6,218.44 v1(284.09,217.93)
  LAY5 w0.5: v1(162.9,203.72) 163.57,203.06 163.57,201.55 162.81,200.79 162.81,197.23 160.65,195.07 160.65,192.66 156.59,188.59 156.59,176.96 v1(155.42,175.79)
  LAY5 w0.508: v1(227.45,252.86) 227.45,252.09 226.82,251.46 224.91,251.46 224.15,252.22 215.26,252.22 214.5,251.46 208.49,251.46 207.52,252.43 201.79,252.43 199.34,249.97 191.08,249.97 190.79,250.27 186.89,250.27 v1(186.05,249.43)
  LAY6 w0.5: v1(162.9,203.72) 163,203.83 163,207.07 165.29,209.35 165.29,216.48 165.76,216.94 165.76,218.41 165.35,218.82 162.68,218.82 161.54,219.96 161.54,225.55 165.04,229.05 165.04,234.43 168.13,237.52 171.11,237.52 171.71,238.12 v1(172.08,238.12) ; v1(147.7,58.04) 147.7,44.07 150.75,41.02 150.75,28.7 149.22,27.18 149.22,21.72 149.6,21.33 149.6,10.29 148.46,9.14 147.76,9.14 144.78,6.16 134.29,6.16 131.44,9.02 127.76,9.02 127.38,9.4 125.98,9.4 v1(125.47,8.89) 122.17,8.89 121.66,9.4 118.82,9.4 117.91,8.49 117.91,7.43 117.28,6.8 112.25,6.8 111.23,5.78 109.28,5.78 108.71,5.21 108.71,3.55 106.8,1.65 100.83,1.65 99.94,2.54 89.91,2.54 89.15,1.78 67.18,1.78 65.78,3.17 v1(65.78,9.4)
  BOTTOM w0.5: v1(297.84,220.98) 296.41,220.98 295.14,222.25 288.41,222.25 v1(284.09,217.93) 280.54,214.37 v1(277.11,214.37) ; R3M45.1 227.83,254.25 227.45,253.87 v1(227.45,252.86)
  BOTTOM w0.508: v1(186.05,249.43) 185.88,249.26 185.05,249.26 182.08,246.28 180.15,246.28 179.32,245.45 179.32,241.43 177.03,239.14 172.84,239.14 172.08,238.38 v1(172.08,238.12)
  vias: v1(158.75,57.28) v1(158.75,56.26) v1(158.75,55.12) v1(159.76,57.28) v1(159.76,56.26) v1(159.76,55.12) v1(184.27,82.29) v1(184.27,80.39) v1(185.16,82.29) v1(185.16,80.39) v1(185.92,82.29) v1(185.92,80.39) v1(186.81,82.29) v1(187.19,73.96) v1(187.96,73.96) v1(188.72,74.93) v1(188.72,73.96) v1(191.13,75.56) v1(191.13,74.8) v1(191.13,74.04) v1(191.89,75.56) v1(191.89,74.8) v1(191.89,74.04) v1(202.94,274.45) v1(203.7,274.32) v1(225.32,269.24) v1(226.06,269.37) v1(229.48,287.27) v1(230.25,287.27) v1(231.01,287.27) v1(232.28,287.4) v1(233.55,287.4) v1(233.55,286.51) v1(278.89,287.91) v1(278.89,287.15) v1(279.65,287.91) v1(279.65,287.15) v1(280.41,287.15) v1(280.41,286.38) v1(280.41,285.62) v1(281.17,287.15) v1(281.17,286.38) v1(301.39,220.85) v1(301.39,219.33)
+V5S_DONGLE: length 2.2
  TOP w0.5: R2A32.1 R2A33.1 R1A3.2
+V5S_HDMIC_CONN1: length 21.3
  TOP w0.38: 275.13,271.59 275.86,271.59 v1(276.04,271.78) ; v1(270.94,270.64) 270.76,270.81 R2A21.1
  LAY6 w0.38: v1(270.94,270.64) 270.94,270.66 271.52,271.25 274.29,271.25 274.82,271.78 v1(276.04,271.78)
  BOTTOM w0.38: v1(276.04,271.78) 275.13,272.69 275.13,274.26 273.55,275.84 273.55,283.34 v1(274.44,284.22)
+V5S_HDMID_CONN2: length 6.8
  TOP w0.38: CR2A2.3 v1(250.57,276.73)
  BOTTOM w0.38: v1(250.82,282.07) 250.82,276.98 v1(250.57,276.73)
+V5S_R:
  vias: v1(196.34,68.58) v1(196.34,67.69) v1(199.77,68.58) v1(199.77,67.69) v1(203.7,68.32) v1(203.7,67.56)
+V12S: length 538.1
  TOP w0.3: EU8B4.5 36.04,253.39 v1(36.19,253.24)
  TOP w0.38: EU8B1.5 53.87,258.17 53.46,258.57 50.41,258.57 50.29,258.44 ; v1(38.86,187.8) 39.16,187.8 39.82,188.47 R8D17.1 R8D18.1 ; v1(3.81,186.05) 5.42,187.67 14.81,187.67 15.6,186.88 21.9,186.88 23.49,185.29 v1(25.78,185.29) ; EU6B1.5 113.35,246.99 EU6B2.5 113.35,246.61 ; R9A23.1 14.73,260.86 v1(14.85,260.73) ; v1(119.76,10.67) 119.76,9.14 120.26,8.63 R6J28.1 ; R7B2.1 61.21,258.44 v1(60.96,258.7) ; R4G5.1 v1(189.73,94.11) ; R5C48.1 v1(152.14,201.67) ; v1(184.53,57.66) 184.53,58.04 183.76,58.8 R4H7.1 ; R6A77.1 107.82,261.62 v1(108.17,261.26)
  TOP w0.5: v1(292.48,249.05) v1(292.48,248.28) 292.6,248.16 R1B12.1 ; R3H27.1 R3H22.1 R3H19.1 R3H9.1 R3H8.1 R3H4.1 235.07,66.93 R3G41.2
  LAY5 w0.38: v1(47.49,253.87) 47.24,253.62 40.76,253.62 39.75,252.6 38.1,252.6 37.46,253.24 v1(36.19,253.24) ; v1(25.78,185.29) 25.78,185.16 26.92,184.02 33.27,184.02 34.92,185.67 37.59,185.67 38.86,186.94 v1(38.86,187.8)
  LAY5 w1: 286.76,136.14 286.76,94.74 286.44,94.42 286.44,92.13 281.43,87.12 281.43,81.66 280.54,80.77 276.64,80.77 273.55,77.68 273.55,72.26 272.56,71.27 255.29,71.27 254.76,70.74 245.74,70.74 C3G26.1 ; 291.56,168.94 291.56,179.26 292.18,179.88 292.18,196.51 290.19,198.5 290.19,205.84 290.83,206.48 290.83,208.41 292.42,210 292.42,213.54 291.33,214.63 291.33,220.02 293.85,222.53 293.87,222.53 293.87,222.56
  LAY6 w0.38: v1(152.14,201.67) 152.14,201.04 151.89,200.79 151.89,198.75 150.54,197.41 150.54,192.53 151.51,191.57 151.51,188.31 150.61,187.42 150.61,167.48 150.11,166.97 150.11,165.58 148.35,163.82 148.35,157.04 148.59,156.8 148.59,154.03 148.35,153.8 148.35,150.51 142.77,144.93 142.77,139.69 141.09,138.01 141.09,135.92 135.89,130.71 135.89,124.07 131.78,119.96 131.78,118.41 127.2,113.83 127.2,98.82 131.01,95.01 131.01,84.19 137.28,77.91 137.28,77.04 145.92,68.4 145.92,58.67 146.68,57.91 146.68,52.32 145.03,50.67 145.03,39.88 143.38,38.23 141.6,38.23 141.22,37.84 141.22,27.3 v1(142.62,25.91)
  LAY6 w0.5: v1(64.89,15.49) 65.27,15.87 65.27,22.85 66.29,23.87 66.29,24.37 67.25,25.33 67.25,29.66 66.29,30.62 v1(66.29,30.99)
  BOTTOM w0.38: v1(194.69,54.35) 194.69,54.99 194.18,55.5 192.53,55.5 191.13,56.89 185.03,56.89 184.53,57.4 v1(184.53,57.66) 184.53,58.29 183.83,58.99 180.44,58.99 179.31,60.13 179.31,64.87 178.12,66.06 178.12,74.62 182.62,79.12 182.75,79.12 183.26,79.63 186.56,79.63 187.83,80.9 189.48,80.9 194.81,86.23 194.81,88.64 193.92,89.53 191.64,89.53 190.75,90.42 190.75,93.09 v1(189.73,94.11)
  BOTTOM w0.5: v1(294.7,223.71) v1(294.7,224.42)
  vias: v1(14.85,261.62) v1(46.86,259.33) v1(46.86,258.57) v1(47.75,259.33) v1(47.75,258.57) v1(48.64,259.33) v1(48.64,258.57) v1(49.53,259.33) v1(49.53,258.57) v1(104.14,251.74) v1(104.64,252.73) v1(105.02,251.74) v1(106.04,252.73) v1(106.42,251.74) v1(107.41,261.26) v1(107.41,260.5) v1(108.17,260.5) v1(108.94,261.26) v1(108.94,260.5) v1(234.82,75.06) v1(237.36,74.93) v1(238.76,74.93) v1(238.76,73.79) v1(240.15,74.93) v1(240.15,73.79) v1(242.95,75.06) v1(287.52,137.79) v1(287.52,136.9)
+V12S_AUDIO: length 0.7
  TOP w0.5: R9A23.2 13.84,258.7
+V12S_CPU: length 6.9
  TOP w0.1: v1(172.33,205.61) 172.36,205.59
  TOP w0.2: v1(162.22,174.88) 162.17,174.88 162.05,174.75
  TOP w0.38: v1(272.92,204.85) 272.92,204.21 R2C32.1 272.16,203.96 v1(272.16,204.85)
  TOP w0.5: 172.36,205.59 R4C19.2 ; 162.05,174.75 R5D29.2
  TOP w0.508: v1(167.76,248.76) 166.7,248.76 R5B54.2 166.42,249.78
  vias: v1(162.22,176.38) v1(162.22,175.61) v1(162.94,176.38) v1(162.94,175.61) v1(162.94,174.88) v1(168.4,248.03) v1(168.78,248.76) v1(169.41,248.03) v1(169.79,248.76) v1(171.57,205.61) v1(172.84,206.37) v1(173.1,205.61) v1(187.19,215.64) v1(187.96,216.53) v1(187.96,215.64) v1(188.72,216.53) v1(188.72,215.64) v1(189.48,216.53) v1(189.48,215.64) v1(190.24,215.64) v1(251.2,213.74) v1(251.2,212.98) v1(251.2,212.22) v1(251.96,213.74) v1(251.96,212.98) v1(251.96,212.22) v1(252.73,213.74) v1(252.73,212.98) v1(252.73,212.22) v1(271.39,204.85) v1(272.16,205.61) v1(272.92,206.37) v1(272.92,205.61) v1(273.68,206.37) v1(273.68,205.61) v1(273.68,204.85) v1(274.44,206.37) v1(274.44,205.61) v1(274.44,204.85) v1(281.3,252.65) v1(281.3,251.89) v1(281.3,251.13) v1(281.3,250.37) v1(281.3,249.6) v1(281.3,248.84) v1(282.44,252.65) v1(282.44,251.89) v1(282.44,251.13) v1(282.44,250.37) v1(282.44,249.6) v1(282.44,248.84) v1(282.7,261.62) v1(284.22,262.76) v1(284.22,261.62) v1(285.62,263.78) v1(285.62,262.76) v1(285.62,261.62) v1(286.89,263.78) v1(286.89,262.76) v1(286.89,261.62) v1(288.29,263.78) v1(288.29,262.76) v1(288.29,261.62)
+V12S_CPU_R1: length 16.6
  TOP w0.5: C2B6.1 273.68,251.71 277.49,247.9 281.17,247.9 282.82,246.25 R1B14.1 282.95,245.87 285.6,245.87 CR1B3.2
  vias: v1(180.21,245.24) v1(180.21,244.47) v1(180.97,245.24) v1(180.97,244.47) v1(181.73,245.24) v1(194.56,246.3) v1(194.56,245.54) v1(195.32,246.3) v1(195.32,245.54) v1(203.17,245.26) v1(203.17,244.5) v1(203.93,245.26) v1(203.93,244.5) v1(204.69,245.26) v1(217.47,245.49) v1(217.67,246.25) v1(218.18,245.49) v1(218.44,246.25) v1(226.44,245.62) v1(226.44,244.85) v1(227.2,245.62) v1(227.2,244.85) v1(227.96,245.62) v1(234.44,252.09) v1(235.96,252.09) v1(237.99,252.09) v1(239.9,252.09) v1(240.84,245.49) v1(241.14,246.23) v1(241.55,245.49) v1(241.9,246.23) v1(242.31,252.09) v1(244.85,252.09) v1(247.39,252.09) v1(249.17,245.49) v1(249.17,244.73) v1(249.93,252.09) v1(249.93,245.49) v1(249.93,244.73) v1(250.69,245.49) v1(250.69,244.73) v1(251.84,252.09) v1(254.5,251.97) v1(257.42,251.97) v1(260.47,251.97) v1(263.14,251.97) v1(263.14,246) v1(263.14,245.24) v1(263.9,246) v1(264.66,246) v1(265.3,252.09) v1(271.27,252.47) v1(271.9,252.09) v1(277.24,255.9) v1(277.74,253.49) v1(278,255.9) v1(278.38,252.98) v1(278.89,262.38) v1(278.89,261.67) v1(278.89,260.96) v1(279.14,253.49) v1(279.14,252.73) v1(279.78,262.38) v1(279.78,261.67) v1(279.78,260.96) v1(280.67,262.38) v1(280.67,261.67) v1(280.67,260.96) v3(182.49,244.14) v3(182.49,243.43) v3(183.26,244.14) v3(183.26,243.43) v3(184.02,244.14) v3(184.02,243.43) v3(195.8,244.12) v3(195.8,243.41) v3(196.57,244.12) v3(196.57,243.41) v3(197.33,244.12) v3(197.33,243.41) v3(205.48,244.14) v3(205.48,243.43) v3(206.24,244.14) v3(206.24,243.43) v3(207.01,244.14) v3(207.01,243.43) v3(218.79,244.12) v3(218.79,243.41) v3(219.55,244.12) v3(219.55,243.41) v3(220.31,244.12) v3(220.31,243.41) v3(228.85,244.14) v3(228.85,243.43) v3(229.61,244.14) v3(229.61,243.43) v3(230.37,244.14) v3(230.37,243.43) v3(242.16,244.12) v3(242.16,243.41) v3(242.92,244.12) v3(242.92,243.41) v3(243.68,244.12) v3(243.68,243.41) v3(252.09,244.14) v3(252.09,243.43) v3(252.85,244.14) v3(252.85,243.43) v3(253.61,244.14) v3(253.61,243.43) v3(265.4,244.12) v3(265.4,243.41) v3(266.16,244.12) v3(266.19,243.41) v3(266.92,244.12) v3(266.92,243.41)
+V12S_CPU_R2: length 3.6
  TOP w0.38: v1(272.03,199.77) 272.03,200.66 R2C32.2 272.79,200.66 v1(272.79,199.77) ; v1(283.59,188.09) v1(283.59,188.85)
  vias: v1(272.03,199.06) v1(272.03,198.35) v1(272.79,199.06) v1(272.79,198.35) v1(273.17,192.02) v1(273.55,199.77) v1(273.55,199.06) v1(273.55,198.35) v1(273.93,193.17) v1(274.32,199.77) v1(274.32,199.06) v1(274.32,198.35) v1(274.95,194.44) v1(274.95,192.02) v1(277.11,194.44) v1(277.11,192.02) v1(278.25,193.17) v1(283.48,175.39) v1(283.48,174.62) v1(284.25,175.39) v1(284.25,174.62) v1(284.25,173.86) v1(284.35,188.85) v1(284.35,188.09) v1(284.35,187.32) v1(285.01,174.62) v1(285.01,173.86) v1(285.11,188.85) v1(285.11,188.09) v1(285.11,187.32) v3(282.54,186.56) v3(282.54,185.8) v3(282.54,185.04) v3(282.54,173.12) v3(282.54,172.36) v3(282.54,171.6) v3(283.26,186.56) v3(283.26,185.8) v3(283.26,185.04) v3(283.26,173.12) v3(283.26,172.36) v3(283.26,171.6)
+V12S_FAN: length 575.8
  TOP w1: 174.11,36.45 162.3,36.45 150.74,48.01 137.78,48.01 136.01,49.78 132.46,49.78 130.68,48 127.76,48 127,47.24 120.52,47.24 119.88,47.88 118.99,47.88 118.23,47.12 116.64,47.12 116.01,47.75 114.87,47.75 114.23,47.12 102.23,47.12 100.58,45.46
  LAY5 w1: 3.93,13.21 1.9,15.24 1.9,206.75 J9C1.2
  LAY6 w1: 253.57,39.98 235.73,39.98 228.25,47.46 214.92,47.46 212.85,49.53 206.24,49.53 205.53,50.24 200.73,50.24 193.8,43.31 187.83,43.31 185.16,40.64 177.02,40.64 175.26,38.88 175.26,36.87 ; 299.33,87.4 299.33,82.42 296.27,79.36 296.27,60.18 290.34,54.25 290.34,48.62 292.48,46.48 292.48,41.4 291.84,40.77 ; 292.35,122.81 291.46,123.69 291.46,135 289.87,136.59 289.87,140.02 291.02,141.17 291.02,148.21
  BOTTOM w1: 98.67,42.8 92.71,42.8 90.42,40.51 90.42,36.96 87.37,33.91 86.63,33.91 81.15,28.43 81.15,24.38 79.5,22.73 76.7,22.73 75.7,21.73 71.4,21.73 70.63,20.95 67.05,20.95 65.89,19.8 65.89,11.82 66.8,10.92 66.8,8.89 65.89,7.99 65.89,6.19 64.16,4.46 12.94,4.46 5.7,11.69
  vias: v1(4.57,12.06) v1(4.57,11.3) v1(98.93,44.7) v1(99.69,44.7) v1(175.26,36.07) v1(175.26,35.3) v1(289.94,150.87) v1(289.94,150.11)
+V12S_FAN_R: length 7.6
  TOP w0.3: EU1E2.6 290.97,139.43 v1(290.83,139.57)
  BOTTOM w0.38: v1(290.83,139.57) 290.83,145.03 v1(289.94,145.92)
+V12S_PCIE_SLOT2: length 16.5
  TOP w0.508: J7B1.A2 64.51,246.35 ; J7B1.A2 63.8,245.65 ; J7B1.A2 64.51,244.94 ; J7B1.A2 65.21,245.65 ; J7B1.B1 60.71,246.65 ; J7B1.B1 59.3,246.65 ; J7B1.B1 60.01,245.94 ; J7B1.B1 60.01,247.35 ; 48.16,246.57 C8B10.1 ; C8B10.1 48.16,248.22 ; C8B10.1 48.98,247.39 ; J7B1.A3 63.21,244.65 ; J7B1.A3 62.51,243.94 ; J7B1.A3 62.51,245.35 ; J7B1.A3 61.8,244.65 ; 60.01,243.94 J7B1.B3 ; J7B1.B3 59.3,244.65 ; J7B1.B3 60.01,245.35 ; J7B1.B3 60.71,244.65 ; J7B1.B2 58.71,245.65 ; J7B1.B2 58.01,246.35 ; J7B1.B2 58.01,244.94 ; J7B1.B2 57.3,245.65
+V12S_PCIE_SLOT2_R: length 3.7
  TOP w0.28: EU8B1.6 53.35,257.67 v1(53.21,257.81)
  BOTTOM w0.5: v1(52.32,255.27) 52.32,256.92 v1(53.21,257.81)
+V12S_PCIE_SLOT3_R: length 2.8
  TOP w0.28: 36.33,253.89 EU8B4.6
  TOP w0.5: 37.59,255.14 36.33,253.89
+V12S_PEG_SLOT_R: length 5.4
  TOP w0.35: EU6B1.6 117.07,250.71 117.34,250.44 117.34,249.81 116.96,249.43 116.58,249.43 116.07,248.92 116.07,247.65 116.45,247.27 EU6B2.3
+V12S_R: length 6.4
  TOP w0.508: R3G35.1 216.91,74.55 216.91,77.6 217.55,78.23 R3G33.1
  vias: v1(229.48,69.59) v1(229.87,68.83) v1(229.87,68.07) v1(229.87,67.31) v1(230.25,69.59) v1(230.63,68.83) v1(230.63,68.07) v1(230.63,67.31)
+VBAT_EC: length 15.4
  TOP w0.203: U8F6.122 33.78,102.29 33.8,102.26 34.06,102.26
  TOP w0.35: C8F18.1 35.17,101.6 34.51,102.26 34.06,102.26
  TOP w0.38: R8F35.1 R8F36.1 ; v1(37.33,102.21) 37.31,102.23 36.06,102.23 35.68,101.85 C8F18.1
  TOP w0.5: R8F50.2 38.48,101.34 37.61,102.21 v1(37.33,102.21) ; R8F35.1 36.95,107.06 v1(37.21,107.31)
  LAY5 w0.508: v1(37.21,107.31) 36.32,106.42 36.32,103.25 37.33,102.23 v1(37.33,102.21)
+VBAT_EC_MIX: length 2.2
  TOP w0.5: R8F50.1 42.41,100.07 R8F49.2
+VBUS_USBC_CONN_BP: length 5.8
  TOP w0.2: J4A1.B4 169.6,285.02 v2(169.74,284.88) ; v2(169.18,284.88) 169.18,284.85 169.35,284.68 J4A1.A9 ; J4A1.A4 171.85,284.85 v2(171.83,284.88)
  LAY6 w1.5: 146.05,277.37 146.3,277.37 147.7,275.97 148.71,275.97
  vias: v1(132.84,262.53) v1(133.4,262.08) v1(134.11,262.1) v1(139.82,275.49) v1(140.53,275.49) v1(141.3,275.49) v2(172.38,284.88)
+VBUS_USBC_CONN_BP_L: length 19.6
  TOP w0.38: R6A65.1 117.34,268.53 116.84,268.02 116.35,268.02 v1(116.33,267.99)
  BOTTOM w0.5: v1(116.33,267.99) 116.35,268.02 116.5,268.02 117.88,269.39 119.69,269.39 120.86,268.22 123.57,268.22 125.1,266.69 129.78,266.69 131.26,268.17 v1(131.26,269.11)
+VBUS_USBC_CONN_FP3: length 8.7
  TOP w0.38: J6C4.P11 122.8,197.36 C6C11.1 v1(123.57,197.36) ; J6C4.P7 120,204.97 121.53,206.5 C6C5.1
  LAY5 w0.38: v1(123.57,197.36) v1(123.57,198.12) 123.57,200.02
  vias: v1(117.72,207.9) v1(117.72,207.14) v1(118.36,207.52) v1(120.01,207.26) v1(120.77,207.26) v1(124.58,260.86) v1(125.34,260.86) v1(128.39,261.8) v1(131.82,269.62) v1(132.33,270.13) v1(132.84,270.64)
+VCC0V9_SVR: length 26
  TOP w0.203: U5A2.R16 v2(168.64,265.45) U5A2.T16 168.32,265.13 ; U5A2.R13 v2(167.34,266.1) U5A2.N13 ; 166.37,265.13 v2(166.69,264.8) ; U5A2.T9 165.07,265.13 ; U5A2.T9 v2(164.74,264.8) 164.42,265.13 ; U5A2.T9 U5A2.R8 v2(164.09,266.1) ; v2(164.09,266.1) 164.42,266.43 U5A2.N8 ; v2(164.09,266.1) U5A2.N6 ; U5A2.H9 165.07,269.03 v2(165.39,269.35) U5A2.H11 ; 165.72,265.13 U5A2.T11 ; U5A2.T11 v2(165.39,264.8) ; U5A2.T11 U5A2.R11 v2(165.39,266.1) 165.72,266.43 U5A2.N11 ; U5A2.J13 v2(167.34,268.7) ; v2(164.09,270.65) U5A2.E8 ; U5A2.L13 167.02,267.73 v2(167.34,268.05) ; U5A2.H13 167.02,269.03 v2(167.34,269.35) U5A2.H15 ; U5A2.M8 v2(164.74,266.75) ; U5A2.M11 v2(165.39,266.75) ; U5A2.H16 168.32,269.03 168.64,269.35 v2(168.61,269.35) ; U5A2.M13 v2(167.34,266.75) ; 167.67,265.13 U5A2.T15 v2(167.34,264.8) 167.02,265.13 ; v2(166.69,269.35) 166.37,269.03 U5A2.H12 ; v2(165.39,268.05) U5A2.L11
  BOTTOM w0.2: C5L19.1 166.11,267.97 165.48,267.97 v2(165.39,268.05) ; C5L7.1 C5L6.1 167.38,269.62 167.38,269.62 167.38,269.39 v2(167.34,269.35) 167.65,269.35 C5L14.1 ; C5L15.1 165.63,269.11 v2(165.39,269.35) ; v2(167.34,268.05) 167.13,267.84 C5L23.1 ; v2(166.69,269.35) 166.3,269.75 C5L13.1 ; C5L33.1 166.11,264.41 ; C5L31.1 166.11,265.17
  BOTTOM w0.254: v2(165.39,266.75) 165.47,266.84 165.47,267.33 C5L24.1 ; C5L34.1 167.38,264.16 167.38,264.76 v2(167.34,264.8) ; 166.11,265.17 165.76,265.17 v2(165.39,264.8) ; C5L28.1 166.11,266.32 165.86,266.32 165.64,266.1 v2(165.39,266.1) ; C5L29.1 168.61,265.43 v2(168.64,265.45) 168.64,264.93 168.78,264.79 C5L32.1 ; 166.11,264.41 166.5,264.8 v2(166.69,264.8)
  vias: v1(153.92,271.91) v1(154.68,271.91) v1(155.44,271.91)
+VCC3V3_S0: length 20
  TOP w0.203: U5A2.L6 163.77,267.73 v2(164.09,268.05) ; U5A2.E6 v2(163.44,270.65)
  TOP w0.38: v1(157.22,264.16) R5A44.2
  LAY6 w0.38: 159.51,269.37 159.51,268.35 157.86,266.7 157.86,264.8 v1(157.22,264.16) ; 161.16,270.13 160.34,270.13 v1(159.63,270.83) ; 161.16,270.13 161.16,269.59 162.58,268.17 163.97,268.17 v2(164.09,268.05) ; 161.16,270.13 162.3,271.27 163.06,271.27 163.44,270.89 v2(163.44,270.65)
  BOTTOM w0.254: C5L25.1 164.2,267.33 164.2,267.94 v2(164.09,268.05)
  BOTTOM w0.38: v2(163.44,270.65) 163.57,270.79 C5L8.1 ; v1(157.22,264.16) R5A44.2 R5L15.2
  vias: v1(159.6,271.71)
+VCC3V3_SX: length 8.1
  TOP w0.203: U5A2.F18 169.29,270 v2(169.32,270) ; U5A2.R6 v2(164.09,265.45)
  TOP w0.5: R5A40.2 154.3,265.05 153.89,264.64 v1(153.79,264.64) ; v1(154.68,261.62) 154.88,261.62 155.39,262.13 R5A49.2 R5A57.2
  BOTTOM w0.089: v2(169.32,270) 169.32,270.12 168.91,270.53 168.91,271.02 169.03,271.14
  BOTTOM w0.1: 169.03,271.14 169.28,271.4 C5L3.1
  BOTTOM w0.2: v1(154.68,261.62) 155.19,262.13 R5A49.2
  BOTTOM w0.38: C5L30.1 164.12,265.43 v2(164.09,265.45)
  vias: v1(151.76,269.49) v1(151.76,268.73) v1(152.65,265.94)
+VCC_EDP_AMOLED: length 23.8
  TOP w0.5: R1B13.1 v1(294,248.28)
  LAY6 w0.5: v1(294,248.28) 294,252.6 294.76,253.36 294.76,254.89 293.11,256.54 293.11,261.36 J1A4.2
+VCC_EDP_BKLT: length 10.3
  TOP w0.38: J1B2.31 296.1,241.61 v1(296.03,241.68) ; R1B12.2 R1B13.2 294.89,246.12 C1B5.1 295.14,245.96 v1(296.03,245.07)
  BOTTOM w0.5: v1(296.03,245.07) 295.77,245.07 295.27,244.57 295.27,242.57 296.03,241.81 v1(296.03,241.68)
+VCC_OBS_AB_PCH: length 4.4
  TOP w0.275: J6H2.43 119.08,42.67
  TOP w0.508: R6H33.2 R6H32.2 119.5,42.24 119.08,42.67
+VCC_OBS_CD_PCH: length 4.5
  TOP w0.305: J6H2.44 119.08,51.43
  TOP w0.508: 119.08,51.43 119.08,52.54 R6H6.2 R6H7.2
+VCCA_SUSCLK: length 1
  TOP w0.5: R7F46.1 U7F1.1
+VCCA_XTAL_1P05: length 23.3
  TOP w0.152: U6E1.P3 107.65,157.33 107.57,157.4 U6E1.P2 107.27,158.1 107.27,160.29 107.11,160.45
  TOP w0.254: 107.44,164.97 107.44,164.42 107.11,164.09 107.11,160.45
  TOP w0.508: L6D4.2 104.39,178.03 R6D50.2 R6D54.2 104.39,174.75 105.79,173.35 105.79,170.94 106.68,170.05 C6D24.1 C6D25.1 107.56,167.89 107.44,167.77 107.44,164.97
+VCCA_XTAL_1P05_L: length 1.7
  TOP w0.3: L6D4.1 105.91,179.75 R6D40.2
+VCCAMPHYPLL_1P05: length 1
  TOP w0.305: U6E1.E49 U6E1.D49 U6E1.C49
+VCCAMPHYPLL_1P05_L: length 1.5
  TOP w0.3: R6F16.2 R6F13.2
+VCCAZPLL_1P05:
  vias: v1(101.98,182.62) v1(101.98,181.74) v1(112.87,159.03) v1(113.38,159.54)
+VCCAZPLL_1P05_L: length 1.4
  TOP w0.5: L6D3.1 100.83,177.93 R6D34.2
+VCCB_SUSCLK: length 1.8
  TOP w0.5: U7F1.6 69.46,113.66 69.21,113.41 R7F45.2
+VCCCORE: length 434.4
  TOP w0.305: J3D1.AK17 v1(219.87,172.03) ; J3D1.AK20 v1(222.61,172.03) ; v1(220.78,172.03) J3D1.AK18 ; v1(218.04,172.03) J3D1.AK15 ; J3D1.AK22 v1(224.44,172.03) ; J3D1.AK21 v1(223.52,172.03)
  TOP w0.356: v1(222.61,172.92) 223.04,172.49 J3D1.AJ20 ; v1(218.04,172.92) 218.47,172.49 J3D1.AJ15 ; J3D1.AJ22 224.87,172.49 v1(224.44,172.92) ; J3D1.AJ14 217.56,172.49 v1(217.12,172.92) ; J3D1.AK19 v1(221.69,172.03) ; J3D1.AJ21 223.96,172.49 v1(223.52,172.92) ; v1(221.69,172.92) 222.13,172.49 J3D1.AJ19 ; J3D1.AJ16 219.38,172.49 v1(218.95,172.92) ; J3D1.AJ17 220.3,172.49 v1(219.87,172.92) ; J3D1.AK13 216.48,171.76 v1(216.21,172.03) ; J3D1.AJ13 216.64,172.49 v1(216.21,172.92) ; J3D1.AK14 v1(217.12,172.03) ; v1(220.78,172.92) 221.21,172.49 J3D1.AJ18 ; J3D1.AK16 v1(218.95,172.03)
  TOP w0.38: v1(216.21,172.92) 216.18,172.92 J3D1.AJ12 ; R2B20.1 278.76,242.44 279.45,243.14 279.45,243.64 280.16,244.35 280.64,244.35 280.65,244.33 v1(280.92,244.33)
  LAY5 w0.38: v1(22.22,13.33) 24.22,11.34 63.66,11.34 71.24,18.92 82.93,18.92 86.81,15.05 107.2,15.05 108.51,16.36 115.08,16.36 115.57,15.87 117,15.87 117.94,16.82 118.99,16.82 120.46,15.34 125.5,15.34 126.87,13.97 131.95,13.97 132.46,14.48 133.85,14.48 134.74,15.37 136.65,15.37 137.66,14.35 140.59,14.35 142.62,16.38 144.39,16.38 145.69,15.09 149.62,15.09 150.11,14.6 151.37,14.6 153.28,16.51 153.28,17.6 154.43,18.75 v1(155.11,18.75)
  LAY6 w0.38: v1(217.77,186.01) 216.54,184.78 213.1,184.78 212.09,185.8 206.88,185.8 206.24,186.43 205.1,186.43 204.72,186.05 202.81,186.05 201.61,184.85 199.58,184.85 190.18,175.45 190.18,174.56 187.65,172.04 184.49,172.04 183.42,170.97 183.42,168.19 182.89,167.66 178.96,167.66 175.51,164.21 175.51,161.16 174.49,160.15 169.79,160.15 168.16,158.51 168.16,152.42 166.49,150.75 163.44,150.75 162.23,149.53 ; v1(280.92,244.33) 282.8,244.33 285.07,242.06 285.07,239.98 286.76,238.3 286.76,236.6 288.39,234.97 288.39,232.64 286.51,230.76 278.06,230.76 272.86,225.55 271.52,225.55 265.55,219.58 v1(262.38,219.58) ; v1(155.11,18.75) 153.97,18.75 153.19,19.53 153.19,20.83 155.06,22.7 155.06,57.91 156.46,59.31 156.46,61.59 154.55,63.5 154.55,73.91 155.39,74.75 155.39,83.37 152.48,86.28 152.48,96.84 153.64,98 153.64,113.18 152.27,114.55 152.27,117.99 153.92,119.64 153.92,132.22 155.4,133.71 156.93,133.71 157.81,134.59 157.81,138.96 156.29,140.49 156.29,145.9 159.24,148.86
  LAY6 w0.4: 159.24,148.86 159.92,149.53 162.23,149.53
  BOTTOM w0.38: 264.43,222.25 v1(264.28,222.4)
  vias: v1(186.05,227.84) v1(186.81,227.84) v1(190.5,226.31) v1(191.26,226.31) v1(192.02,226.82) v1(195.07,226.19) v1(195.19,224.03) v1(195.83,223.01) v1(195.83,222.25) v1(197.23,226.19) v1(197.35,224.03) v1(199.13,222.63) v1(200.15,226.57) v1(201.16,225.04) v1(201.29,222.63) v1(201.51,217.81) v1(201.51,216.16) v1(203.32,225.04) v1(203.42,217.81) v1(203.42,216.16) v1(204.47,226.57) v1(204.59,223.01) v1(204.59,222.25) v1(205.23,217.8) v1(205.23,216.15) v1(205.99,226.69) v1(205.99,224.41) v1(206.37,216.53) v1(206.37,215.77) v1(207.77,222.63) v1(208.15,226.69) v1(208.15,224.41) v1(208.91,217.68) v1(209.93,226.57) v1(209.93,222.63) v1(210.94,225.04) v1(212.94,212.1) v1(213.1,225.04) v1(213.1,223.01) v1(213.1,222.25) v1(213.1,217.68) v1(214.24,226.57) v1(214.85,213.75) v1(215.01,216.41) v1(215.01,215.64) v1(215.77,225.3) v1(215.9,222.63) v1(216.02,208.66) v1(216.66,212.09) v1(217.17,223.77) v1(217.55,217.68) v1(217.81,208.79) v1(217.78,206.5) v1(217.77,183.93) v1(217.77,181.85) v1(217.77,178.68) v1(217.77,176.59) v1(217.93,225.3) v1(218.53,213.75) v1(218.56,204.99) v1(218.56,201.19) v1(218.58,199.46) v1(218.58,198.55) v1(218.58,197.64) v1(218.58,196.72) v1(218.58,195.81) v1(218.58,194.89) v1(218.58,193.98) v1(218.58,193.06) v1(218.58,192.15) v1(218.58,191.23) v1(218.58,190.32) v1(218.58,189.41) v1(219.32,223.77) v1(219.5,199.46) v1(219.5,198.55) v1(219.5,197.64) v1(219.5,195.81) v1(219.5,193.98) v1(219.5,191.23) v1(219.5,189.41) v1(219.71,226.44) v1(220.2,202.83) v1(220.43,212.1) v1(220.56,186.01) v1(220.59,178.68) v1(220.81,183.93) v1(220.81,181.85) v1(220.95,176.59) v1(220.95,174.51) v1(221.09,208.91) v1(221.09,206.5) v1(221.32,197.64) v1(221.32,195.81) v1(221.32,193.98) v1(221.32,191.23) v1(221.32,189.41) v1(221.36,225.04) v1(221.48,217.68) v1(221.74,223.01) v1(221.74,222.25) v1(221.71,204.99) v1(221.81,201.19) v1(222.25,213.74) v1(222.24,197.64) v1(222.24,196.72) v1(222.24,195.81) v1(222.24,194.89) v1(222.24,193.98) v1(222.24,192.15) v1(222.24,191.23) v1(222.24,190.32) v1(222.24,189.41) v1(222.24,188.49) v1(223.15,197.64) v1(223.15,195.81) v1(223.15,193.98) v1(223.15,191.23) v1(223.15,189.41) v1(223.26,226.57) v1(223.34,202.83) v1(223.77,216.41) v1(223.77,215.64) v1(224.07,199.46) v1(224.07,198.55) v1(224.07,197.64) v1(224.07,196.72) v1(224.07,195.81) v1(224.07,194.89) v1(224.07,193.98) v1(224.07,192.15) v1(224.07,191.23) v1(224.07,190.32) v1(224.07,189.41) v1(224.07,188.49) v1(224.12,183.93) v1(224.12,178.68) v1(224.12,176.59) v1(224.24,212.1) v1(224.17,181.85) v1(224.28,225.04) v1(224.51,208.79) v1(224.51,206.5) v1(225.04,222.5) v1(224.98,204.99) v1(224.98,201.19) v1(224.98,199.46) v1(224.98,197.64) v1(224.98,195.81) v1(224.98,193.98) v1(224.98,191.23) v1(224.98,189.41) v1(225.93,217.68) v1(225.9,199.46) v1(225.9,198.55) v1(225.9,197.64) v1(225.9,196.72) v1(225.9,195.81) v1(225.9,194.89) v1(225.9,193.98) v1(225.9,192.15) v1(225.9,191.23) v1(225.9,190.32) v1(225.9,189.41) v1(225.9,188.49) v1(226.02,213.88) v1(226.44,225.04) v1(226.74,202.83) v1(226.81,199.46) v1(226.81,197.64) v1(226.81,195.81) v1(226.81,193.98) v1(226.81,191.23) v1(226.81,189.41) v1(227.2,222.5) v1(227.3,185.99) v1(227.3,183.91) v1(227.3,178.8) v1(227.58,226.57) v1(227.71,208.79) v1(227.71,206.5) v1(227.72,199.46) v1(227.72,198.55) v1(227.72,197.64) v1(227.72,196.72) v1(227.72,195.81) v1(227.72,194.89) v1(227.72,193.98) v1(227.72,192.15) v1(227.72,191.23) v1(227.72,190.32) v1(227.72,189.41) v1(227.72,188.49) v1(228.44,212.22) v1(228.45,208.79) v1(228.45,206.5) v1(228.5,204.99) v1(228.5,201.19) v1(228.64,199.46) v1(228.64,197.64) v1(228.64,195.81) v1(228.64,193.98) v1(228.64,191.23) v1(228.64,189.41) v1(228.69,185.99) v1(228.69,183.91) v1(228.69,179.75) v1(228.69,177.67) v1(229.02,181.83) v1(229.1,225.04) v1(229.55,199.46) v1(229.55,198.55) v1(229.55,197.64) v1(229.55,196.72) v1(229.55,195.81) v1(229.55,194.89) v1(229.55,193.98) v1(229.55,192.15) v1(229.55,191.23) v1(229.55,190.32) v1(229.55,189.41) v1(229.55,188.49) v1(230.12,217.68) v1(230.34,213.88) v1(230.26,202.83) v1(230.5,223.01) v1(230.5,222.25) v1(230.47,199.46) v1(230.47,197.64) v1(230.47,195.81) v1(230.47,193.98) v1(230.47,191.23) v1(230.47,189.41) v1(230.75,226.82) v1(231.02,208.91) v1(231.02,206.5) v1(231.9,225.17) v1(232.02,204.99) v1(232.02,201.19) v1(232.02,199.03) v1(232.15,212.22) v1(232.41,216.41) v1(232.41,215.64) v1(232.67,197.64) v1(232.67,196.72) v1(232.67,195.81) v1(232.67,194.89) v1(232.67,193.98) v1(232.67,192.15) v1(232.67,191.24) v1(232.67,190.32) v1(232.67,189.41) v1(232.67,188.49) v1(233.17,226.57) v1(233.58,196.72) v1(233.58,194.89) v1(233.58,193.06) v1(233.58,191.24) v1(233.58,190.32) v1(233.58,189.41) v1(233.58,187.58) v1(233.91,202.83) v1(233.91,199.03) v1(234.06,222.63) v1(234.15,213.88) v1(234.18,225.04) v1(234.5,197.64) v1(234.5,196.72) v1(234.5,195.81) v1(234.5,194.89) v1(234.5,193.98) v1(234.5,193.06) v1(234.5,192.15) v1(234.5,191.24) v1(234.5,190.32) v1(234.69,217.68) v1(235.41,196.72) v1(235.41,195.81) v1(235.41,194.89) v1(235.41,193.06) v1(235.41,191.24) v1(235.55,208.03) v1(235.55,204.99) v1(235.55,201.19) v1(235.55,199.03) v1(235.93,212.1) v1(236.22,222.63) v1(236.34,225.04) v1(236.32,197.64) v1(236.32,196.72) v1(236.32,195.81) v1(236.78,198.73) v1(237.45,209.89) v1(237.45,206.38) v1(237.45,202.83) v1(237.49,226.57) v1(237.96,213.88) v1(239.01,217.68) v1(239.14,223.01) v1(239.14,222.25) v1(239.23,201.32) v1(239.26,208.02) v1(239.26,204.98) v1(239.87,212.22) v1(240.03,225.17) v1(241.04,216.41) v1(241.04,215.64) v1(241.3,209.88) v1(241.26,206.38) v1(241.26,202.97) v1(241.68,213.87) v1(242.82,217.68) v1(243.04,208.03) v1(243.2,226.57) v1(243.33,204.98) v1(243.68,212.22) v1(244.09,225.04) v1(244.95,209.89) v1(244.95,206.53) v1(244.98,223.77) v1(245.11,213.87) v1(246.5,226.57) v1(247.14,223.77) v1(247.52,225.04) v1(247.77,223.01) v1(247.77,222.25) v1(249.68,225.04) v1(250.57,222.63) v1(250.82,226.57) v1(251.2,223.77) v1(252.6,225.3) v1(252.6,222.63) v1(253.11,227.33) v1(255.14,225.17) v1(256.41,226.57) v1(257.42,225.04) v1(259.58,225.04) v1(260.73,226.57) v1(261.62,224.53) v1(262.76,226.44) v1(262.76,222.4) v1(264.41,227.71) v1(265.43,227.71)
