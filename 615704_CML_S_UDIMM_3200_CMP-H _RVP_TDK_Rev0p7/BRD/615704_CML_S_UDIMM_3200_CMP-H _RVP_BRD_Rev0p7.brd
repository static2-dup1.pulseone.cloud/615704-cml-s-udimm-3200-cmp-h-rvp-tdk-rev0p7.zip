# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
DS8A3  -  [SLED_24357IA]  48.42 261.87 0 top
DS8A4  -  [SLED_24357IA]  56.68 261.87 0 top
DS8H1  -  [SLEDR2012MA]  47.49 57.4 180 top
DS8H2  -  [SLEDR2012MA]  49.91 42.16 90 top
DS8H3  -  [SLEDR2012MA]  51.56 42.16 90 top
DS8H4  -  [SLEDR2012MA]  53.21 42.16 90 top
DS8H5  -  [SLEDR2012MA]  54.86 42.16 90 top
DS8H6  -  [SLEDR2012MA]  56.51 42.16 90 top
DS8H7  -  [SLEDR2012MA]  60.7 42.16 90 top
DS9J1  -  [SLEDR2012MA]  22.47 23.49 180 top
E4C1  0.005  [SMR4_0805IC_RVP]  184.15 199.9 270 top
E4C2  0.005  [SMR4_0805IC_RVP]  186.18 199.9 270 top
EU1B1  -  [TK0_LCC60_S7100_DFS5700_400_MA]  281.94 232.41 270 top
EU1D1  -  [LCC31_S51_50MA]  281.71 184.76 180 top
EU1D2  -  [LCC31_S51_50MA]  281.71 171.32 180 top
EU1E1  30V  [TK0_LCC5_S3100_650_DF2450X2280_MA_VR]  292.1 143 0 top
EU1E2  -  [LCC8_S20_50DF16X10MA]  293.62 138.43 180 top
EU2A1  -  [TK0_LCC10_1050X2550_500_MA]  254.12 273.68 90 top
EU2A2  -  [TK0_LCC10_1050X2550_500_MA]  257.81 273.68 90 top
EU2A3  -  [TK0_LCC10_1050X2550_500_MA]  261.36 273.68 90 top
EU2A4  -  [TK0_LCC10_1050X2550_500_MA]  264.92 273.68 90 top
EU2A5  -  [TK0_LCC10_1050X2550_500_MA]  268.98 273.68 90 top
EU2A6  -  [TK0_LCC10_1050X2550_500_MA]  272.54 273.68 90 top
EU2A7  -  [LCC48_S60_40DFS45MB]  256.1 265.93 180 top
EU2B1  -  [LCC8_S21_50DF16X9_VIA_MA]  272.92 259.33 180 top
EU2B2  -  [LCC31_S51_50MA]  253.89 242.59 270 top
EU2B3  -  [LCC31_S51_50MA]  243.96 242.57 270 top
EU2B4  -  [LCC31_S51_50MA]  267.2 242.57 270 top
EU2G1  -  [LCC20_S118_16DFS67IA]  263.27 81.02 0 top
EU2M1  -  [TK0_LCC16_S3050_DFS1525_500_MA]  259.33 244.09 90 bottom
EU3A1  -  [TK0_LCC10_1050X2550_500_MA]  242.06 279.14 90 top
EU3B1  -  [LCC31_S51_50MA]  207.28 242.59 270 top
EU3B2  -  [LCC31_S51_50MA]  230.65 242.59 270 top
EU3B3  -  [LCC31_S51_50MA]  220.59 242.57 270 top
EU3B4  -  [TK0_LCC42_3600X9100_500_DF2050X7550_MA]  220.06 256.41 90 top
EU3M1  -  [TK0_LCC16_S3050_DFS1525_500_MA]  236.09 244.09 90 bottom
EU3M2  -  [TK0_LCC16_S3050_DFS1525_500_MA]  212.72 244.09 90 bottom
EU4B1  -  [LCC48_S60_40DFS30MA]  186.94 259.14 180 top
EU4B2  -  [LCC8_79X59_20IA]  174.24 256.03 0 top
EU4B3  -  [LCC31_S51_50MA]  184.3 242.59 270 top
EU4B4  -  [LCC31_S51_50MA]  197.61 242.57 270 top
EU4B5  -  [TK0_LCC42_3600X9100_500_DF2050X7550_MA]  204.06 256.41 90 top
EU4G1  30V  [TK0_LCC5_S3100_650_DF2450X2280_MA_VR]  185.03 84.71 90 top
EU4G2  30V  [LCC8_56X53_127MA]  188.84 81.02 90 top
EU4M1  -  [TK0_LCC16_S3050_DFS1525_500_MA]  189.73 244.09 90 bottom
EU5A1  -  [LCC56_S7150_40DF340X550_MA]  142.36 267.33 0 top
EU5B1  CSD87350  [LCC8_50X60_127DF50X31MA]  163.7 243.2 0 top
EU5B2  -  [TK0_LCC28_S4100_400_DFS2400_MA]  155.82 240.03 90 top
EU5C1  30V  [TK0_LCC5_S3100_650_DF2450X2280_MA_VR]  153.54 215.14 180 top
EU5C2  -  [LCC8_S21_50_DF09X16MA]  161.92 210.44 0 top
EU5C3  -  [LCC14_30X20_40DF26X9MA]  160.78 201.04 90 top
EU5C4  -  [LCC8_S33_65DF18X27MA]  169.54 199.39 270 top
EU5C5  30V  [TK0_LCC5_S3100_650_DF2450X2280_MA_VR]  158.24 216.03 0 top
EU5D2  -  [LCC14_30X20_40DF26X9MA]  153.28 173.1 90 top
EU5D3  -  [LCC8_S33_65DF18X27MA]  161.41 169.04 270 top
EU5F1  -  [LCC8_S21_50_DF09X16MA]  141.35 105.15 90 top
EU5G1  30V  [LCC8_56X53_127MA]  152.9 90.55 180 top
EU5G2  30V  [LCC8_56X53_127MA]  147.32 88.39 0 top
EU5G3  -  [TK0_LCC10_S3050_DF1625X2475_500_MA]  163.44 93.98 180 top
EU6A1  -  [LCC48_S60_40DFS45MB]  123.95 278.64 90 top
EU6A2  -  [LCC14_S365_50DFS205MA]  113.15 264.16 0 top
EU6B1  -  [LCC8_S20_50DF16X10MA]  114.55 251.71 0 top
EU6B2  30V  [LCC8_56X53_127MA]  116.84 244.73 180 top
EU6B3  -  [LCC8_79X59_20IA]  121.92 238 90 top
EU6D1  -  [TK0_LCC40_6100X4100_400_DF4700X2700_MA]  131.82 183.64 90 top
EU7A1  -  [LCC10_S26_50DF125X215MA]  76.07 262 0 top
EU7A2  -  [LCC10_S26_50DF125X215MA]  82.29 262 0 top
EU7A3  -  [LCC56_S70_40DFS52MA]  94.48 260.09 90 top
EU7B1  30V  [TK0_LCC5_S3100_650_DF2450X2280_MA_VR]  74.93 257.43 0 top
EU7B2  30V  [TK0_LCC5_S3100_650_DF2450X2280_MA_VR]  70.73 257.43 180 top
EU7G3  -  [LCC8_80X60_127DF340X430MA]  94.51 82.17 180 top
EU7H1  -  [LCC16_40X35_50DF26X21_VIA_MA]  78.35 57.4 180 top
EU8B1  -  [LCC8_S20_50DF16X10MA]  56 256.67 180 top
EU8B2  30V  [TK0_LCC5_S3100_650_DF2450X2280_MA_VR]  43.81 255.27 0 top
EU8B3  30V  [TK0_LCC5_S3100_650_DF2450X2280_MA_VR]  50.16 255.27 180 top
EU8B4  -  [LCC8_S20_50DF16X10MA]  33.27 254.89 0 top
EU8F1  -  [LCC8_S21_50DF16X9MA]  25.27 118.87 180 top
EU8F2  -  [LCC10_S30_50DF26X17MA]  52.07 99.69 180 top
EU8G1  -  [LCC10_S30_50DF26X17MA]  54.99 87.25 180 top
EU8G2  30V  [LCC8_56X53_127MA]  43.56 79.25 270 top
EU8G3  -  [LCC16_40X35_50DF26X21_VIA_MA]  35.05 70.1 90 top
EU8H1  -  [LCC12_S25_40DF20X13MA]  54.86 48.51 270 top
EU8H2  -  [LCC8_S21_50DF16X9MA]  60.7 48.39 270 top
EU9E1  -  [LCC8_80X60_127DF340X430MA]  17.27 139.95 0 top
F3A1  -  [SFU1206IE]  231.77 279.27 90 top
F6C1  -  [SFU1206IE]  132.71 207.77 270 top
F6G1  -  [SFU0603IB]  103.63 84.07 0 top
F6G2  -  [SFU0603IB]  102.48 72.64 0 top
F6G3  -  [SFU0603IB]  121.41 70.99 0 top
FB2L1  120OHM  [SFB0402IA]  244.22 267.71 90 bottom
FB2L2  330  [SFB1608MB]  254.25 264.54 270 bottom
FB3A1  120OHM  [SFB0603IB]  212.09 261.36 90 top
FB3A2  120OHM  [SFB0603IB]  213.48 261.36 90 top
FB3L1  120OHM  [SFB0402IA]  238.5 264.41 0 bottom
FB5A1  120OHM  [SFB0603IB]  147.82 285.49 0 top
FB5A2  60OHM  [SFB0603IA]  149.6 280.92 90 top
FB5A3  60OHM  [SFB0603IA]  160.27 278.76 90 top
FB5A4  120OHM  [SFB0603IB]  153.41 278.38 90 top
FB5A5  21  [TK0_SM0805_2200X1450_MC]  135.25 262.63 270 top
FB5A6  21  [TK0_SM0805_2200X1450_MC]  135.89 271.4 90 top
FB6A1  30ohm  [SFB0805MA]  116.45 284.73 90 top
FB6A2  120OHM  [SFB0603IB]  131.69 274.7 90 top
FB6J1  60OHM  [SFB0603IA]  115.18 22.73 90 top
FB9B1  60OHM  [SFB0603IA]  13.33 232.28 90 top
FB9B2  60OHM  [SFB0603IA]  14.6 232.28 90 top
FB9C1  60OHM  [SFB0603IA]  15.62 220.92 270 top
FB9C2  60OHM  [SFB0603IA]  16.76 220.92 270 top
ISO2B1  -  [GND_ISOLATION]  254.5 237.49 0 top
ISO2B2  -  [GND_ISOLATION]  266.44 237.49 0 top
ISO2B3  -  [GND_ISOLATION]  271.14 233.68 0 top
ISO2B4  -  [GND_ISOLATION]  254.5 230 180 top
ISO2B5  -  [GND_ISOLATION]  266.44 230 180 top
ISO2C1  -  [GND_ISOLATION]  270 225.42 0 top
ISO2D1  -  [GND_ISOLATION]  274.32 187.58 0 top
ISO2D2  -  [GND_ISOLATION]  274.32 180.21 180 top
ISO2D3  -  [GND_ISOLATION]  274.32 176.15 0 top
ISO2D4  -  [GND_ISOLATION]  274.32 168.65 180 top
ISO3B1  -  [GND_ISOLATION]  207.89 237.49 0 top
ISO3B2  -  [GND_ISOLATION]  219.83 237.49 0 top
ISO3B3  -  [GND_ISOLATION]  231.26 237.49 0 top
ISO3B4  -  [GND_ISOLATION]  243.2 237.49 0 top
ISO3B5  -  [GND_ISOLATION]  207.89 230 180 top
ISO3B6  -  [GND_ISOLATION]  219.83 230 180 top
ISO3B7  -  [GND_ISOLATION]  231.26 230 180 top
ISO3B8  -  [GND_ISOLATION]  243.2 230 180 top
ISO4B1  -  [GND_ISOLATION]  184.91 237.49 0 top
ISO4B2  -  [GND_ISOLATION]  196.85 237.49 0 top
ISO4B3  -  [GND_ISOLATION]  184.91 230 180 top
ISO4B4  -  [GND_ISOLATION]  196.85 230 180 top
ISO5G1  -  [GND_ISOLATION]  163.32 91.69 90 top
ISO6L1  -  [GND_ISOLATION]  121.15 279.65 270 bottom
ISO6L2  -  [GND_ISOLATION]  121.15 277.62 270 bottom
ISO17528  -  [GND_ISOLATION]  173.48 244.85 0 top
ISO17599  -  [GND_ISOLATION]  173.48 241.81 180 top
J1A1  -  [PWR_TPV_2X4_1M_420MA]  286.29 279.35 90 top
J1A2  -  [HDR_TPR_2X4_420MA]  286.29 279.35 0 top
J1A3  -  [PWR_TPV_2X2_1M_420MA]  286.3 279.35 90 top
J1A4  -  [HDR_TPV_1X3IA]  296.79 267.59 90 top
J1B1  -  [HDR_TPV_1X2_2540_MA_CCG1]  285.75 253.74 0 top
J1B2  -  [TK0_SHDR_SHLD_SJV_1X44_11EM_2M_500_MA]  299.59 237.36 180 top
J1C1  -  [XDP_SJV_2X30_2M_MB]  293.55 198.74 180 top
J1D1  -  [HDR_TPV_1X2_2540_MA_CCG1]  300.6 190.12 90 top
J1D2  -  [HDR_TPV_1X2_2540_MA_CCG1]  283.59 74.17 0 top
J1D4  -  [HDR_TPV_1X2_2540_MA_CCG1]  300.6 159.51 90 top
J1D9  -  [HDR_TPV_1X3IA]  294.89 170.94 0 top
J1E1  -  [HDR_TPV_1X2_2540_MA_CCG1]  272.16 74.17 0 top
J1E3  -  [HDR_TPV_1X4_1M_IB]  300.1 146.68 180 top
J1E5  -  [DDR4_TJV_4X72_3M_MB]  282.77 131.66 270 top
J1F1  -  [DDR4_TJV_4X72_3M_MB]  282.75 123.88 270 top
J1F2  -  [DDR4_TJV_4X72_3M_MB]  282.77 113.46 270 top
J1F3  -  [DDR4_TJV_4X72_3M_MB]  282.75 104.57 270 top
J1G3  -  [HDR_TPV_2X2MA]  301.24 78.36 270 top
J1G4  -  [HDR_TPV_2X2MA]  301.24 72.01 270 top
J1G5  -  [HDR_TPV_2X2MA]  301.24 65.66 270 top
J2A1  -  [DP_HDMI_TJR_19P_20P_4EM_2M_IA]  258.06 277.44 180 top
J2A2  -  [HDR_TPV_1X2_2540_MA_CCG1]  249.04 273.3 90 top
J3A1  -  [USB3_SHLD_TJR_26P_6EM_200MA]  218.18 281.6 180 top
J3A2  -  [HDMI_TJR_19P_4EM_1M_MA]  237.49 281.34 180 top
J3D1  -  [LPDB_LGA1200_CML_S_LP6930_MA]  222.42 180.72 0 top
J4A1  -  [USBC_SHLD_SJR_24P_6EM_2M_MB_PIP]  173.35 284.09 180 top
J4A2  -  [USBX32_SHLD_RJV_5X7_8M_IB]  191.26 281.6 180 top
J4G1  -  [PWR_TPV_2X12_2M_420MA]  181.22 68.07 90 top
J4H1  -  [HDR_TPV_1X3IA]  174.49 33.53 0 top
J4J1  -  [HDR_TPV_1X2_2540_MA_CCG1]  172.97 24.51 90 top
J4J2  -  [HDR_TPV_1X2_2540_MA_CCG1]  172.97 20.7 90 top
J4J3  -  [HDR_TPV_1X2_2540_MA_CCG1]  172.97 13.08 90 top
J4J4  -  [HDR_TPV_1X2_2540_MA_CCG1]  172.97 16.89 90 top
J4R1  -  [LAI_SJV_PCIE3_X8_MIDBUS_4M_IB]  172.31 160.85 0 bottom
J5A1  -  [AUDIO_TJR_8P_2M_MA]  155.32 290.84 180 top
J5B1  -  [HDR_TPV_2X3_100IA]  150.11 248.28 90 top
J5B2  -  [PCIE_TPV_4X41_2M_IA]  143.78 246.65 0 top
J5B3  -  [PCIEX4_SJR_2X37_2EM_2M_MB]  151.78 228.18 90 top
J5D1  -  [INS_7000_4320_MA]  161.03 183.85 180 top
J5E1  -  [INS_7000_4320_MA]  161.03 145.85 180 top
J5H1  -  [SASHD_TJR_4X9_2EM_75MA]  157.71 62.65 90 top
J5J1  -  [SHDR_SPV_SHF_2X10_127MA]  135.63 29.84 90 top
J5J2  -  [SATA_SPR_1X22_2E_2M_IA]  147.82 5.84 270 top
J6B1  -  [HDR_TPV_2X10_K1_2M_MA]  111.5 255.14 90 top
J6B2  -  [INS_7000_4320_MA]  102.66 235.57 0 top
J6B5  -  [USB3A_SHIELD_TJV_9P_4EM_200MA]  111.01 227.27 0 top
J6C3  -  [USB3P1_MPV_2X10_6EM_2M_80MB]  99.56 191.97 90 top
J6C4  -  [USB3P1_MPV_2X10_6EM_2M_80MA]  115.2 204.34 90 top
J6G1  -  [SATA_TPV_1X7_2EM_MA]  113.03 78.1 0 top
J6G2  -  [SATA_TPV_1X7_2EM_MA]  113.03 66.93 0 top
J6H1  -  [SATA_TPV_1X7_2EM_MA]  131.57 64.51 0 top
J6H2  -  [XDP_SJV_2X30_2M_MB]  108.58 44.32 90 top
J6J1  -  [HDR_TPV_2X10IB]  116.2 29.59 90 top
J6J2  -  [XSEAF240_50MA]  130 15.82 0 top
J7A1  -  [RJ45_SHLD_TJR_12P_2LED_2EM_2M_08IA]  71.37 273.29 90 top
J7A2  -  [HDR_TPV_2X5_254MA]  96.64 270.25 90 top
J7B1  -  [PCIE_TPV_4X16_2M_MA_CCG]  62.51 246.65 0 top
J7C1  -  [PCIE_SJR_75P_KEYE_2EM_2M_MB_KOZ_2230_CCG]  70.33 226.32 180 top
J7C2  -  [CON_SJR_1X2_2EM_MB]  88.13 219.71 90 top
J7C3  -  [CON_SJR_1X2_2EM_MB]  93.72 219.71 90 top
J7C7  -  [HDR_TPV_2X5_254MC]  83.31 200.53 180 top
J7C9  -  [HDR_TPV_1X3_50IB]  83.43 195.32 270 top
J7D2  -  [HDR_TPV_1X2_2540_MA_CCG1]  81.91 191.39 270 top
J7D3  -  [HDR_TPV_1X2_2540_MA_CCG1]  81.91 187.58 270 top
J7G1  -  [HDR_SPV_2X25_2M_K29K30K31_50IA]  77.25 69.72 90 top
J7G2  -  [HDR_SJV_2X10_K1_2M_IA]  81.16 68.01 90 top
J7H1  -  [CON_SJV_2X5_2EM_05IA_CCG1]  85.8 47.47 270 top
J7J1  -  [HDR_SPV_2X14_K4K21K22IA]  78.35 28.19 90 top
J7J3  -  [HDR_TPV_1X2_2540_MA_CCG1]  62.73 16.13 0 top
J7J4  -  [HDR_TPV_1X5IA]  82.29 12.19 270 top
J7J6  -  [DIN_TJR_12P_5EM_MA]  78.42 7.49 180 top
J8B1  -  [PCIE_TPV_4X16_2M_MA_CCG]  42.18 246.65 0 top
J8H1  -  [PCIEX4_SJR_2X37_2EM_2M_MB]  42.52 57.09 270 top
J8H2  -  [B2B_SJV_2X30_2M_IA]  53.46 55.5 90 top
J8H3  -  [HDR_TPV_1X2_2540_MA_CCG1]  27.94 39.24 0 top
J8H4  -  [HDR_TPV_1X2_2540_MA_CCG1]  48.64 36.45 0 top
J8H5  -  [HDR_TPV_1X4IA]  40.51 33.65 0 top
J8H6  -  [HDR_TPV_1X4IA]  44.7 33.65 0 top
J8J1  -  [HDR_TPV_1X3IA]  48.64 31.37 0 top
J8J2  -  [HDR_TPV_1X3_254MB]  27.94 31.11 0 top
J8J3  -  [HDR_TPV_1X3IA]  36.32 31.11 0 top
J8J4  -  [HDR_TPV_1X2_2540_MA_CCG1]  32.13 27.43 0 top
J8J5  -  [HDR_TPV_1X3IA]  27.94 20.06 0 top
J8J6  -  [HDR_TPV_1X3IA]  32.13 20.06 0 top
J8J7  -  [HDR_TPV_1X3IA]  36.32 20.06 0 top
J8J8  -  [HDR_TPV_1X3IA]  40.51 20.06 0 top
J8J9  -  [HDR_TPV_1X3_2540_MB]  44.57 20.06 0 top
J8J10  -  [HDR_TPV_1X3IA]  48.76 20.06 0 top
J8J11  -  [HDR_TPV_1X3IA]  52.95 20.06 0 top
J8J12  -  [HDR_TPV_1X3IA]  57.15 20.06 0 top
J8J13  -  [HDR_TPV_2X20_1M_2X2MA]  25.52 7.11 90 top
J9A1  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.22 278.38 90 top
J9A2  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.22 274.57 90 top
J9A3  -  [HDR_TPV_1X3IA]  19.68 273.43 90 top
J9A4  -  [HDR_TJV_2X8_K12_100X100IA]  4.82 270.76 0 top
J9A5  -  [HDR_TPV_2X6_254MA]  19.68 269.49 0 top
J9B1  -  [HDR_TPV_2X4IA]  19.68 252.47 0 top
J9B2  -  [HDR_TPV_1X4IA]  9.77 248.79 0 top
J9B3  -  [HDR_TPV_1X4IA]  5.26 248.71 0 top
J9B4  -  [HDR_TPV_2X3_100IA]  19.68 240.54 0 top
J9B5  -  [HDR_TPV_1X3IA]  5.2 237.49 0 top
J9B6  -  [HDR_TPV_1X3IA]  9.77 237.49 0 top
J9B7  -  [HDR_TPV_2X5_K10_2540MA]  5.33 228.47 0 top
J9C1  -  [HDR_TPV_1X4_1M_IB]  6.73 214.12 0 top
J9D1  -  [MICROSD_SJR_10P_4EM_MA]  19.68 193.17 270 top
J9D2  -  [CON_SPR_1X10_2M_20IA]  10.41 182.5 270 top
J9D3  -  [HDR_TPV_2X3_100IA]  20.57 177.16 0 top
J9D4  -  [B2B_SJR_1X5_2M_MA]  11.27 169.92 270 top
J9D5  -  [HDR_TPV_2X4IA]  20.57 167.38 0 top
J9E1  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 159.76 90 top
J9E2  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 155.95 90 top
J9E3  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 152.14 90 top
J9E4  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 148.21 90 top
J9E5  -  [HDR_TPV_1X2_2540_MA_CCG1]  16.63 46.48 90 top
J9E6  -  [HDR_TPV_1X3IA]  12.19 145.03 0 top
J9E7  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 144.4 90 top
J9E8  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 140.59 90 top
J9E9  -  [HDR_TPV_2X10_K1_2M_MA]  5.71 134.87 0 top
J9F2  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 118.36 90 top
J9F3  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 110.62 90 top
J9F4  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 114.55 90 top
J9F5  -  [HDR_TJV_1X5_IA]  4.95 105.79 0 top
J9F6  -  [HDR_TPV_1X3IA]  8.89 100.84 0 top
J9G1  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 91.95 90 top
J9G2  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 88.14 90 top
J9G5  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 76.71 90 top
J9G6  -  [HDR_TPV_1X2_2540_MA_CCG1]  5.96 36.7 90 top
J9G7  -  [HDR_TPV_1X2_2540_MA_CCG1]  6.98 72.77 90 top
J9G8  -  [HDR_TPV_1X2_2540_MA_CCG1]  32.13 39.24 0 top
J9H1  -  [HDR_TPV_2X5_K10_2540MA]  7.62 57.02 180 top
J9H2  -  [HDR_TPV_2X4IA]  4.95 48 0 top
J9H3  -  [HDR_TPV_2X4_K7_254MA]  15.36 42.42 0 top
J9H4  -  [HDR_TPV_2X3_100IA]  4.82 32.76 0 top
J9J1  -  [HDR_TPV_2X3_100IA]  15.36 30.48 0 top
J9J2  -  [HDR_TPV_2X4IA]  4.95 24 0 top
J9J4  -  [HDR_TPV_1X2_2540_MA_CCG1]  24 18.79 0 top
J9J5  -  [HDR_TPV_1X2_2540_MA_CCG1]  17.01 6.48 90 top
L2A1  90OHM  [SMI4_13X10MA]  252.83 271.07 90 top
L2A2  90OHM  [SMI4_13X10MA]  254.86 271.07 90 top
L2A3  90OHM  [SMI4_13X10MA]  256.51 271.07 90 top
L2A4  90OHM  [SMI4_13X10MA]  258.54 271.07 90 top
L2B1  22uH  [SMI40X40MB]  267.71 258.57 90 top
L2B2  0.220 uH  [I415X295_345IA]  254.5 238.12 270 top
L2B3  0.220 uH  [I415X295_345IA]  266.44 238.12 270 top
L2D1  0.220 uH  [I415X295_345IA]  274.32 179.58 90 top
L2D2  0.220 uH  [I415X295_345IA]  274.32 168.02 90 top
L2G1  0.3uH  [SMI_S29IA]  265.55 92.33 180 top
L3A1  90OHM  [SMI4_50X65MA]  237.99 276.45 90 top
L3A2  90OHM  [SMI4_79X47IA]  208.15 267.54 0 top
L3A3  90OHM  [SMI4_79X47IA]  208.15 265.25 0 top
L3A4  90OHM  [SMI4_79X47IA]  223.82 264.92 90 top
L3A5  90OHM  [SMI4_79X47IA]  226.49 264.92 90 top
L3A6  90OHM  [SMI4_50X65MA]  215.9 264.51 90 top
L3A7  90OHM  [SMI4_50X65MA]  219.71 264.51 90 top
L3B1  0.220 uH  [I415X295_345IA]  207.89 238.12 270 top
L3B2  0.220 uH  [I415X295_345IA]  219.83 238.12 270 top
L3B3  0.220 uH  [I415X295_345IA]  231.26 238.12 270 top
L3B4  0.220 uH  [I415X295_345IA]  243.2 238.12 270 top
L4A1  90OHM  [SMI4_50X65MA]  199.13 264.51 90 top
L4A2  90OHM  [SMI4_50X65MA]  202.94 264.51 90 top
L4B1  4.7uH  [SMI2020MA]  192.15 258.7 90 top
L4B2  0.47uH  [TK0_SM_7300X6800_MC]  173.51 243.33 90 top
L4B3  0.220 uH  [I415X295_345IA]  184.91 238.12 270 top
L4B4  0.220 uH  [I415X295_345IA]  196.85 238.12 270 top
L4C1  0.60UH  [SMI40X40MA]  171.45 196.09 270 top
L5A1  90OHM  [SMI4_79X47IA]  165.55 281.05 270 top
L5A2  0.6uH  [SMI40X40MA]  154.43 268.6 90 top
L5C1  1uH  [SMI2520MD]  165.6 210.69 0 top
L5D1  0.60UH  [SMI40X40MA]  161.92 165.23 270 top
L5F1  1uH  [SMI2520MD]  141.6 109.47 0 top
L5G1  0.56uH  [SMI26X25IA]  144.01 89.79 180 top
L6A1  2.2uH  [SMI53X55MB]  116.84 262.89 0 top
L6C1  90OHM  [SMI4_79X47IA]  106.12 221.87 270 top
L6C2  90OHM  [SMI4_50X65MA]  120.67 221.74 180 top
L6C3  90OHM  [SMI4_79X47IA]  98.34 195.27 90 top
L6C4  90OHM  [SMI4_79X47IA]  113.04 185.1 315 top
L6D1  90OHM  [SMI4_79X47IA]  115.9 191.77 270 top
L6D2  90OHM  [SMI4_50X65MA]  120.89 190.87 90 top
L6D3  2.2uH  [SMI2012MB]  101.09 178.18 90 top
L6D4  2.2uH  [SMI2012MB]  105.91 178.18 180 top
L6F1  2.2uH  [SMI2012MB]  115.69 114.93 0 top
L6G1  80OHM  [SMI4_0605MA]  111.25 83.23 270 top
L6G2  80OHM  [SMI4_0605MA]  111.37 72.08 270 top
L6G3  80OHM  [SMI4_0605MA]  129.87 69.98 270 top
L7B1  1uH  [SMI22X18MA]  94.1 252.98 270 top
L8D1  1uH  [SMI2520MD]  47.72 164.71 0 top
L8E1  1uH  [SMI2520MD]  47.65 155.57 0 top
L8E2  1uH  [SMI2520MD]  47.67 146.42 0 top
L8E3  1uH  [SMI2520MD]  47.65 137.13 0 top
L8F1  1uH  [SMI2520MD]  47.62 128.24 0 top
L8F2  1.5uH  [SMI_S68_MA]  54.86 100.96 0 top
L8G1  2.2uH  [SMI40X40MA]  57.02 87.5 0 top
LB5G1  -  [LB_B4_IA]  135.76 80.14 0 top
LB5G2  -  [LB_E1_IA]  140.97 67.18 0 top
LB6H1  -  [LB_PBF_2LI_IA]  130.83 54.46 0 top
LP4A1  90OHM  [SMI4_79X47IA]  205.1 272.34 180 top
LP4A2  90OHM  [SMI4_79X47IA]  204.97 270.05 180 top
LP7C1  90OHM  [SMI4_79X47IA]  66.59 222.76 90 top
LP7C2  90OHM  [SMI4_79X47IA]  86.28 199.64 90 top
LP7C3  90OHM  [SMI4_79X47IA]  88.82 199.64 90 top
M7J1  0  [SMR0603IA]  80.89 23.62 270 top
MH1B1  -  [SCH_MTG_NLX_N156_PCCG]  298.45 259.08 0 top
MH1F1  -  [SCH_MTG_NLX_N156_PCCG]  298.45 127 0 top
MH1H1  -  [SCH_MTG_NLX_N156_PCCG]  298.45 54.61 0 top
MH5A1  -  [SCH_MTG_NLX_N156_PCCG]  140.97 281.94 0 top
MH5F1  -  [SCH_MTG_NLX_N156_PCCG]  140.97 127 0 top
MH5H1  -  [SCH_MTG_NLX_N156_PCCG]  140.97 54.61 0 top
MH7A1  -  [SCH_MTG_NLX_N156_PCCG]  95.25 281.94 0 top
MH9A1  -  [SCH_MTG_NLX_N156_PCCG]  16.51 281.94 0 top
MH9F1  -  [SCH_MTG_NLX_N156_PCCG]  16.51 127 0 top
MH9H1  -  [SCH_MTG_NLX_N156_PCCG]  16.51 54.61 0 top
NOREF  -  []  63.61 289.91 0 top
NOREF#2  -  [unnamed#2]  57.41 74.71 0 top
NOREF#3  -  []  32.8 130.27 90 top
NOREF#4  -  [unnamed#3]  94.49 259.84 0 top
NOREF#5  -  []  63.61 289.91 0 top
NOREF#6  -  []  27.77 130.05 90 top
NOREF#7  -  []  16.51 -6.35 0 top
NOREF#8  -  [unnamed#2]  -7 287.1 0 top
NOREF#9  -  []  28.13 129.62 0 top
NOREF#10  -  []  -262.54 -355.89 0 top
NOREF#11  -  []  28.13 129.62 90 top
NOREF#12  -  [unnamed#2]  264.26 287.84 0 top
NOREF#13  -  []  161.19 134.79 0 top
NOREF#14  -  [unnamed#2]  -7 4.99 0 top
NOREF#15  -  [unnamed#4]  140.46 45.46 0 top
NOREF#16  -  [unnamed#2]  192.32 27.19 90 top
NOREF#17  -  []  27.77 130.05 0 top
NOREF#18  -  [unnamed#2]  311.8 287.1 0 top
NOREF#19  -  [unnamed#2]  311.8 4.99 0 top
NOREF#20  -  [unnamed#2]  292.42 272.3 0 top
NOREF#21  -  []  91.82 -69.47 0 top
Q1A1  -  [SOT23MA]  281.94 268.6 270 top
Q1B1  -  [BGA4_1_50MD]  280.54 243.2 180 top
Q1C1  FDN306P  [SOT23MA]  293.62 220.6 180 top
Q1C2  -  [SOT23MA]  300.73 219.84 90 top
Q1C3  -  [SOT23MA]  300.73 216.15 90 top
Q2A1  -  [SOT23MA]  253.87 277.87 270 top
Q2A2  -  [BGA4_1_50MD]  277.49 277.11 180 top
Q2A3  2SK3541T2L  [SOT723MA]  269.36 268.48 180 top
Q2A4  2SK3541T2L  [SOT723MA]  272.16 268.1 180 top
Q2A5  2SK3541T2L  [SOT723MA]  278 267.97 180 top
Q2A6  2SK3541T2L  [SOT723MA]  269.11 267.59 270 top
Q2A7  2SK3541T2L  [SOT723MA]  272.16 266.32 180 top
Q2A8  2SK3541T2L  [SOT723MA]  278 266.32 180 top
Q2G1  MGSF1N02LT1G  [SOT23MA]  249.93 82.04 180 top
Q3B1  BAT54C  [SOT23MA]  231.14 257.55 180 top
Q3G2  2N7002PS  [SC70_6_20X13MA]  221.48 78.61 180 top
Q3G3  -  [SOT23MA]  225.8 78.36 180 top
Q4G1  2N7002PS  [SC70_6_20X13MA]  186.18 92.58 180 top
Q4G2  -20V  [LCC5_S30_65DF1MA]  179.57 83.31 90 top
Q4G3  FDN306P  [SOT23MA]  197.35 78.48 0 top
Q4G4  FDN306P  [SOT23MA]  180.97 77.34 90 top
Q4H1  -  [SOT363MB]  177.67 59.05 0 top
Q4H2  2N7002PS  [SC70_6_20X13MA]  171.06 57.53 90 top
Q4H3  -  [SOT363MB]  177.67 56.64 0 top
Q4H4  -  [SOT23IA]  174.11 52.96 0 top
Q4H5  -  [SOT23MA]  177.92 52.96 0 top
Q4J1  -  [SOT23MA]  173.48 8.13 180 top
Q5B1  -  [SOT23MA]  149.35 239.65 270 top
Q5C1  -20V  [LCC5_S30_65DF1MA]  154.94 210.31 180 top
Q5C2  2N7002PS  [SC70_6_20X13MA]  157.09 207.01 270 top
Q5C3  2N7002PS  [SC70_6_20X13MA]  150.87 205.1 90 top
Q5C4  2N7002PS  [SC70_6_20X13MA]  153.34 205.1 90 top
Q5D1  2N7002PS  [SC70_6_20X13MA]  152.01 165.48 0 top
Q5D2  -  [SOT23MA]  148.14 163.44 0 top
Q5E1  2N7002PS  [SC70_6_20X13MA]  153.03 161.92 270 top
Q5E2  2N7002PS  [SC70_6_20X13MA]  154.17 160.02 90 top
Q5E3  -  [SOT23MA]  151.13 153.29 0 top
Q5M1  DMN62D0LFB  [LCC3_10X6_35MA]  154.05 238.38 90 bottom
Q5M2  DMN62D0LFB  [LCC3_10X6_35MA]  148.84 237.87 270 bottom
Q5M3  DMN62D0LFB  [LCC3_10X6_35MA]  149.22 234.57 0 bottom
Q5M4  DMN62D0LFB  [LCC3_10X6_35MA]  161.92 235.33 0 top
Q6A1  2N7002PS  [SC70_6_20X13MA]  121.66 268.98 270 top
Q6A2  2N7002PS  [SC70_6_20X13MA]  127.38 267.71 270 top
Q6A3  -20V  [LCC5_S30_65DF1MA]  129.79 265.56 90 top
Q6A4  -20V  [LCC5_S30_65DF1MA]  131.82 262.76 270 top
Q6C1  -  [SOT23MA]  129.41 221.87 0 top
Q6G1  -  [SOT23MA]  104.01 96.01 180 top
Q6G2  -  [SOT23MA]  108.33 96.01 180 top
Q6L1  -  [SOT23MA]  111.5 264.79 180 bottom
Q6T1  -  [SOT23MA]  108.96 100.71 180 bottom
Q6T2  -  [SOT23MA]  104.26 100.71 180 bottom
Q7A1  2N7002PS  [SC70_6_20X13MA]  66.29 259.97 180 top
Q7B1  2N7002PS  [SC70_6_20X13MA]  64.38 258.82 0 top
Q7B2  -  [SOT23MA]  67.56 256.28 0 bottom
Q7B3  -  [SOT23MA]  64.32 256.22 0 top
Q7B4  -20V  [LCC5_S30_65DF1MA]  73.53 254.51 0 top
Q7B5  -  [SOT23MA]  63.62 252.86 0 top
Q7B6  -  [SOT23MA]  66.42 248.54 90 top
Q7B7  -  [SOT23MA]  86.48 244.98 180 top
Q7B8  -  [SOT23MA]  86.48 241.43 180 top
Q7B9  -  [SOT23MA]  84.07 232.28 0 top
Q7B10  -  [SOT23MA]  84.07 228.85 0 top
Q7C1  2N7002PS  [SC70_6_20X13MA]  84.45 222.63 90 top
Q7F1  2SK3541T2L  [SOT723MA]  70.86 120.27 180 top
Q7G1  -  [SOT23MA]  81.02 93.98 270 top
Q7G2  -  [SOT363MB]  62.73 78.61 0 top
Q7H1  -  [SOT363MB]  96.9 41.78 90 top
Q7H2  FDN306P  [SOT23MA]  81.78 41.15 270 top
Q7H3  FDN306P  [SOT23MA]  87.12 41.15 270 top
Q8A1  2SK3541T2L  [SOT723MA]  25.27 265.68 0 top
Q8B1  -  [SOT23MA]  29.97 258.19 0 top
Q8B2  -  [SOT23MA]  33.78 258.19 0 top
Q8C1  -  [SOT23MA]  28.82 218.57 90 top
Q8C2  -  [SOT23MA]  32.25 218.57 90 top
Q8C3  -  [SOT23MA]  28.19 213.36 90 top
Q8C4  -  [SOT23MA]  28.19 209.42 90 top
Q8C5  -  [SOT23MA]  45.84 206.75 0 top
Q8C6  -  [SOT23MA]  49.65 206.75 0 top
Q8C7  2N7002PS  [SC70_6_20X13MA]  32.76 205.87 90 top
Q8C8  -  [SOT23MA]  38.22 204.34 90 top
Q8C9  2N7002PS  [SC70_6_20X13MA]  35.43 202.06 0 top
Q8C10  2N7002PS  [SC70_6_20X13MA]  40.13 202.06 0 top
Q8C11  2N7002PS  [SC70_6_20X13MA]  45.84 202.06 0 top
Q8C12  -  [SOT363MB]  39.37 197.86 0 top
Q8C13  2N7002PS  [SC70_6_20X13MA]  42.92 197.86 0 top
Q8C14  FDN306P  [SOT23MA]  51.05 194.94 90 top
Q8C15  -  [SOT23MA]  54.48 194.94 90 top
Q8D1  2N7002PS  [SC70_6_20X13MA]  41.02 192.66 0 top
Q8D2  2SK3541T2L  [SOT723MA]  27.94 191.64 90 top
Q8D3  -  [SOT23MJ]  34.03 190.88 90 top
Q8D4  -  [SOT23MJ]  37.33 190.88 90 top
Q8D5  -  [SOT23MA]  30.73 190.75 90 top
Q8D6  -  [SOT23MA]  44.83 190.75 90 top
Q8D7  -  [SOT23MA]  57.4 190.75 90 top
Q8D8  -  [SOT23MA]  60.96 190.75 90 top
Q8D9  -  [SOT23MA]  49.27 187.83 0 top
Q8D10  -  [SOT23MJ]  42.29 180.21 90 top
Q8D11  -  [SOT23MA]  32.13 180.08 90 top
Q8D12  -  [SOT23MA]  38.98 180.08 90 top
Q8D13  MGSF1N02LT1G  [SOT23MA]  35.43 166.37 0 top
Q8D14  MGSF1N02LT1G  [SOT23MA]  35.43 162.94 0 top
Q8E1  -  [SOT23MA]  34.03 156.72 90 top
Q8E2  -  [SOT23MA]  37.84 156.72 90 top
Q8E3  -  [SOT23MA]  37.84 152.91 90 top
Q8E4  -  [SOT23MA]  34.06 152.9 90 top
Q8E5  -  [SOT23MA]  36.04 150.88 270 top
Q8E6  -  [SOT23MA]  39.75 150.87 270 top
Q8E7  -  [SOT23MA]  37.84 144.78 90 top
Q8E8  -  [SOT23MA]  34.06 144.78 90 top
Q8E9  -  [SOT23MA]  37.33 134.75 0 top
Q8E10  -  [SOT23MA]  37.33 131.19 0 top
Q8F1  -  [SOT23MA]  44.7 117.73 90 top
Q8G1  FDN306P  [SOT23MA]  58.29 95.38 270 top
Q8G2  -  [SOT23MA]  41.27 89.03 180 top
Q8G3  -  [SOT23MA]  45.08 89.03 180 top
Q8G4  FDN306P  [SOT23MA]  55.62 80.77 180 top
Q8G5  -  [SOT23MA]  25.65 80.26 180 top
Q8G6  -  [SOT23MA]  29.84 80.26 180 top
Q8G7  FDN306P  [SOT23MA]  47.24 79.12 270 top
Q8G8  -  [SOT23MA]  26.79 77.47 0 top
Q8H1  -  [SC88_6_135X220_65MA]  25.01 49.15 0 top
Q8H2  -  [SOT23MA]  49.65 47.75 180 top
Q8H3  2SK3541T2L  [SOT723MA]  33.27 46.73 0 top
Q8H4  2SK3541T2L  [SOT723MA]  47.75 45.59 180 top
Q8H5  -  [SC88_6_135X220_65MA]  25.01 45.08 0 top
Q8H6  2SK3541T2L  [SOT723MA]  47.75 43.69 180 top
Q8H7  2SK3541T2L  [SOT723MA]  47.75 41.65 180 top
Q9C1  PMV40UN2  [SOT23MH]  13.33 217.04 0 top
Q9C2  PMV40UN2  [SOT23MH]  12.82 208.41 180 top
Q9F1  2SK3541T2L  [SOT723MA]  12.7 98.42 180 top
Q9G1  -  [SOT23MA]  14.98 84.07 270 top
Q9G2  -  [SOT23MA]  18.41 84.07 270 top
Q9G3  -  [SOT23MA]  22.09 84.07 270 top
Q9G4  -  [SOT23MA]  22.98 74.04 0 top
Q9G5  -  [SOT23MA]  15.11 73.91 270 top
Q9G6  2N7002PS  [SC70_6_20X13MA]  18.66 67.69 270 top
R1A1  1K  [SMR0402IA]  302.76 278.89 270 top
R1A2  10K  [SMR0402IA]  302.76 275.33 90 top
R1A3  0.01  [SMR0603IA]  281.68 270.89 180 top
R1A4  0  [SMR0402IA]  297.68 269.87 180 top
R1A5  0  [SMR0402IA]  299.21 269.87 0 top
R1A6  1M  [SMR0402IA]  280.54 269.75 0 top
R1B1  0.002  [SMR4_2512IG_RVP]  283.71 258.82 180 top
R1B2  0  [SMR0402IA]  293.24 254.13 90 top
R1B3  200K  [SMR0402IA]  285.87 249.93 270 top
R1B4  10K  [SMR0402IA]  289.05 250.82 90 top
R1B5  0  [SMR0402IA]  289.94 250.82 90 top
R1B6  0  [SMR0402IA]  290.83 250.82 90 top
R1B7  100K  [SMR0402IA]  291.71 250.82 90 top
R1B8  10mOHM  [SMR0603IC]  293.49 250.57 270 top
R1B9  24.9K  [SMR0402IA]  288.16 249.55 270 top
R1B10  11K  [SMR0402IA]  288.16 247.78 270 top
R1B11  0  [SMR0402IA]  286.89 247.39 270 top
R1B12  10mOHM  [SMR0603IC]  292.6 247.39 270 top
R1B13  10mOHM  [SMR0603IC]  294 247.39 270 top
R1B14  0  [SMR0402IA]  282.82 246 270 top
R1B15  10K  [SMR0402IA]  291.97 244.98 0 top
R1B16  100K  [SMR0402IA]  295.27 244.35 180 top
R1B17  45.3K  [SMR0402IA]  282.7 243.33 90 top
R1B18  10mOHM  [SMR0603IC]  291.08 242.95 0 top
R1B19  24.3K  [SMR0402IA]  280.54 242.19 180 top
R1B20  10K  [SMR0402IA]  284.09 241.81 0 top
R1B21  0  [SMR0402IA]  280.54 240.41 0 top
R1B22  100K  [SMR0402IA]  294.38 240.16 0 top
R1B23  100K  [SMR0402IA]  295.27 239.01 180 top
R1B24  680  [SMR0402IA]  282.19 238.25 270 top
R1B25  680  [SMR0402IA]  283.21 238.25 270 top
R1B26  680  [SMR0402IA]  284.35 238.12 270 top
R1B27  0  [SMR0201IA]  295.09 237.92 180 top
R1B28  680  [SMR0402IA]  281.05 237.74 270 top
R1B29  2.2  [SMR0805IA]  287.27 237.23 90 top
R1B30  0  [SMR0201IA]  294.56 237.29 0 top
R1B31  10K  [SMR0402IA]  286 236.98 90 top
R1B32  0  [SMR0201IA]  295.09 236.14 180 top
R1B33  0  [SMR0201IA]  294.56 235.51 0 top
R1B34  10K  [SMR0402IA]  288.29 235.08 180 top
R1B35  0  [SMR0201IA]  295.09 234.36 180 top
R1B36  0  [SMR0402IA]  287.9 234.19 270 top
R1B37  0  [SMR0201IA]  294.56 233.73 0 top
R1B38  0  [SMR0201IA]  295.09 232.59 180 top
R1B39  0  [SMR0402IA]  288.16 232.41 180 top
R1B40  0  [SMR0402IA]  289.17 232.41 0 top
R1B41  0  [SMR0201IA]  294.56 231.95 0 top
R1B42  100K  [SMR0402IA]  295.27 230.88 180 top
R1B43  10K  [SMR0402IA]  288.16 230.38 180 top
R1B44  0  [SMR0402IA]  287.27 229.61 0 top
R1B45  10K  [SMR1005MD]  287.27 228.85 0 top
R1B46  680  [SMR0402IA]  286.25 228.09 180 top
R1B47  10K  [SMR1005MD]  287.27 228.09 0 top
R1B48  499K  [SMR0402IA]  291.08 240.41 90 top
R1B49  499K  [SMR0402IA]  291.08 239.65 270 top
R1C1  680  [SMR0402IA]  284.09 227.13 135 top
R1C2  0  [SMR0402IA]  286.13 226.31 0 top
R1C3  59K  [SMR0402IA]  282.69 225.52 0 top
R1C4  100  [SMR0402IA]  281.94 225.42 90 top
R1C5  0  [SMR0402IA]  284.48 225.42 0 top
R1C6  0  [SMR0402IA]  282.7 224.66 0 top
R1C7  21.5K  [SMR0402IA]  282.06 223.01 0 top
R1C8  2.49K  [SMR0603IA]  285.87 223.01 90 top
R1C9  100  [SMR0402IA]  280.92 222.76 180 top
R1C10  0  [SMR0402IA]  282.95 222.25 180 top
R1C11  2.49K  [SMR0603IA]  287.27 222.25 90 top
R1C12  0  [SMR0603IA]  296.92 222.25 180 top
R1C13  0  [SMR0402IA]  280.92 221.74 270 top
R1C14  0  [SMR0402IA]  282.32 221.49 270 top
R1C15  100K  [SMR0402IA]  298.7 221.36 90 top
R1C16  0  [SMR0603IA]  296.92 220.98 180 top
R1C17  2.49K  [SMR0603IA]  284.55 220.65 45 top
R1C20  2.49K  [SMR0603IA]  285.75 219.71 45 top
R1C21  1M  [SMR0402IA]  297.68 219.71 0 top
R1C22  0  [SMR0402IA]  289.17 218.82 270 top
R1C23  0  [SMR0402IA]  290.06 218.82 270 top
R1C24  0  [SMR0402IA]  291.84 218.82 270 top
R1C25  0  [SMR0402IA]  294.38 218.82 270 top
R1C26  1K  [SMR0402IA]  298.57 218.82 180 top
R1C27  0  [SMR0402IA]  288.29 217.93 90 top
R1C28  0  [SMR0402IA]  290.95 217.93 90 top
R1C29  0  [SMR0402IA]  292.73 217.93 90 top
R1C30  0  [SMR0402IA]  293.62 217.93 90 top
R1C31  100K  [SMR0402IA]  297.68 217.93 0 top
R1C32  0  [SMR0402IA]  296.92 216.79 0 top
R1C33  100K  [SMR0402IA]  299.59 216.79 180 top
R1C34  0  [SMR0402IA]  296.92 215.9 0 top
R1C35  0  [SMR0402IA]  296.92 214.88 0 top
R1C36  0  [SMR0402IA]  299.33 214.25 0 top
R1C37  0  [SMR0402IA]  301.11 214.25 180 top
R1C38  150  [SMR0402IA]  297.81 212.98 180 top
R1C39  0  [SMR0603IA]  300.86 212.98 180 top
R1C40  0  [SMR0402IA]  285.11 212.72 180 top
R1C41  0  [SMR0402IA]  299.33 211.96 0 top
R1C42  1K  [SMR0402IA]  301.75 211.07 90 top
R1C43  0  [SMR0402IA]  300.22 210.95 180 top
R1C44  1K  [SMR0402IA]  283.33 210.69 0 top
R1C45  0  [SMR0402IA]  285.11 210.69 180 top
R1C46  1K  [SMR0402IA]  299.33 209.93 0 top
R1C47  1K  [SMR0402IA]  301.11 209.93 180 top
R1C48  0  [SMR0603IA]  282.32 209.8 180 top
R1C50  10K  [SMR0402IA]  300.22 209.04 180 top
R1C51  10K  [SMR0402IA]  281.68 208.15 0 top
R1C54  10K  [SMR0402IA]  300.22 208.02 180 top
R1C55  10K  [SMR0402IA]  301.87 207.9 270 top
R1C56  10K  [SMR0402IA]  281.68 207.14 0 top
R1C58  10K  [SMR0402IA]  297.81 207.14 180 top
R1C60  10K  [SMR0402IA]  281.68 206.12 0 top
R1C62  10K  [SMR0402IA]  297.81 206.12 180 top
R1C66  10K  [SMR0402IA]  281.68 205.1 0 top
R1C70  10K  [SMR0402IA]  297.81 204.21 180 top
R1C72  10K  [SMR0402IA]  281.68 203.2 0 top
R1C74  0  [SMR0402IA]  297.81 203.2 180 top
R1C77  10K  [SMR0402IA]  281.68 202.18 0 top
R1C79  0  [SMR0402IA]  297.81 202.18 180 top
R1C80  10K  [SMR0402IA]  300.22 202.18 180 top
R1C85  10K  [SMR0402IA]  281.68 201.17 0 top
R1C88  10K  [SMR0402IA]  300.22 200.4 180 top
R1C92  10K  [SMR0402IA]  300.22 199.52 180 top
R1C93  10K  [SMR0402IA]  284.22 199.13 0 top
R1C94  1K  [SMR0402IA]  296.92 198.63 0 top
R1C95  10K  [SMR0402IA]  300.22 198.63 180 top
R1C96  10K  [SMR0402IA]  301.87 197.99 90 top
R1C97  0  [SMR0402IA]  297.81 197.74 180 top
R1C98  10K  [SMR0402IA]  300.22 197.74 180 top
R1C99  0  [SMR0402IA]  296.92 196.85 0 top
R1C101  0  [SMR0402IA]  297.81 195.96 180 top
R1C102  0  [SMR0402IA]  296.92 195.07 0 top
R1D1  0  [SMR0402IA]  297.81 194.31 180 top
R1D2  8.2K  [SMR0402IA]  286 73.66 270 top
R1D3  10K  [SMR0402IA]  297.81 193.55 180 top
R1D4  2.2  [SMR0603IA]  286 186.05 0 top
R1D5  1  [SMR0603IA]  287.4 183.64 180 top
R1D6  0  [SMR0603IA]  283.71 180.59 0 top
R1D7  2.2  [SMR0603IA]  286.02 172.59 0 top
R1D8  1  [SMR0603IA]  287.17 168.53 90 top
R1D9  0  [SMR0603IA]  283.99 167.26 0 top
R1D10  0  [SMR0402IA]  287.27 164.72 270 top
R1D11  0  [SMR0402IA]  288.41 164.72 270 top
R1D12  0  [SMR0402IA]  289.56 164.72 270 top
R1D13  0  [SMR0402IA]  290.7 164.72 270 top
R1D16  100K  [SMR0402IA]  294.13 162.69 180 top
R1E3  0  [SMR0402IA]  287.02 161.16 0 top
R1E4  100K  [SMR0402IA]  293.24 160.4 0 top
R1E5  0  [SMR0402IA]  287.02 160.02 0 top
R1E7  0  [SMR0402IA]  287.02 158.88 0 top
R1E8  5.23K  [SMR1005MD]  290.06 158.88 270 top
R1E9  0  [SMR0402IA]  281.17 158.49 270 top
R1E10  0  [SMR0402IA]  282.32 158.49 270 top
R1E11  0  [SMR0402IA]  283.46 158.49 270 top
R1E12  0  [SMR0402IA]  293.24 158.11 0 top
R1E13  0  [SMR0402IA]  290.95 157.99 90 top
R1E14  0  [SMR0402IA]  292.1 157.99 90 top
R1E15  100K  [SMR0402IA]  286.89 156.46 180 top
R1E16  100K  [SMR0402IA]  286 154.18 0 top
R1E17  6.2K  [SMR0402IA]  295.14 153.92 0 top
R1E18  15K  [SMR0402IA]  296.03 152.91 180 top
R1E19  806  [SMR0402IA]  282.19 152.65 270 top
R1E20  0  [SMR0402IA]  286 151.89 0 top
R1E21  0  [SMR0402IA]  282.95 151.76 90 top
R1E22  0  [SMR0402IA]  283.71 151.76 90 top
R1E23  0  [SMR0402IA]  284.48 151.76 90 top
R1E24  0  [SMR0402IA]  285.24 151.76 90 top
R1E25  3.3K  [SMR0402IA]  295.65 150.49 90 top
R1E26  0  [SMR0402IA]  280.54 148.84 270 top
R1E27  0  [SMR0402IA]  281.68 148.84 270 top
R1E28  0  [SMR0402IA]  282.82 148.84 270 top
R1E29  0  [SMR0402IA]  283.97 148.84 270 top
R1E30  0  [SMR0402IA]  285.11 148.84 270 top
R1E31  100K  [SMR0402IA]  287.4 146.81 180 top
R1E32  0.002  [SMR4_2512IG_RVP]  292.22 146.68 90 top
R1E33  0  [SMR0805IA]  295.65 145.79 270 top
R1E34  0  [SMR0402IA]  280.28 145.29 0 top
R1E35  100K  [SMR0402IA]  286.51 144.52 0 top
R1E36  0  [SMR0402IA]  280.28 144.14 0 top
R1E37  0  [SMR0402IA]  280.28 143 0 top
R1E38  2.05K  [SMR0402IA]  283.33 143 270 top
R1E40  0  [SMR0402IA]  286.51 142.24 0 top
R1E41  0  [SMR0402IA]  284.22 142.11 90 top
R1E42  0  [SMR0402IA]  285.36 142.11 90 top
R1E45  10K  [SMR0402IA]  296.03 139.44 180 top
R1E46  0  [SMR0402IA]  296.03 138.56 180 top
R1E47  10K  [SMR0402IA]  295.14 137.67 0 top
R1F3  2K  [SMR0402IA]  292.86 120.9 180 top
R1F4  0  [SMR0402IA]  290.95 119.89 90 top
R1F5  2K  [SMR0402IA]  291.97 119.89 0 top
R1F6  2  [SMR0402IA]  292.86 118.87 180 top
R1F7  24.9  [SMR0402IA]  290.95 117.85 90 top
R1F8  24.9  [SMR0402IA]  291.97 116.84 0 top
R1F9  0  [SMR0402IA]  284.73 116.58 270 top
R1F12  2  [SMR0402IA]  291.97 115.06 0 top
R1F16  0  [SMR0402IA]  290.95 114.04 270 top
R1F17  0  [SMR0402IA]  292.86 114.04 180 top
R1F21  2K  [SMR0402IA]  291.97 113.16 0 top
R1F22  2K  [SMR0402IA]  292.86 112.27 180 top
R1F25  24.9  [SMR0402IA]  292.86 109.6 180 top
R1F26  2  [SMR0402IA]  290.95 108.84 270 top
R1F31  0  [SMR0402IA]  290.95 107.06 270 top
R1F32  2K  [SMR0402IA]  291.97 106.81 0 top
R1F33  0  [SMR0402IA]  285.36 106.3 0 top
R1F34  2K  [SMR0402IA]  292.86 105.92 180 top
R1F39  2K  [SMR0402IA]  292.86 101.34 180 top
R1F42  0  [SMR0402IA]  290.95 100.33 90 top
R1F43  2K  [SMR0402IA]  291.97 100.33 0 top
R1F50  24.9  [SMR0402IA]  290.95 98.3 90 top
R1F51  0  [SMR0402IA]  291.97 98.3 90 top
R1F52  2  [SMR0402IA]  292.86 97.41 90 top
R1G5  0  [SMR0402IA]  296.29 76.01 90 top
R1G6  0  [SMR0402IA]  296.29 70.17 90 top
R1H2  0  [SMR0402IA]  296.29 64.32 90 top
R1P1  0  [SMR0402IA]  284.48 182.9 0 bottom
R1P2  0  [SMR0402IA]  284.09 180.72 90 bottom
R1P3  0  [SMR0402IA]  284.22 168.15 90 bottom
R1P4  0  [SMR0402IA]  283.33 168.15 90 bottom
R2A1  50mOHM  [SMR0603IC]  253.11 281.94 180 top
R2A2  47K  [SMR0402IA]  250.82 279.02 0 top
R2A3  2.2K  [SMR0402IA]  244.47 276.1 90 top
R2A4  560  [SMR0402IA]  245.36 276.1 90 top
R2A5  2.2K  [SMR0402IA]  247.52 276.1 90 top
R2A6  10mOHM  [SMR4_0805IB_RVP]  275.2 275.46 90 top
R2A7  1M  [SMR0402IA]  266.7 274.19 270 top
R2A8  10K  [SMR0402IA]  278.13 272.92 270 top
R2A9  20K  [SMR0402IA]  271.52 272.29 270 top
R2A10  1M  [SMR0402IA]  278.89 272.03 90 top
R2A11  0  [SMR0201IA]  260.04 271.58 90 top
R2A12  0  [SMR0201IA]  260.68 271.58 90 top
R2A13  0  [SMR0201IA]  262.2 271.58 90 top
R2A14  0  [SMR0201IA]  262.83 271.58 90 top
R2A15  0  [SMR0201IA]  263.72 271.58 90 top
R2A16  0  [SMR0201IA]  264.36 271.58 90 top
R2A17  0  [SMR0201IA]  265.88 271.58 90 top
R2A18  0  [SMR0201IA]  266.52 271.58 90 top
R2A19  100K  [SMR0402IA]  267.33 271.4 90 top
R2A20  100K  [SMR0402IA]  268.47 271.4 90 top
R2A21  10K  [SMR0402IA]  270.76 271.4 90 top
R2A22  2.2K  [SMR0402IA]  273.3 271.4 90 top
R2A23  2.2K  [SMR0402IA]  274.06 271.4 90 top
R2A24  0  [SMR0402IA]  252.73 271.27 90 top
R2A25  0  [SMR0402IA]  253.49 271.27 90 top
R2A26  0  [SMR0402IA]  254.76 271.27 90 top
R2A27  0  [SMR0402IA]  255.52 271.27 90 top
R2A28  0  [SMR0402IA]  256.41 271.27 90 top
R2A29  0  [SMR0402IA]  257.17 271.27 90 top
R2A30  0  [SMR0402IA]  258.44 271.27 90 top
R2A31  0  [SMR0402IA]  259.2 271.27 90 top
R2A32  100K  [SMR0402IA]  278.13 270.89 270 top
R2A33  100K  [SMR0402IA]  278.89 270.89 270 top
R2A34  0.01  [SMR4_0603ID_RVP]  249.8 270.64 180 top
R2A35  10K  [SMR0402IA]  247.14 270.25 90 top
R2A36  2.2K  [SMR0402IA]  272.16 269.87 180 top
R2A37  4.7K  [SMR0402IA]  251.58 268.98 180 top
R2A38  1K  [SMR0402IA]  248.28 268.86 0 top
R2A39  1K  [SMR0402IA]  248.28 267.84 0 top
R2A40  0  [SMR0402IA]  250.69 267.84 0 top
R2A41  4.7K  [SMR0402IA]  248.28 266.83 0 top
R2A42  0  [SMR0402IA]  250.69 266.83 0 top
R2A43  4.7K  [SMR0402IA]  261.11 266.19 0 top
R2A44  4.7K  [SMR0402IA]  248.28 265.81 0 top
R2A45  4.7K  [SMR0402IA]  262 265.43 180 top
R2A46  2.2K  [SMR0402IA]  272.16 265.43 180 top
R2A47  0.022  [SMR4_0603ID_RVP]  266.44 265.3 180 top
R2A48  0  [SMR0402IA]  278.89 265.17 270 top
R2A49  100K  [SMR0402IA]  279.9 265.17 270 top
R2A50  2.2K  [SMR0402IA]  248.28 264.79 0 top
R2A51  0  [SMR0402IA]  250.69 264.79 0 top
R2A52  10K  [SMR0402IA]  262 264.67 180 top
R2A53  10K  [SMR0402IA]  278 264.29 90 top
R2A54  2.2K  [SMR0402IA]  248.28 264.03 0 top
R2A55  0  [SMR0402IA]  250.69 264.03 0 top
R2A56  0  [SMR0402IA]  262 263.9 180 top
R2A57  200K  [SMR0402IA]  271.78 263.78 180 top
R2A58  0.022  [SMR4_0603ID_RVP]  266.44 263.65 180 top
R2A59  1K  [SMR0402IA]  270.89 262.76 0 top
R2A60  10K  [SMR0402IA]  246.63 262.51 270 top
R2A61  10K  [SMR0402IA]  250.69 262.25 0 top
R2A62  10K  [SMR0402IA]  247.65 261.87 90 top
R2A63  402K  [SMR0402IA]  270.89 261.75 0 top
R2A64  330K  [SMR0402IA]  273.3 261.75 0 top
R2A65  330K  [SMR0402IA]  276.09 261.75 180 top
R2A66  4.7K  [SMR0402IA]  245.61 261.62 90 top
R2A67  100K  [SMR0402IA]  249.17 261.62 90 top
R2A68  4.99K  [SMR0402IA]  250.69 261.36 0 top
R2A69  4.7K  [SMR0402IA]  260.09 261.36 270 top
R2A70  0  [SMR0402IA]  255.01 260.48 90 top
R2A71  0  [SMR0402IA]  275.2 265.43 0 top
R2B1  0  [SMR0402IA]  244.47 259.21 270 top
R2B2  30V  [SOD123IB]  261.49 259.21 90 top
R2B3  0.01  [SMR4_0603ID_RVP]  275.97 258.44 180 top
R2B4  100K  [SMR0402IA]  271.9 258.06 180 top
R2B5  1  [SMR0603IA]  256.54 248.16 180 top
R2B6  1  [SMR0603IA]  246.76 248.03 180 top
R2B7  1  [SMR0603IA]  270.38 248.03 180 top
R2B8  10K  [SMR0402IA]  258.82 247.9 270 top
R2B9  1uF  [SMC0402IA]  267.97 247.27 90 top
R2B10  2.2  [SMR0603IA]  252.6 246.89 90 top
R2B11  2.2  [SMR0603IA]  265.81 246.89 90 top
R2B12  0  [SMR0402IA]  269.87 246.12 180 top
R2B14  0  [SMR0402IA]  259.08 245.49 270 top
R2B16  0  [SMR0603IA]  248.15 244.85 90 top
R2B17  0  [SMR0603IA]  258.06 244.73 90 top
R2B18  0  [SMR0402IA]  270.76 244.73 90 top
R2B19  0  [SMR0603IA]  272.41 243.84 90 top
R2B20  100  [SMR0402IA]  278.76 242.19 270 top
R2B21  100  [SMR0402IA]  274.44 241.55 270 top
R2B22  110  [SMR0402IA]  275.46 241.55 270 top
R2B23  45.3  [SMR0402IA]  276.47 241.55 270 top
R2B24  0  [SMR0402IA]  277.49 240.66 90 top
R2B25  0  [SMR0402IA]  279.78 240.16 180 top
R2B26  10  [SMR0402IA]  274.44 239.77 270 top
R2B27  0  [SMR0402IA]  275.46 239.77 270 top
R2B28  49.9  [SMR0402IA]  276.22 239.77 270 top
R2B29  36.5K  [SMR0402IA]  279.27 239.39 0 top
R2B30  357  [SMR0402IA]  272.66 239.01 0 top
R2B31  2.2  [SMR1206A]  261.11 238.5 90 top
R2B32  0  [SMR0402IA]  278.25 238.25 90 top
R2B33  37.4K  [SMR0402IA]  273.55 238.12 180 top
R2B34  100  [SMR0402IA]  277.24 238.12 90 top
R2B35  0  [SMR0402IA]  272.66 237.23 0 top
R2B36  0  [SMR0402IA]  272.66 236.35 0 top
R2B37  23.7K  [SMR0402IA]  274.42 236.19 270 top
R2B38  3.16K  [SMR0402IA]  271.14 235.46 90 top
R2B39  0  [SMR0402IA]  273.55 235.46 180 top
R2B40  73.2K  [SMR0402IA]  272.66 234.44 0 top
R2B41  200  [SMR0402IA]  273.55 233.68 180 top
R2B42  806  [SMR0402IA]  274.44 233.68 90 top
R2B45  2.4K  [SMR0402IA]  272.54 232.92 0 top
R2B46  19.6K  [SMR0402IA]  275.46 232.92 180 top
R2B47  11.5  [SMR0402IA]  273.55 232.15 180 top
R2B48  23.7  [SMR0402IA]  274.57 232.15 0 top
R2B49  7.15K  [SMR0402IA]  272.66 231.39 0 top
R2B50  825  [SMR0402IA]  275.46 231.39 180 top
R2B53  11.5K  [SMR0402IA]  272.66 230.63 0 top
R2B54  8.66K  [SMR0402IA]  274.57 230.63 0 top
R2B55  3.9  [SMR1005MA]  275.97 229.49 180 top
R2B56  8.45K  [SMR0402IA]  275.08 228.73 0 top
R2B59  316  [SMR0402IA]  273.55 227.96 180 top
R2B60  21.5K  [SMR0402IA]  275.97 227.96 180 top
R2B61  73.2K  [SMR0402IA]  272.66 227.2 0 top
R2B62  1.27K  [SMR0402IA]  275.08 227.2 0 top
R2C1  12.4K  [SMR0402IA]  270.12 226.57 0 top
R2C2  51.1K  [SMR0402IA]  272.66 226.44 0 top
R2C3  0  [SMR0402IA]  275.08 226.44 0 top
R2C4  402  [SMR0402IA]  273.55 225.68 180 top
R2C5  27.4K  [SMR0402IA]  275.97 225.68 180 top
R2C6  0  [SMR0402IA]  280.16 224.92 90 top
R2C7  0  [SMR0402IA]  272.66 224.79 0 top
R2C8  23.7K  [SMR0402IA]  274.44 224.79 0 top
R2C9  8.45K  [SMR0402IA]  270.89 224.53 90 top
R2C10  16.9K  [SMR0402IA]  273.55 223.77 270 top
R2C11  732  [SMR0402IA]  276.73 223.77 270 top
R2C12  0  [SMR0402IA]  272.66 222.88 90 top
R2C13  40.2  [SMR0402IA]  274.44 222.88 90 top
R2C14  0  [SMR0402IA]  275.97 222.88 90 top
R2C15  0  [SMR0402IA]  277.49 222.88 90 top
R2C16  30.1  [SMR0402IA]  277.36 221.99 270 top
R2C17  10K  [SMR0402IA]  278.25 221.99 270 top
R2C18  3.48K  [SMR0402IA]  274.19 221.11 90 top
R2C19  3.48K  [SMR0402IA]  276.6 221.11 90 top
R2C20  2.2K  [SMR0402IA]  278.63 219.58 270 top
R2C21  2.2K  [SMR0402IA]  279.4 219.58 270 top
R2C22  6.8  [SMR0805IA]  273.68 218.06 90 top
R2C23  6.8  [SMR0805IA]  275.33 218.06 90 top
R2C24  0  [SMR0402IA]  278.63 216.41 90 top
R2C25  0  [SMR0402IA]  279.4 216.41 90 top
R2C26  100  [SMR0402IA]  262 210.44 180 top
R2C27  51  [SMR0402IA]  263.52 210.44 0 top
R2C28  51  [SMR0402IA]  262 209.04 180 top
R2C29  51  [SMR0402IA]  263.52 209.04 0 top
R2C30  100  [SMR0402IA]  262 207.77 180 top
R2C31  51  [SMR0402IA]  263.52 207.77 0 top
R2C32  .002  [SMR4_1206IB_RVP]  272.41 203.71 270 top
R2D1  10K  [SMR0402IA]  266.82 166.49 270 top
R2E2  0  [SMR0402IA]  280.03 158.49 270 top
R2E5  0  [SMR0402IA]  279.78 154.94 0 top
R2E6  0  [SMR0402IA]  279.78 153.8 0 top
R2E7  0  [SMR0402IA]  279.78 152.65 0 top
R2G1  2.2  [SMR1206A]  268.09 95.88 0 top
R2G2  .002  [SMR4_1206IB_RVP]  250.44 89.79 180 top
R2G5  0.01  [SMR0603IA]  262.76 87.25 180 top
R2G6  0  [SMR0603IA]  264.03 84.33 90 top
R2G7  0  [SMR0603IA]  268.47 83.82 90 top
R2G8  0.01  [SMR4_0603ID_RVP]  256.15 83.69 90 top
R2G11  0  [SMR0603IA]  266.31 82.42 0 top
R2G12  0.01  [SMR4_0603ID_RVP]  274.32 82.29 0 top
R2G13  51  [SMR0805IA]  251.71 81.79 90 top
R2G14  0  [SMR0402IA]  259.58 81.79 180 top
R2G15  75K  [SMR0402IA]  267.2 81.15 180 top
R2G16  0  [SMR0402IA]  249.3 79.75 90 top
R2G17  0  [SMR0402IA]  250.44 79.75 90 top
R2G18  0  [SMR0402IA]  267.2 79.37 180 top
R2G19  0  [SMR0402IA]  253.11 78.87 180 top
R2G20  0  [SMR0402IA]  259.84 78.87 0 top
R2G21  0  [SMR0402IA]  267.2 78.48 180 top
R2G22  0  [SMR0402IA]  259.08 78.23 180 top
R2G23  4.7K  [SMR0402IA]  248.03 77.72 270 top
R2G24  0  [SMR0402IA]  252.22 77.72 0 top
R2G25  6.04K  [SMR0402IA]  260.09 77.72 270 top
R2G26  0  [SMR0402IA]  261.87 77.72 270 top
R2G27  619K  [SMR0402IA]  266.31 77.6 0 top
R2G28  0  [SMR0402IA]  262.89 76.83 90 top
R2G29  0  [SMR0402IA]  263.77 76.83 90 top
R2G30  0  [SMR0402IA]  252.22 76.58 0 top
R2G31  0  [SMR0402IA]  258.19 76.45 0 top
R2G32  47K  [SMR0402IA]  253.11 75.44 180 top
R2G33  10K  [SMR0402IA]  261.87 75.31 270 top
R2G34  20K  [SMR0402IA]  250.95 75.18 270 top
R2G35  0  [SMR0402IA]  269.49 74.93 180 top
R2G36  0  [SMR0402IA]  260.98 74.42 90 top
R2G37  10K  [SMR0402IA]  262.89 74.42 90 top
R2G38  0  [SMR0402IA]  249.8 74.29 90 top
R2G39  0  [SMR0402IA]  253.11 74.29 180 top
R2G40  10K  [SMR0402IA]  269.49 74.17 180 top
R2L1  0  [SMR0402IA]  246.76 267.08 0 bottom
R2L2  10K  [SMR0402IA]  245.36 266.57 180 bottom
R2M1  6.8  [SMR0805IA]  257.68 248.28 0 bottom
R2M2  1K  [SMR0402IA]  256.54 248.28 180 bottom
R2M3  0  [SMR0402IA]  262.25 247.01 90 bottom
R2M4  0  [SMR0402IA]  246.25 246.76 180 bottom
R2M5  0  [SMR0402IA]  257.81 246.12 90 bottom
R2M6  0  [SMR0402IA]  255.9 245.74 90 bottom
R2M7  0  [SMR0402IA]  255.9 244.98 0 bottom
R2M8  0  [SMR0402IA]  246.25 244.47 90 bottom
R2M9  3.9  [SMR1005MA]  262.5 242.31 270 bottom
R2M10  0  [SMR0402IA]  258.92 240.94 180 bottom
R2M11  0  [SMR0402IA]  259.71 240.92 0 bottom
R2M12  2.32K  [SMR0603A]  262.5 239.52 180 bottom
R2M13  2.32K  [SMR0603A]  257.68 238.5 90 bottom
R2M14  2.32K  [SMR0603A]  262 236.85 90 bottom
R2M15  2.32K  [SMR0603A]  257.68 235.96 90 bottom
R2M16  2.2  [SMR1206A]  250.06 235.84 90 bottom
R2M17  2.2  [SMR1206A]  247.9 235.84 90 bottom
R2M18  0.002  [SMR4_2512IG_RVP]  258.57 231.14 270 bottom
R2M19  0.002  [SMR4_2512IG_RVP]  248.66 231.14 270 bottom
R2M20  0  [SMR0603IA]  257.93 250.32 180 bottom
R2N1  0.002  [SMR4_2512IG_RVP]  268.85 225.17 180 bottom
R2P3  0.002  [SMR4_2512IG_RVP]  269.74 186.43 270 bottom
R2P4  2.2  [SMR1206A]  278.89 182.75 90 bottom
R2P5  0.002  [SMR4_2512IG_RVP]  269.62 176.53 270 bottom
R2P6  2.2  [SMR1206A]  278.76 169.92 90 bottom
R3A1  10K  [SMR0402IA]  223.01 285.88 90 top
R3A2  15K  [SMR0402IA]  232.66 284.73 90 top
R3A3  10K  [SMR0402IA]  231.77 283.46 0 top
R3A4  3.3K  [SMR0402IA]  234.82 278.76 90 top
R3A5  100K  [SMR0402IA]  235.83 278.76 90 top
R3A6  0  [SMR0201IA]  237.94 276.4 90 top
R3A7  0  [SMR0201IA]  238.58 276.4 90 top
R3A8  0  [SMR0201IA]  239.47 276.4 90 top
R3A9  0  [SMR0201IA]  240.1 276.4 90 top
R3A10  0  [SMR0201IA]  240.99 276.4 90 top
R3A11  0  [SMR0201IA]  241.63 276.4 90 top
R3A12  0  [SMR0201IA]  242.51 276.4 90 top
R3A13  0  [SMR0201IA]  243.15 276.4 90 top
R3A14  5.11  [SMR0402IA]  237.1 273.68 90 top
R3A15  5.11  [SMR0402IA]  237.99 273.68 90 top
R3A16  5.11  [SMR0402IA]  239.01 273.68 90 top
R3A17  5.11  [SMR0402IA]  239.9 273.68 90 top
R3A18  5.11  [SMR0402IA]  240.91 273.68 90 top
R3A19  5.11  [SMR0402IA]  241.8 273.68 90 top
R3A20  5.11  [SMR0402IA]  242.82 273.68 90 top
R3A21  5.11  [SMR0402IA]  243.71 273.68 90 top
R3A22  10K  [SMR0402IA]  232.15 272.92 270 top
R3A23  3.3K  [SMR0402IA]  234.56 271.65 0 top
R3A24  6.2K  [SMR0402IA]  234.56 269.87 0 top
R3A25  10K  [SMR0402IA]  235.45 268.98 180 top
R3A26  0  [SMR0603IA]  208.28 267.71 0 top
R3A27  0  [SMR0603IA]  208.28 266.57 0 top
R3A28  0  [SMR0402IA]  235.45 265.68 180 top
R3A29  0  [SMR0603IA]  208.28 265.43 0 top
R3A30  0  [SMR0201IA]  216.48 265 270 top
R3A31  220K  [SMR1005MD]  217.39 265.17 270 top
R3A32  220K  [SMR1005MD]  218.59 265.17 270 top
R3A33  0  [SMR0201IA]  220.29 265 270 top
R3A34  220K  [SMR1005MD]  221.2 265.17 270 top
R3A35  220K  [SMR1005MD]  222.4 265.17 270 top
R3A36  0  [SMR0603IA]  223.64 265.05 90 top
R3A37  0  [SMR0603IA]  224.79 265.05 90 top
R3A38  0  [SMR0603IA]  226.31 265.05 90 top
R3A39  0  [SMR0603IA]  227.45 265.05 90 top
R3A40  4.99K  [SMR0402IA]  235.45 264.79 180 top
R3A41  0  [SMR0603IA]  208.28 264.29 0 top
R3A42  0  [SMR0201IA]  215.84 264.46 90 top
R3A43  0  [SMR0201IA]  219.65 264.46 90 top
R3A44  249  [SMR0402IA]  234.56 263.9 0 top
R3A45  100K  [SMR0402IA]  235.58 263.02 0 top
R3A46  100K  [SMR0402IA]  236.47 261.87 180 top
R3B1  0  [SMR0402IA]  237.23 259.21 270 top
R3B2  0  [SMR0402IA]  238.37 259.21 270 top
R3B3  0  [SMR0402IA]  239.26 259.21 270 top
R3B4  0  [SMR0402IA]  240.41 259.21 270 top
R3B5  0  [SMR0402IA]  241.3 259.21 270 top
R3B6  0  [SMR0402IA]  242.44 259.21 270 top
R3B7  0  [SMR0402IA]  243.33 259.21 270 top
R3B8  68.1K  [SMR0402IA]  214.09 256.79 180 top
R3B9  1K  [SMR0402IA]  210.82 256.67 180 top
R3B10  1K  [SMR0402IA]  226.82 256.67 180 top
R3B11  10K  [SMR0402IA]  229.23 256.28 270 top
R3B12  1K  [SMR0402IA]  213.2 255.9 0 top
R3B13  68.1K  [SMR0402IA]  209.93 255.78 0 top
R3B14  1K  [SMR0402IA]  225.93 255.78 0 top
R3B15  15K  [SMR0402IA]  230.25 255.4 90 top
R3B16  0  [SMR0402IA]  231.14 255.4 90 top
R3B17  1K  [SMR0402IA]  210.82 255.01 180 top
R3B18  1K  [SMR0402IA]  213.2 255.01 0 top
R3B19  1K  [SMR0402IA]  226.82 255.01 180 top
R3B20  1K  [SMR0402IA]  210.82 254.25 180 top
R3B21  1K  [SMR0402IA]  226.82 254.25 180 top
R3B22  68.1K  [SMR0402IA]  214.09 254.13 180 top
R3B23  68.1K  [SMR0402IA]  209.93 253.49 0 top
R3B24  68.1K  [SMR0402IA]  225.93 253.49 0 top
R3B25  1K  [SMR0402IA]  213.23 253.24 0 top
R3B26  1  [SMR0603IA]  209.93 248.16 180 top
R3B27  1  [SMR0603IA]  233.29 248.16 180 top
R3B28  1  [SMR0603IA]  223.39 248.03 180 top
R3B29  10K  [SMR0402IA]  212.21 247.9 270 top
R3B30  10K  [SMR0402IA]  235.58 247.9 270 top
R3B31  10K  [SMR0402IA]  236.34 247.9 270 top
R3B32  10K  [SMR0402IA]  237.99 247.9 270 top
R3B33  2.2  [SMR0603IA]  219.32 246.89 90 top
R3B34  2.2  [SMR0603IA]  229.36 246.89 90 top
R3B35  2.2  [SMR0603IA]  242.69 246.89 90 top
R3B36  1uF  [SMC0402IA]  231.64 246.63 0 top
R3B37  0  [SMR0402IA]  212.47 245.49 270 top
R3B38  0  [SMR0402IA]  235.83 245.49 270 top
R3B39  0  [SMR0402IA]  236.72 245.49 270 top
R3B40  0  [SMR0603IA]  224.79 244.85 90 top
R3B41  0  [SMR0603IA]  211.45 244.73 90 top
R3B42  0  [SMR0603IA]  234.82 244.73 90 top
R3B43  0  [SMR0402IA]  237.49 244.6 270 top
R3F1  240  [SMR0402IA]  213.61 115.47 90 top
R3F2  240  [SMR0402IA]  211.32 115.44 90 top
R3F3  240  [SMR0402IA]  212.34 106.31 0 top
R3G1  240  [SMR0402IA]  212.85 96.65 0 top
R3G2  0  [SMR0402IA]  228.21 94.74 180 top
R3G3  0  [SMR0402IA]  230.88 94.74 180 top
R3G4  0  [SMR0402IA]  227.33 93.72 0 top
R3G5  0  [SMR0402IA]  229.99 93.72 0 top
R3G32  200K  [SMR0402IA]  216.4 78.74 90 top
R3G33  200K  [SMR0402IA]  217.55 78.74 90 top
R3G34  10mOHM  [SMR4_0805IB_RVP]  213.1 73.43 90 top
R3G35  1K  [SMR1206IB]  218.31 73.15 90 top
R3G36  1K  [SMR1206IB]  220.59 73.15 90 top
R3G37  1K  [SMR1206IB]  222.88 73.15 90 top
R3G38  1K  [SMR1206IB]  225.17 73.15 90 top
R3G39  1K  [SMR1206IB]  227.45 73.15 90 top
R3G40  1K  [SMR1206IB]  229.74 73.15 90 top
R3G41  0.002  [SMR4_2512IG_RVP]  232.66 68.71 0 top
