# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPIO_PCIE_SLOT3_WAKE_N: length 159
  TOP w0.089: U6E1.BF24 92,147.18 88.19,147.18 88.07,147.31 85.25,147.31 84.73,147.83 R7E20.1
  TOP w0.1: R7E20.1 83.56,147.32 82.16,147.32 R7E19.2 81.21,148.28 79.92,148.28 77.87,146.23 76.22,146.23 75.84,146.62 70.53,146.62 69.88,145.97 64.56,145.97 62.35,143.76 61.89,143.76 v1(60.62,142.49) ; v1(46.48,237.74) R8B21.2 R8B20.1
  LAY6 w0.125: v1(60.62,142.49) 58.07,145.04 58.07,159.65 59.2,160.78 59.2,162.59 58.68,163.11 58.68,166.69 58.42,166.95 58.42,167.38 56.26,169.54 50.81,169.54 50.41,169.94 50.41,183.69 48.94,185.17 47.77,185.17 46.99,185.95 46.99,187.12 46.02,188.09 45.46,188.09 44.83,188.72 44.83,198.12 44.06,198.88 44.06,201.47 43.81,201.72 43.81,204.57 44.18,204.94 44.18,209.08 42.67,210.59 42.67,212.47 41.65,213.49 39.37,213.49 38.35,214.5 37.46,214.5 36.45,215.52 36.45,235.56 37.36,236.47 37.86,236.47 39.13,237.74 42.77,237.74 43.66,236.85 45.59,236.85 v1(46.48,237.74)
GPIO_PCIESLOT2_RST_N: length 86.4
  TOP w0.089: U6E1.AP2 97.72,157.92 97.76,157.96 97.76,159.13 97.71,159.18 97.71,159.18 97.71,160.93 97.71,161.21 94.87,164.06 94.87,164.34 v1(93.34,165.86)
  TOP w0.1: R7B68.1 v1(90.7,234.44)
  BOTTOM w0.1: v1(90.7,234.44) 92.17,232.97 92.17,225.91 88.54,222.27 88.54,216.36 87.13,214.95 87.13,198.64 85.21,196.72 85.21,196.29 85.85,195.65 85.85,193.24 86.65,192.44 86.65,179.13 87.79,178 87.79,174.68 91.69,170.78 91.69,167.51 v1(93.34,165.86)
GPIO_PCIESLOT2_RST_R_N: length 9.8
  TOP w0.1: R7B61.1 87.37,236.6 87.88,236.09 87.88,234.69 R7B67.2 R7B68.2 88.77,234.85 88.87,234.95 89.78,234.95 90.29,235.46 90.29,236.09 89.72,236.66 U7B3.2
GPIO_PCIESLOT3_RST_N: length 22.6
  TOP w0.089: v1(93.72,166.62) 93.98,166.37 93.98,165.61 95.25,164.34 95.25,163.95 97.9,161.29 97.9,161.01 97.9,159.26 97.95,159.21 97.95,157.94 97.95,157.94 97.95,157.64 97.84,157.54 97.84,157.12 U6E1.AN4
  BOTTOM w0.1: R7P2.1 88.39,174.76 92.2,170.95 92.2,168.15 v1(93.72,166.62)
GPIO_PCIESLOT3_RST_R_N: length 196.5
  TOP w0.1: R8C51.1 v1(28.82,203.07) 28.82,202.94 28.32,202.44 27.55,202.44 26.67,203.33 25.9,203.33 25.46,203.77 25.46,204.79 25.27,204.98 24.25,204.98 R9C18.2
  LAY5 w0.125: v1(93.09,240.16) 87.88,240.16 87.54,240.5 82.96,240.5 82.65,240.82 79.9,240.82 77.51,243.21 73.9,243.21 71.5,245.62 71.12,245.62 67.86,248.87 53.69,248.87 53.34,248.52 47.48,248.52 46.85,247.9 34.55,247.9 32.13,250.32 v1(30.6,250.32)
  LAY6 w0.125: v1(28.82,203.07) 28.29,203.6 28.29,213 28.19,213.1 28.19,214.84 27.19,215.84 27.19,222.17 26.59,222.77 26.59,227.21 24.24,229.56 24.24,234.12 25.12,235 25.12,237.72 25.68,238.28 25.68,239.74 28.72,242.79 28.72,245.13 29.73,246.14 29.73,249 30.6,249.87 v1(30.6,250.32)
  BOTTOM w0.1: R7P2.2 88.39,178.07 87.13,179.33 87.13,191.47 88.39,192.72 88.39,196.73 87.5,197.62 87.5,213.58 89.55,215.63 89.55,220.38 92.56,223.39 92.56,229.21 93.72,230.38 93.72,239.52 v1(93.09,240.16)
GPIO_PEG_RST_N: length 19
  TOP w0.089: 93.58,130.16 93.58,130.95 96.55,133.92 U6E1.AT49
  TOP w0.1: 93.58,130.16 93.58,120.88 R7F25.1
GPIO_SSD2_RST_N: length 152.5
  TOP w0.1: R5C11.1 169.92,234.82 169.54,234.44 167.76,234.44 167.44,234.76 U5C1.2 167.44,235.78 167.13,236.09 166.24,236.09 165.98,235.84 165.98,235.33 R5C7.2 165.64,234.66 165.64,232.77 166.78,231.63 166.78,226.84 166.35,226.41 161.32,226.41 v1(161.16,226.57)
  LAY5 w0.125: v1(99.56,216.38) 101.88,216.38 103.43,214.83 115.73,214.83 124.67,223.77 134.62,223.77 137.41,220.98 138.43,220.98 138.93,220.47 139.82,220.47 140.58,219.71 141.85,219.71 142.49,219.07 142.49,218.69 143.38,217.8 144.14,217.8 145.28,216.66 147.7,216.66 149.47,214.88 152.14,214.88 155.06,217.8 155.06,218.31 156.97,220.22 v1(160.62,220.22)
  LAY6 w0.125: v1(160.62,220.22) 160.78,220.22 160.98,220.42 160.98,226.39 v1(161.16,226.57)
  BOTTOM w0.1: 96.9,167.51 96.9,170.85 95.69,172.06 95.69,183.47 96.45,184.24 96.45,185.77 99.12,188.43 99.12,189.83 97.05,191.9 97.05,203.31 97.59,203.85 97.59,210.85 99.31,212.56 99.31,216.12 v1(99.56,216.38)
GPIO_SSD2_RST_R_N: length 12.5
  TOP w0.089: U6E1.AM7 v1(98.25,155.32)
  BOTTOM w0.089: v1(98.25,155.32) 98.25,155.76 98.32,155.83 98.32,156.21 98.19,156.34 98.19,157.83 97.62,158.41 97.62,161.96
  BOTTOM w0.1: 97.62,161.96 97.62,165.9 R7P7.1
GPIO_SSD_RST_N: length 143.9
  TOP w0.089: 103.54,129.2 103.25,129.49 103.25,130.6 103.71,131.06 103.71,135.18 103.84,135.31 U6E1.AB48
  TOP w0.1: v1(38.6,73.02) 38.35,73.28 38.35,78.23 38.48,78.36 38.48,78.89 38.71,79.12 38.71,80.79 R8G43.1 ; 103.54,129.2 103.55,129.18 103.55,128.22 104.04,127.73 104.04,124.66 104.5,124.2 104.5,120.88 105.37,120.01 v1(106.04,120.01)
  BOTTOM w0.1: v1(38.6,73.02) 38.77,73.19 53.5,73.19 55.11,74.8 55.11,75.51 56.56,76.96 59.56,76.96 61.34,75.18 64.89,75.18 65.98,76.27 69.52,76.27 70.48,75.31 74.77,75.31 75.79,76.33 77.08,76.33 78.1,75.31 79.15,75.31 81.94,72.52 87.21,72.52 90.42,75.73 90.42,77.23 97.64,84.45 98.13,84.45 100.58,86.91 100.58,87.66 105.41,92.49 106.44,92.49 112.52,98.56 112.52,102.74 113.15,103.38 113.15,104.14 113.84,104.82 113.84,113.61 107.44,120.01 v1(106.04,120.01)
GPIO_SSD_RST_R_N: length 8.6
  TOP w0.1: R8G33.1 34.16,83.06 34.16,81.79 34.86,81.09 U8G1.2 36.51,81.09 36.83,81.41 R8G43.2 R8G45.2
GPIO_WLAN_RST_N: length 23.5
  TOP w0.089: U6E1.AN40 v1(97.44,139.51)
  BOTTOM w0.089: 97.05,135.25 97.05,135.61 96.7,135.96 96.7,136.73 97.06,137.09 97.06,137.74 97.32,138 97.32,138.01 97.32,138.37 97.32,138.37 97.55,138.6 97.55,138.95 97.44,139.07 v1(97.44,139.51)
  BOTTOM w0.1: R7T8.1 95.72,119.73 95.72,132.81 97.05,134.14 97.05,135.25
GPIO_WLAN_RST_R_N: length 183.9
  TOP w0.38: R8E58.1 27.68,133.09 27.68,129.35 27.49,129.16 v1(27.49,128.14)
  LAY5 w0.125: v1(27.49,128.14) 27.96,127.67 27.96,125.4 29.21,124.15 29.21,123.44 28.83,123.06 28.44,123.06 27.3,121.92 27.3,116.59 29.21,114.68 29.21,111.88 29.46,111.63 29.46,109.77 30.18,109.05 30.18,99.44 29.72,98.99 29.72,94.93 28.85,94.06 28.85,91.47 27.58,90.2 27.58,89.02 26.91,88.35 26.91,82.68 27.33,82.26 27.33,81.03 28.34,80.02 28.34,75.75 27.97,75.38 27.97,73.51 25.81,71.35 25.81,66.5 28.61,63.69 33.46,63.69 33.89,63.26 36.4,63.26 37.46,64.31 37.46,65.06 39.49,67.09 39.49,69.43 41.52,71.46 41.52,72.33 44.51,75.31 45.08,75.31 45.46,74.93 50.77,74.93 51.78,75.93 52.69,75.93 54.38,77.62 55.44,77.62 55.99,78.16 58.79,78.16 59.06,77.89 64.67,77.89 65.4,78.61 66.04,78.61 66.76,77.89 70.95,77.89 72.66,79.59 73.49,79.59 75.81,81.91 79.62,81.91 81.42,83.71 82.35,83.71 82.85,84.21 85.14,84.21 91.85,90.92 91.85,92.84 91.35,93.34 91.35,101.77 91.82,102.23 91.82,103 v1(92.32,103.5)
  BOTTOM w0.1: R7T8.2 94.23,116.46 92.48,114.71 92.48,111.12 91.18,109.82 91.18,107.82 91.58,107.43 91.58,104.58 92.32,103.83 v1(92.32,103.5)
GPIO_WLAN_WAKE_N: length 164.5
  TOP w0.089: U6E1.AE39 v1(101.52,139.6)
  TOP w0.1: R7B28.1 72.64,247.14 v1(72.64,243.33)
  LAY5 w0.125: v1(72.64,243.33) 73.28,242.69 77.5,242.69 79.75,240.44 82.49,240.44 82.81,240.12 86.9,240.12 87.5,239.52 v1(88.13,239.52) ; v1(101.52,139.6) 100.71,140.41 100.71,146.81 100.96,147.06 100.96,148.08 101.21,148.33 101.98,148.33 102.48,148.84 102.48,149.6 103.12,150.24 103.12,157.86 98.78,162.2 98.78,178.6 97.76,179.62 97.76,185.96 95.37,188.34 95.37,198.16 91.68,201.85 91.68,202.24 90.8,203.13 v1(90.8,203.2)
  LAY6 w0.125: v1(90.8,203.2) 88.07,205.93 88.07,223.26 89.02,224.22 89.02,225.93 87.88,227.08 87.88,234.69 88.66,235.48 88.66,238.99 v1(88.13,239.52)
  BOTTOM w0.089: 102.61,134.75 102.61,138.51 v1(101.52,139.6)
  BOTTOM w0.1: R6T13.1 106.93,110.36 106.93,116.81 105.82,117.92 104.43,117.92 102.61,119.73 102.61,134.75
GPIO_YLW_BLNK_BRD: length 21.8
  TOP w0.1: 25.01,43.78 23.84,43.78 23.49,43.43 19.3,43.43 16.82,45.91 16.82,47.18 16.12,47.88 14.85,47.88 10.47,52.26 CR9H1.3
GPIO_YLW_BLNK_HDR: length 15.3
  TOP w0.1: R8H72.1 R9H20.1 24.38,36.07 v1(24,36.45) ; Q8H1.3 v1(25.01,47.12)
  LAY6 w0.125: v1(25.01,47.12) 25.01,44.95 23.23,43.16 23.23,36.96 23.74,36.45 v1(24,36.45)
GPIO_YLW_BLNK_HDR_R: length 70.6
  TOP w0.1: J8J2.1 27.94,32.64 C8H23.1 26.41,34.16 R8H72.2 25.52,32.26 26.54,31.24 26.54,30.22 v1(27.94,28.83) ; CP9H1.1 10.41,64.51 9.39,63.5 9.39,62.1 8.12,60.83 6.35,60.83 J9H1.4
  BOTTOM w0.1: J9H1.4 6.19,58.45 6.19,53.82 12.57,47.44 12.57,29.08 14.85,26.8 18.79,26.8 19.93,27.94 27.05,27.94 v1(27.94,28.83)
GPP_A_8_CLKRUN_N: length 31.8
  TOP w0.089: U6E1.AV32 v1(95.96,142.88)
  BOTTOM w0.089: v1(95.96,142.88) 95.66,143.19 94.98,143.19 94.86,143.07 94.3,143.07 94.08,142.84 93.52,142.84 93.31,142.63 92.22,142.63
  BOTTOM w0.1: 92.22,142.63 90.81,142.63 89.73,141.55 86.18,141.55 85.85,141.22 85.12,141.22 82.19,138.29 81.71,138.29 80.81,137.39 79.5,137.39 79.14,137.03 74.93,137.03 74.54,136.65 72.39,136.65 R7R53.2 71.08,136.36 69.81,136.36 R7R56.1
GPP_A_8_CLKRUN_R_N: length 320
  TOP w0.1: J6J2.171 v1(138.77,18.24) ; v1(17.54,90.68) 16.63,91.58 16.63,92.45 16.86,92.69 U8F6.63 ; J7J1.18 v1(98.67,35.53)
  LAY5 w0.125: v1(17.54,90.68) 17.01,91.2 17.01,92.84 17.54,93.36 17.54,102.05 17.06,102.53 17.06,109.62 16.22,110.46 16.22,118.2 13.54,120.89 13.54,130.94 14.22,131.62 14.22,134.36 v1(13.58,135) ; v1(131.82,37.08) 131.82,37.34 130.5,38.66 126.8,38.66 126.35,38.21 126.35,35.73 125.29,34.67 123.31,34.67 121.92,36.07 103.21,36.07 102.89,35.74 102.16,35.74 101.47,35.05 99.16,35.05 v1(98.67,35.53) 97.74,34.6 61.69,34.6 61.25,34.16 57.02,34.16 56.64,34.54 51.96,34.54 51.24,33.82 48.06,33.82 47.11,34.76 47.11,35.61 46.41,36.31 39.09,36.31 38.36,35.58 29.27,35.58 28.91,35.95 28.44,35.95 27.73,36.66 26.13,36.66 25.42,35.95 19.67,35.95 v1(19.17,36.45)
  LAY6 w0.125: v1(17.54,90.68) 17.6,90.62 17.6,86.28 18.37,85.51 18.37,81.7 17.66,80.98 17.66,66.17 18.99,64.84 18.99,49.99 16.38,47.38 16.38,37.21 17.27,36.32 19.05,36.32 v1(19.17,36.45)
  LAY8 w0.1: v1(138.77,18.24) 134.74,22.27 134.74,33.2 131.82,36.12 v1(131.82,37.08)
  BOTTOM w0.1: v1(13.58,135) 14,135 16.04,137.03 16.85,137.03 18.01,135.87 19.56,135.87 22.11,133.32 22.11,133.1 24.26,130.96 28.04,130.96 28.49,130.5 28.49,130.12 29.97,128.65 36.11,128.65 38.7,126.06 47.42,126.06 48.26,125.22 49.64,125.22 53.2,128.78 56.46,128.78 60.26,132.58 62.43,132.58 64.05,134.2 66.51,134.2 67.43,135.13 R7R56.2
GPP_B_14_SPKR: length 164
  TOP w0.089: U6E1.AW29 v1(95.23,143.94)
  TOP w0.1: v1(18.92,72.26) R9G32.1 R9G31.1
  LAY6 w0.125: v1(18.92,72.26) 18.92,77.42 19.82,78.32 19.82,82.16 19.38,82.6 19.38,97.53 20.96,99.11 20.96,101.22 20.7,101.47 20.06,101.47 19.81,101.73 19.81,112.9 20.44,113.54 20.44,121.07 21.34,121.97 21.34,133.47 20.32,134.49 v1(20.32,140.61)
  BOTTOM w0.1: v1(20.32,140.61) 20.32,139.32 21.08,138.56 22.85,138.56 23.57,137.84 23.57,133.4 24.95,132.01 29.44,132.01 30.13,131.32 37.6,131.32 39.18,132.91 41.8,132.91 42.34,132.37 43.37,132.37 44.17,133.16 54.28,133.16 58.16,137.04 63,137.04 63.5,137.54 64,137.54 64.89,136.65 66.29,136.65 66.92,137.29 R7R52.2 R7R51.1 66.99,138.24 70,138.24 71.26,139.5 72.85,139.5 73.34,139 74.7,139 75.12,138.58 77.87,138.58 78.65,139.36 81.73,139.36 84.9,142.53 85.25,142.53 85.72,143 89.02,143 89.53,143.51 91.92,143.51 92.71,144.3 94.87,144.3 v1(95.23,143.94)
GPP_E_0_SATAPCIE_0_SATAGP_0: length 96.5
  TOP w0.089: v1(99.89,138.77) U6E1.AH41
  TOP w0.1: v1(105.53,54.1) 106.04,53.59 106.68,53.59 106.93,53.34 R6H8.1 R6H9.1
  LAY6 w0.125: v1(105.53,54.1) 105.53,60.58 101.43,64.68 101.43,69.18 102.13,69.87 102.13,74.14 101.45,74.82 101.45,83.86 102.26,84.67 102.26,88.22 103.77,89.72 103.77,93.84 102.74,94.87 102.1,94.87 100.84,96.13 100.84,99.57 v1(102.1,100.84)
  BOTTOM w0.089: 100.38,135.25 100.38,135.5 100.14,135.73 100.14,138.52 v1(99.89,138.77)
  BOTTOM w0.1: v1(102.1,100.84) 101.11,101.83 101.11,109.79 102.03,110.7 102.03,115.53 100.93,116.62 100.93,118.13 99.48,119.59 99.48,128.19 100.38,129.08 100.38,135.25
GPP_E_1_SATAPCIE_1_SATAGP_1: length 141.3
  TOP w0.089: U6E1.AJ43 v1(99.7,138.03)
  TOP w0.1: R5H6.1 v1(134.62,40.64) ; v1(105.28,40.89) 105.41,40.77 R6H24.1
  LAY5 w0.125: v1(134.62,40.64) 134.24,41.02 126.76,41.02 126.5,40.75 124.71,40.75 124.2,40.24 119.25,40.24 118.46,41.03 105.41,41.03 v1(105.28,40.89)
  LAY6 w0.125: v1(100.58,102.49) 100.07,101.98 100.07,101.22 100.34,100.95 100.34,95.92 101.89,94.36 102.53,94.36 103.26,93.63 103.26,89.93 101.76,88.43 101.76,84.88 100.95,84.07 100.95,74.61 101.62,73.93 101.62,70.08 100.93,69.39 100.93,63.66 104.77,59.82 104.77,54.86 102.99,53.08 102.99,43.18 v1(105.28,40.89)
  BOTTOM w0.089: v1(99.7,138.03) 99.95,137.78 99.95,133.99 99.25,133.29
  BOTTOM w0.1: v1(100.58,102.49) 100.88,102.79 100.88,109.88 101.8,110.8 101.8,115.43 100.71,116.53 100.71,118.03 99.25,119.48 99.25,133.29
GPP_E_2_SATAPCIE_2_SATAGP_2: length 109.9
  TOP w0.089: U6E1.AK47 99.76,135.86 99.68,135.78 99.68,135.44 99.68,135.43 99.68,135.42 99.77,135.34 99.77,133.49 99.77,132.54 98.68,131.45 98.68,130.53 98.27,130.12 98.27,128.72
  TOP w0.1: R6H25.1 v1(109.98,40) R6H34.1 ; v1(96.77,99.06) 97.53,99.82 97.53,103.6 96.77,104.36 96.77,105.66 97.53,106.42 97.53,107.82 97.12,108.24 97.12,110.31 97.53,110.72 97.53,113.37 98.37,114.21 98.37,115.48 98.09,115.76 98.09,118.51 97.36,119.25 97.36,127.81 98.27,128.72
  LAY5 w0.125: v1(109.98,40) 104.14,40 v1(104.01,39.88)
  LAY6 w0.125: v1(104.01,39.88) 104.01,40.89 101.47,43.43 101.47,60.63 98.93,63.16 98.93,94 97.53,95.4 97.53,98.3 v1(96.77,99.06)
GPP_E_3_CPU_GP_0: length 119.2
  TOP w0.089: U6E1.AL47 99.25,135.89 99.49,135.65 99.49,135.36 99.49,135.35 99.49,135.34 99.58,135.26 99.58,133.11 99.58,132.62 98.48,131.53 98.48,130.61 98.05,130.17 98.05,128.78
  TOP w0.1: v1(99.18,39.88) 100.1,40.79 104.72,40.79 105.08,40.44 108.02,40.44 110.54,37.92 111.07,37.92 111.63,38.48 111.63,40.26 R6H26.1 ; v1(95.5,98.42) 96.31,99.24 96.31,106.86 97.02,107.57 97.02,107.95 96.89,108.08 96.89,110.4 97.28,110.79 97.28,113.43 98.15,114.3 98.15,115.39 97.87,115.67 97.87,118.42 97.13,119.15 97.13,127.87 98.05,128.78
  LAY6 w0.125: v1(99.18,39.88) 99.18,41.4 97.46,43.13 97.46,46.79 99.31,48.64 99.31,60.65 97.42,62.54 97.42,87.69 96.52,88.59 96.52,94.27 94.87,95.92 94.87,97.79 v1(95.5,98.42)
GPP_E_4_SATA_DEVSLP_0: length 118.7
  TOP w0.089: U6E1.AL48 99.25,135.31 99.38,135.18 99.38,132.7 98.29,131.61 98.29,130.69 97.82,130.22 97.82,129.76
  TOP w0.1: R6H27.1 v1(112.26,40) R6H35.1 112.26,38.35 111.56,37.65 110.48,37.65 107.93,40.21 104.92,40.21 104.57,40.56 100.89,40.56 v1(100.2,39.88) ; 97.82,129.76 97.82,128.85 96.9,127.92 96.9,119.06 97.64,118.32 97.64,115.57 97.92,115.29 97.92,114.4 97.05,113.53 97.05,110.88 96.66,110.49 96.66,107.97 96.59,107.9 96.59,107.52 96.09,107.01 96.09,100.41 v1(95.63,99.95)
  LAY6 w0.125: v1(100.2,39.88) 100.2,40.76 97.71,43.25 97.71,46.68 99.56,48.54 99.56,60.75 97.67,62.64 97.67,93.48 95.12,96.03 95.12,97.53 95.5,97.92 95.75,97.92 96.01,98.17 96.01,99.56 v1(95.63,99.95)
GPP_E_5_SATA_DEVSLP_1: length 122.8
  TOP w0.089: U6E1.AH35 v1(100.08,141.9)
  TOP w0.1: v1(102.99,39.88) 103.45,40.34 104.47,40.34 104.83,39.98 107.83,39.98 110.45,37.36 112.67,37.36 113.66,38.35 113.66,40.51 R6H28.1
  LAY6 w0.125: v1(102.99,39.88) 100.96,41.91 100.96,60.42 98.43,62.96 98.43,93.79 96.77,95.45 v1(96.77,97.28)
  BOTTOM w0.089: 98.57,135.74 98.57,136.67 98.71,136.81 98.71,137.36 99.09,137.74 99.09,138.39 99.26,138.56 99.26,139.07 99.37,139.18 99.37,141.19 v1(100.08,141.9)
  BOTTOM w0.1: 98.57,135.74 98.57,119.65 R7T12.1 97.91,117.47 97.91,114.61 97.61,114.31 97.61,108.13 98.35,107.39 98.35,103.95 97.91,103.51 97.91,98.42 v1(96.77,97.28)
GPP_E_6_SATA_DEVSLP_2: length 112.8
  TOP w0.089: U6E1.AH40 v1(100.08,139.51)
  TOP w0.1: R6H29.1 v1(114.55,40) R6H36.1
  LAY6 w0.125: v1(114.55,40) 114.94,40 118.24,43.31 118.24,49.31 118.49,49.56 118.49,57.14 114.04,61.59 114.04,69.44 106.5,76.99 106.5,78.41 105.52,79.39 105.52,95.44 103.4,97.55 103.4,100.3 v1(102.1,101.6)
  BOTTOM w0.089: v1(100.08,139.51) 100.33,139.26 100.33,136.02 100.61,135.74 100.61,135.51
  BOTTOM w0.1: v1(102.1,101.6) 101.72,101.6 101.34,101.98 101.34,109.69 102.26,110.61 102.26,115.62 101.16,116.72 101.16,118.23 99.71,119.68 99.71,127.91 100.61,128.8 100.61,135.51
GPP_E_7_CPU_GP1: length 121.1
  TOP w0.089: 97.48,128.79 97.58,128.88 97.58,130.24 98.1,130.77 98.1,131.69 99.19,132.78 99.19,135.1 99.01,135.29 99.01,136.27 98.89,136.39 98.89,136.51 98.85,136.55 U6E1.AM45
  TOP w0.1: v1(95.63,100.71) 95.86,100.94 95.86,107.11 96.23,107.48 96.23,107.86 96.44,108.06 96.44,110.59 96.82,110.98 96.82,113.62 97.69,114.49 97.69,115.15 97.41,115.43 97.41,117.72 R7F29.1 96.68,118.46 96.68,127.98 97.48,128.79 ; v1(102.23,39.88) 102.74,39.37 104.21,39.37 104.55,39.7 106.59,39.7 109.16,37.14 114.98,37.14 116.71,38.86 116.71,39.37 116.07,40 116.07,40.38 R6H30.1
  LAY6 w0.125: v1(102.23,39.88) 100.71,41.4 100.71,60.32 98.17,62.85 98.17,93.68 96.26,95.6 96.26,100.07 v1(95.63,100.71)
GPP_E_8_SATA_LED_N: length 241.9
  TOP w0.089: 98.28,128.45 98.49,128.66 98.49,130.08 98.87,130.45 98.87,131.37 99.96,132.46 99.96,133.57 99.96,135.42 99.91,135.46 U6E1.AK48
  TOP w0.1: R6H31.1 v1(116.84,40) ; R9G36.1 v1(21.97,69.98) ; v1(99.06,98.93) 98.8,98.93 97.76,99.98 97.76,103.69 97,104.45 97,105.57 97.76,106.33 97.76,107.92 97.34,108.33 97.34,110.21 97.76,110.63 97.76,113.27 98.6,114.12 98.6,115.57 98.32,115.86 98.32,118.6 97.58,119.34 97.58,127.75 98.28,128.45
  LAY5 w0.125: v1(116.84,40) 116.33,40.51 110.87,40.51 110.49,40.13 110.49,39.75 109.98,39.24 105.53,39.24 v1(105.02,38.74) 104.52,39.24 92.4,39.24 91.03,37.87 91.03,37.23 89.83,36.03 79.33,36.03 78.74,36.62 75.76,36.62 75,35.86 73.23,35.86 71.75,37.34 68.07,37.34 67.18,36.45 66.04,36.45 65.65,36.83 65.02,36.83 64.51,36.32 51.87,36.32 49.45,38.73 47.9,38.73 47.26,38.1 45.57,38.1 45.18,38.48 39.97,38.48 39.72,38.22 38.43,38.22 37.92,38.73 36.46,38.73 36.2,38.47 35.43,38.47 33.66,36.7 31.49,36.7 28.95,39.24 25.01,39.24 22.54,41.72 v1(21.01,41.72)
  LAY6 w0.125: v1(99.06,98.93) 98.55,98.42 98.55,95.81 100.73,93.62 100.73,85.34 99.94,84.55 99.94,74.19 100.62,73.52 100.62,70.5 99.91,69.8 99.91,63.25 102.74,60.43 102.74,43.08 104.77,41.04 104.77,38.99 v1(105.02,38.74) ; v1(21.97,69.98) 21.46,69.47 21.46,68.58 21.71,68.32 22.12,68.32 22.47,67.97 22.47,66.29 22,65.82 22,58.33 22.96,57.37 22.96,52.1 22.73,51.87 22.73,49.78 22.08,49.13 22.08,44.18 21.01,43.12 v1(21.01,41.72)
GPP_E_9_USB_OC0_N: length 102.6
  TOP w0.089: U6E1.AH36 v1(100.08,141.12)
  TOP w0.1: R6H10.1 108.45,54.61 103.63,54.61 v1(103.25,54.23)
  LAY6 w0.125: v1(99.06,98.04) 98.8,97.79 98.8,95.91 100.98,93.73 100.98,85.17 100.19,84.38 100.19,74.3 100.87,73.62 100.87,70.4 100.17,69.69 100.17,63.35 103.25,60.27 v1(103.25,54.23)
  BOTTOM w0.089: v1(100.08,141.12) 99.59,140.63 99.59,139.07 99.47,138.95 99.47,138.4 99.28,138.21 99.28,137.66 98.9,137.28 98.9,136.73 98.79,136.63 98.79,134.76
  BOTTOM w0.1: C6R2.1 100.82,141.86 v1(100.08,141.12) ; 98.79,134.76 98.79,119.12 98.55,118.87 98.55,118.24 99.56,117.22 99.56,115.57 ; 99.56,115.57 R6T5.2 ; 99.56,115.57 99.19,115.57 97.83,114.21 97.83,108.22 98.57,107.48 98.57,103.85 98.17,103.44 98.17,98.93 v1(99.06,98.04)
GPP_E_10_USB_OC1_N: length 104.1
  TOP w0.089: U6E1.AL40 v1(98.84,139.51)
  TOP w0.1: R6H11.1 109.72,54.35 109.22,54.35 108.58,54.99 98.57,54.99 v1(98.19,54.61)
  LAY6 w0.125: v1(98.19,54.61) 98.69,55.11 98.69,60.91 97.17,62.43 97.17,87.58 96.27,88.48 96.27,94.16 94.61,95.82 94.61,98.3 v1(95.5,99.19)
  BOTTOM w0.089: v1(98.84,139.51) 99.03,139.32 99.03,138.6 98.9,138.47 98.9,137.82 98.87,137.8 98.49,137.42 98.49,136.97 98.29,136.78 98.29,136.65
  BOTTOM w0.1: 98.29,136.65 98.29,120.27 96.54,118.52 96.54,114.81 97.15,114.2 97.15,107.31 96.26,106.42 96.26,105.41 R7T26.1 96.26,104.39 96.26,103 R7T27.2 96.26,101.98 96.26,99.82 95.63,99.19 v1(95.5,99.19)
GPP_E_11_USB_OC2_N: length 100
  TOP w0.089: U6E1.AJ44 v1(99.51,137.29)
  TOP w0.1: R6H12.1 111.76,54.43 110.71,55.47 CR6H1.2 105.3,55.47 105.02,55.75 v1(104.26,55.75)
  LAY6 w0.125: v1(99.06,101.34) 100.09,100.31 100.09,95.82 102.23,93.67 102.23,91.57 102.74,91.06 102.74,89.76 101.51,88.53 101.51,84.99 100.7,84.17 100.7,74.51 101.37,73.83 101.37,70.19 100.68,69.49 100.68,63.56 104.39,59.84 104.39,55.88 v1(104.26,55.75)
  BOTTOM w0.089: C6R3.1 99.76,135.32 99.76,137.04 v1(99.51,137.29)
  BOTTOM w0.1: v1(99.06,101.34) 99.03,101.34 98.39,101.98 98.39,102.97 R6T19.2 98.8,104.39 98.8,105.79 R6T18.1 ; R6T18.1 R6T17.2 ; R6T18.1 100.66,107.64 100.66,109.98 101.57,110.89 101.57,115.34 100.48,116.43 100.48,117.93 99.02,119.39 99.02,134.59 C6R3.1
GPP_E_12_USB_OC3_N: length 194.1
  TOP w0.089: v1(98.6,138.78) U6E1.AL41
  TOP w0.1: v1(47.87,108.08) 47.87,108.46 44.19,112.14 33.29,112.14 CR8F1.2 ; v1(97.79,56.01) 98.04,56.26 102.48,56.26 103.25,57.02 110.46,57.02 CR6H2.2 ; R6H1.2 112.01,55.5 CR6H2.2 ; CR6H2.2 112.77,54.71 R6H18.2
  LAY6 w0.125: v1(96.01,87.5) 96.62,86.89 96.62,62.27 98.19,60.7 98.19,58.69 97.28,57.78 97.28,56.51 v1(97.79,56.01)
  BOTTOM w0.089: 98.07,136.69 98.07,136.93 98.3,137.16 98.3,137.5 98.68,137.88 98.68,138.23 98.6,138.31 v1(98.6,138.78)
  BOTTOM w0.1: v1(47.87,108.08) 50.54,108.08 53.72,104.9 69.58,104.9 71.94,102.55 71.94,101.38 74.76,98.56 74.76,96.63 77.8,93.59 81.58,93.59 83.95,91.22 86.75,91.22 89.15,88.81 94.7,88.81 v1(96.01,87.5) 96.69,88.19 99.23,88.19 103.25,92.2 103.25,93.72 100.15,96.82 95.32,96.82 94.99,97.15 94.99,105.92 96.84,107.77 96.84,114.18 96.26,114.76 96.26,118.62 98.07,120.42 98.07,131.87 C6R4.1 98.07,132.28 98.07,136.69
GPP_F_0_SATAPCIE_3_SATAGP_3: length 115.1
  TOP w0.089: U6E1.AN47 98.08,135.91 98.14,135.85 98.14,133.37 95.68,130.9 95.68,129.8
  TOP w0.1: R6H14.1 R6H3.1 115.44,55.5 115.44,58.93 114.58,59.79 102.71,59.79 100.96,58.04 96.13,58.04 95.8,57.71 v1(95.8,56.31) ; v1(93.34,102.61) 92.87,103.08 92.87,103.88 93.11,104.13 93.11,110.09 92.65,110.55 92.65,111.66 95.05,114.06 95.48,114.06 95.96,114.55 95.96,116.13 95.68,116.41 95.68,129.8
  LAY6 w0.125: v1(93.34,102.61) 93.34,102.09 92.01,100.76 92.01,95.75 92.8,94.97 92.8,93.64 93.64,92.81 93.64,89.7 92.7,88.77 92.7,80.49 93.5,79.7 93.5,74.02 92.63,73.16 92.63,68.58 93.21,68 93.21,58.29 95.19,56.31 v1(95.8,56.31)
GPP_F_1_SATAPCIE_4_SATAGP_4: length 107.5
  TOP w0.089: 97.38,130.05 97.38,130.31 97.91,130.85 97.91,131.77 99,132.86 99,135.02 98.82,135.21 98.82,136.19 U6E1.AM46
  TOP w0.1: R6H15.1 115.82,58.87 114.67,60.02 98.75,60.02 v1(97.66,58.93) ; v1(93.72,98.42) 94.48,99.19 94.48,100.84 95.4,101.76 95.4,106.9 R7F51.1 94.61,107.69 94.61,109.71 95.49,110.59 95.79,110.59 96.37,111.16 96.37,113.81 96.73,114.17 96.73,116.63 96.45,116.91 96.45,128.04 97.38,128.97 97.38,130.05
  LAY6 w0.125: v1(97.66,58.93) 97.66,60.83 96.37,62.12 96.37,86.12 95.3,87.18 95.3,88.99 95.77,89.45 95.77,93.95 93.72,96 v1(93.72,98.42)
GPP_F_2_SATAPCIE_5_SATAGP_5: length 111.9
  TOP w0.089: U6E1.AM43 v1(98.25,138.05)
  TOP w0.1: R6H16.1 R6H4.1 116.05,55.65 116.05,58.96 114.76,60.24 97.83,60.24 v1(96.52,58.93)
  LAY6 w0.125: v1(96.52,58.93) 95.87,59.58 95.87,79.08 94.8,80.15 94.8,89.2 95.26,89.66 95.26,93.75 92.96,96.04 92.96,99.19 v1(93.72,99.95)
  BOTTOM w0.089: v1(98.25,138.05) 97.93,138.05 97.45,137.57 97.45,137.22 97.75,136.92 97.75,135.76
  BOTTOM w0.1: v1(93.72,99.95) 94.36,100.58 94.36,105.6 96.62,107.86 96.62,114.09 96.03,114.67 96.03,118.71 96.42,119.1 96.42,127.42 97.4,128.4 97.4,129.87 96.52,130.76 96.52,132.59 97.75,133.82 97.75,135.76
GPP_F_3_SATAPCIE_6_SATAGP_6: length 119.5
  TOP w0.089: 95.9,129.65 95.9,130.86 98.34,133.29 98.34,135.52 98.55,135.73 U6E1.AM47
  TOP w0.1: 95.9,129.65 95.9,116.58 96.19,116.29 96.19,114.45 95.57,113.84 95.15,113.84 92.88,111.57 92.88,110.64 93.34,110.18 v1(93.34,103.5) ; R6H17.1 R6H5.1 118.36,55.37 118.36,57.53 115.42,60.47 97.3,60.47 95.32,58.5 95.32,55.98 v1(95.8,55.5)
  LAY6 w0.125: v1(95.8,55.5) 95.3,56.01 94.61,56.01 92.96,57.66 92.96,67.9 92.38,68.47 92.38,73.34 93.24,74.2 93.24,79.6 92.45,80.39 92.45,93.34 91.76,94.04 91.76,100.87 92.83,101.94 92.83,103 v1(93.34,103.5)
GPP_F_4_SATAPCIE_7_SATAGP_7: length 107.6
  TOP w0.089: 96.13,129.39 96.13,130.82 98.53,133.21 98.53,135.33 U6E1.AM48
  TOP w0.1: 96.13,129.39 96.13,116.67 96.41,116.39 96.41,114.36 94.1,112.04 94.1,111.12 93.57,110.59 93.57,105.82 93.85,105.54 93.85,102.36 93.19,101.7 93.19,101.24 v1(93.72,100.71) ; R6H13.1 R6H2.1 114.3,55.37 114.3,56.89 115.06,57.66 115.06,58.8 114.3,59.56 103.5,59.56 101.34,57.4 v1(97.79,57.4)
  LAY6 w0.125: v1(97.79,57.4) 98.44,58.06 98.44,60.81 96.91,62.33 96.91,87.48 96.02,88.38 96.02,94.06 94.36,95.71 94.36,100.07 v1(93.72,100.71)
GPP_F_5_SATA_DEVSLP_3: length 18.8
  TOP w0.089: 95.19,129.74 95.19,130.96 97.76,133.52 97.76,135.42 97.72,135.46 U6E1.AP48
  TOP w0.1: 95.19,129.74 95.19,119.2 R7F27.1
GPP_F_6_SATA_DEVSLP_4: length 181.6
  TOP w0.089: 94.74,129.69 94.74,131.04 97.38,133.68 97.38,135.26 97.29,135.35 97.29,135.68 97.06,135.91 U6E1.AR47
  TOP w0.1: R8G82.2 32.38,67.08 32.25,67.21 v1(32.25,67.31) ; v1(88.9,102.74) 89.39,103.24 89.39,104.23 90.65,105.48 90.65,108.43 90.77,108.56 90.77,109.96 91.09,110.27 91.09,111.91 92.25,113.07 92.25,116.26 92.74,116.74 92.74,118.4 94.74,120.4 94.74,129.69 ; v1(50.67,48.56) 49.32,48.56 48.76,48 R8H39.2
  LAY5 w0.125: v1(92.45,55.62) 92.45,55.6 89.98,53.14 86.76,53.14 86.22,53.68 84.08,53.68 81.83,51.44 78.28,51.44 77,50.16 73.19,50.16 72.05,49.02 61.21,49.02 60.57,49.66 60.07,49.66 59.81,49.4 59.12,49.4 57.6,47.88 51.36,47.88 v1(50.67,48.56) 50.59,48.64 47.78,48.64 46.75,47.61 43.67,47.61 42.14,46.08 37.59,46.08 37.19,46.48 32.33,46.48 v1(31.8,45.95)
  LAY6 w0.125: v1(31.8,45.95) 31.8,46.12 34.79,49.12 34.79,51.32 33.91,52.2 33.91,53.7 34.03,53.82 34.03,65.45 32.25,67.23 v1(32.25,67.31) ; v1(88.9,102.74) 90.8,100.84 90.8,90.8 90.16,90.17 90.16,81.13 92.4,78.9 92.4,75.13 91.63,74.36 91.63,68.13 92.2,67.56 92.2,55.88 v1(92.45,55.62)
GPP_F_7_SATA_DEVSLP_5: length 19.7
  TOP w0.089: U6E1.AN46 97.84,136.26 97.84,135.88 97.95,135.77 97.95,133.45 95.42,130.92 95.42,129.77
  TOP w0.1: R7F28.1 95.25,118.74 95.42,118.92 95.42,129.77
GPP_F_8_SATA_DEVSLP_6: length 25
  TOP w0.089: U6E1.AN37 v1(97.75,141.01)
  BOTTOM w0.089: v1(97.75,141.01) 98.18,140.57 98.18,140.03 97.92,139.77 97.92,138.68 97.52,138.28 97.52,137.91 97.26,137.65 97.26,137.14 97.28,137.12 97.55,136.84 97.55,135.77 97.28,135.5 97.28,135.25
  BOTTOM w0.1: R7T11.1 95.25,118.49 96.2,119.44 96.2,132.78 97.28,133.86 97.28,135.25
GPP_F_9_SATA_DEVSLP_7: length 19.7
  TOP w0.089: 94.97,129.72 94.97,131 97.57,133.6 97.57,135.34 97.48,135.43 97.48,135.78 97.56,135.86 U6E1.AP47
  TOP w0.1: 94.97,129.72 94.97,119.86 R7F26.1
GPP_F_10_SATA_SLOCK: length 22.8
  TOP w0.089: U6E1.AR42 v1(96.63,138.18)
  BOTTOM w0.089: v1(96.63,138.18) 96.27,137.82 96.26,137.82 96.01,137.57 96.01,137.22 96.13,137.1 96.13,135.64 96.26,135.51 96.26,135.25
  BOTTOM w0.1: R7T16.2 92.71,118.74 93.09,118.74 94.99,120.65 94.99,132.97 96.26,134.24 96.26,135.25
GPP_F_12_SATA_SDATAOUT1: length 29.5
  TOP w0.089: U6E1.AU46 96.68,136.13 96.68,135.85 96.8,135.73 96.8,135.3 97,135.11 97,133.84 94.28,131.12 94.28,129.64
  TOP w0.1: 94.28,129.64 94.28,120.59 92.28,118.59 92.28,117.05 91.79,116.56 91.79,113.26 90.63,112.1 90.63,110.57 R7F50.2
GPP_F_13_SATA_SDATAOUT0: length 19.9
  TOP w0.089: 94.05,129.62 94.05,131.16 96.81,133.92 96.81,135.02 96.61,135.22 96.61,135.61 U6E1.AU47
  TOP w0.1: R7F36.2 91.82,118.45 94.05,120.69 94.05,129.62
GPP_F_14_EXT_PWR_GATE_PS_ON_N: length 23
  TOP w0.089: v1(97.13,138.78) U6E1.AP41
  BOTTOM w0.089: v1(97.13,138.78) 97.13,138.08 96.87,137.82 96.87,137.17 96.51,136.81 96.51,135.81 96.82,135.5 96.82,135.19
  BOTTOM w0.1: R7T9.1 95.25,120.27 95.25,132.71 96.82,134.29 96.82,135.19
GPP_F_15_USB_OC4_N: length 20.9
  TOP w0.089: U6E1.AV47 96.05,135.91 96.05,133.96 92.87,130.79 92.87,130.37
  TOP w0.1: 92.87,130.37 92.87,124.49 92.22,123.84 92.22,120.53 91.94,120.24 91.19,120.24 90.75,119.8 90.75,119.2 R7F35.2
GPP_F_16_USB_OC5_N: length 22.3
  TOP w0.089: U6E1.AR35 v1(96.65,141.77)
  BOTTOM w0.089: 95.78,135.25 95.78,135.98 95.94,136.13 95.94,137.02 95.82,137.14 95.82,137.65 96.01,137.84 96.01,138.16 96.28,138.43 96.28,138.55 96.97,139.24 96.97,139.66 97.3,139.99 97.3,141.12 v1(96.65,141.77)
  BOTTOM w0.1: 95.78,135.25 95.78,134.44 94.74,133.39 94.74,122.3 R7T3.2
GPP_F_17_USB_OC6_N: length 196.7
  TOP w0.089: U6E1.AR37 v1(96.65,141.01)
  TOP w0.1: CR8F2.2 38.37,113.66 30.98,113.66 v1(30.35,114.3)
  LAY5 w0.125: v1(30.35,114.3) 30.35,113.66 31.24,112.77 31.24,106.55 31.75,106.04 31.75,104.39 31.24,103.88 31.24,99.44 30.48,98.68 30.48,92.03 28.33,89.89 28.33,88.69 27.66,88.02 27.66,83 28.44,82.22 28.44,80.99 29.1,80.33 29.1,75.44 28.72,75.07 28.72,73.2 26.56,71.03 26.56,66.81 28.93,64.44 33.77,64.44 34.21,64.01 36.09,64.01 36.7,64.62 36.7,65.37 38.74,67.4 38.74,69.74 40.64,71.63 40.64,72.5 44.2,76.06 45.39,76.06 45.77,75.68 50.46,75.68 51.46,76.68 52.38,76.68 54.06,78.37 55.13,78.37 55.68,78.92 59.38,78.92 60.6,80.13 64.48,80.13 65.12,80.77 66.09,80.77 66.6,80.26 69.65,80.26 70.41,81.02 73.3,81.02 75.6,83.32 79.97,83.32 81.11,84.47 82.04,84.47 82.54,84.97 84.83,84.97 89.78,89.92 89.78,98.85 90.37,99.44 v1(90.37,102.61)
  BOTTOM w0.089: 95.55,135.25 95.55,136.02 95.75,136.21 95.75,136.95 95.63,137.06 95.63,137.73 95.82,137.91 95.82,138.24 96.09,138.51 96.09,138.62 96.78,139.32 96.78,139.74 97.1,140.05 97.1,140.64 96.73,141.01 v1(96.65,141.01)
  BOTTOM w0.1: v1(90.37,102.61) 90.37,102.74 89.78,103.32 89.78,103.76 88.9,104.65 88.9,109.6 88.26,110.23 88.26,111.89 87.75,112.39 87.75,113.31 CR7T1.2 90.29,115.85 90.29,117.73 R7T13.2 89.53,118.49 89.53,125.84 94.41,130.72 94.41,133.39 95.55,134.53 95.55,135.25
GPP_F_18_USB_OC7_N: length 354.3
  TOP w0.089: U6E1.AV43 v1(95.33,138.09)
  TOP w0.1: v1(231.9,258.44) 231.9,257.05 R3B16.2
  LAY5 w0.125: v1(231.9,258.44) 231.9,258.91 231.35,259.46 224.19,259.46 223.43,260.22 217.39,260.22 213.24,264.38 211.64,264.38 208.15,260.89 199.74,260.89 198.7,259.85 195.08,259.85 193.54,258.32 192.65,258.32 192.4,258.57 184.7,258.57 184.34,258.21 174.01,258.21 172.96,257.16 164.33,257.16 163.96,256.78 161.93,256.78 160.75,255.6 159.58,255.6 158.43,254.46 147.08,254.46 146.49,253.87 137.08,253.87 134.07,250.86 131.25,250.86 129.9,249.51 127.87,249.51 124.78,246.41 119.8,246.41 118.95,247.26 117.01,247.26 116.59,246.84 110.55,246.84 v1(110.51,246.89) ; v1(123.44,187.07) 123.06,187.07 122.43,186.44 122.43,175.3 123.31,174.42 123.31,167.53 122.17,166.39 122.17,164.42 123.55,163.04 123.55,157.47 124.58,156.44 124.58,150.64 123.43,149.49 123.43,136.41 120.9,133.88 120.9,129.45 111.5,120.05 111.5,118.74 108.12,115.36 108.12,112.9 107.06,111.84 107.06,111.19 103.42,107.55 102.22,107.55 100.6,105.93 91.19,105.93 90.45,106.68 88.8,106.68 v1(87.65,107.82)
  LAY6 w0.125: v1(110.51,246.89) 110.51,245.08 108.7,243.28 108.7,241.51 109.72,240.49 109.72,236.29 103.5,230.08 103.5,227.5 104.01,227 104.01,213.91 107.18,210.74 107.18,202.49 114.34,195.33 118.99,195.33 120.01,194.31 121.15,194.31 123.06,192.4 123.06,187.45 v1(123.44,187.07)
  BOTTOM w0.089: v1(95.33,138.09) 95.44,137.99 95.44,136.99 95.56,136.87 95.56,136.29 95.33,136.07 95.2,135.93 95.2,135.25
  BOTTOM w0.1: 95.2,135.25 95.2,134.68 94.05,133.54 94.05,130.87 89.28,126.09 89.28,116.33 88.9,115.95 87.24,115.95 86.3,115.01 86.3,109.17 v1(87.65,107.82)
GPP_H_5_WAKE_SLTBC_L: length 141.3
  TOP w0.089: U6E1.AC39 v1(103.77,139.6)
  TOP w0.1: v1(125.34,40) 125.98,39.37 131.19,39.37 133.22,37.34 133.22,29.4 136.46,26.16 136.9,26.16 137.49,25.58 139.56,25.58 140.11,25.02 R5J3.2
  LAY6 w0.125: v1(112.9,106.17) 113.76,105.31 113.76,100.48 114.93,99.31 114.93,90.43 116.46,88.9 116.46,87.25 120.55,83.15 120.55,79.81 122.9,77.46 122.9,72.18 120,69.28 120,62.29 125.47,56.82 125.47,54.99 125.98,54.48 125.98,52.73 124.89,51.64 124.89,40.46 v1(125.34,40)
  BOTTOM w0.089: 104.26,138.17 104.26,139.11 v1(103.77,139.6)
  BOTTOM w0.1: 104.26,138.17 104.87,137.56 104.87,120.49 105.91,119.45 107.23,119.45 113.36,113.33 113.36,107.52 112.9,107.06 v1(112.9,106.17)
GPP_H_15: length 255.6
  TOP w0.089: 103.34,126.96 103.34,127.42 103.15,127.6 103.15,128.87 102.83,129.19 102.83,130.73 103.32,131.22 103.32,135.35 103.41,135.44 103.41,135.73 103.34,135.81 U6E1.AC47
  TOP w0.1: 103.34,126.96 103.34,124.37 103.8,123.91 v1(103.8,120.24) ; R7F44.2 81.78,113.54 81.53,113.54 80.77,114.3 v1(80.77,120.52) ; R5A58.1 v1(157.22,261.11)
  LAY5 w0.125: v1(103.8,120.24) 103.8,121.07 109.09,126.36 111.53,126.36 116.58,131.41 116.58,137.46 114.92,139.11 114.92,153.1 115.95,154.12 115.95,160.2 115.05,161.09 115.05,164.64 114.8,164.89 114.8,165.93 115.56,166.69 115.56,171.49 116.84,172.77 116.84,176.84 117.53,177.53 117.53,183.33 116.06,184.8 116.06,186.32 v1(116.58,186.84)
  LAY6 w0.125: v1(116.58,186.84) 115.82,186.08 115.82,185.55 118.61,182.75 124.71,182.75 128.01,186.05 128.01,188.08 126.14,189.94 126.14,199.68 127.31,200.84 127.31,209.1 128.68,210.47 128.68,213.07 128.2,213.55 128.2,215.33 127.63,215.9 127.63,217.33 126.29,218.67 126.29,226.17 125.4,227.06 125.4,235.73 124.8,236.33 124.8,238.09 124.97,238.26 124.97,239.38 131.5,245.9 131.5,248.04 138.08,254.62 141.17,254.62 142.66,256.1 142.66,256.78 144.07,258.2 145.72,258.2 146.35,258.84 149.06,258.84 150.32,260.1 154.92,260.1 155.93,261.11 v1(157.22,261.11) ; v1(80.77,120.52) 80.77,119.51 83.18,117.09 95.26,117.09 97.43,119.26 102.82,119.26 v1(103.8,120.24)
  BOTTOM w0.1: R6T11.2 R6T6.1 109.6,114.68 109.6,115.31 106.17,118.74 104.77,118.74 103.8,119.72 v1(103.8,120.24)
GPP_I_0_DDSP_HPD_0: length 323.6
  TOP w0.089: U6E1.AT6 v1(96.44,155.98)
  TOP w0.1: v1(281.17,268.22) 280.41,268.22 280.03,268.6 280.03,269.24 R1A6.1
  LAY5 w0.125: v1(88.13,251.59) 88.78,252.24 93.35,252.24 93.53,252.41 96.73,252.41 97.03,252.72 103.82,252.72 104.47,253.37 106.92,253.37 107.43,252.86 112.04,252.86 112.77,253.59 125.47,253.59 126.01,254.13 127,254.13 127.63,254.76 128.67,254.76 129.34,255.44 131.51,255.44 135.1,259.02 142.85,259.02 143.14,259.31 148.82,259.31 149.6,260.09 155.06,260.09 155.57,260.6 157.73,260.6 159,261.87 167.84,261.87 168.86,262.89 170.07,262.89 172.33,265.15 172.33,266.06 175.12,268.85 184.79,268.85 185.8,267.84 191.36,267.84 192.63,269.11 198.14,269.11 199.79,267.46 200.94,267.46 201.84,266.55 204.52,266.55 205.08,267.11 208.11,267.11 210.21,269.21 214.93,269.21 216.81,267.34 221.78,267.34 222.16,266.96 227.33,266.96 228.62,268.25 228.62,270.56 230.35,272.29 244.34,272.29 246.5,270.13 252.64,270.13 253.36,270.85 266.45,270.85 267.17,270.13 270.76,270.13 272.22,268.67 274.12,268.67 275.31,269.85 277.35,269.85 278.52,268.68 280.72,268.68 v1(281.17,268.22)
  BOTTOM w0.089: 95.67,160.1 96.32,159.45 96.32,156.49 96.44,156.37 v1(96.44,155.98)
  BOTTOM w0.1: 95.67,160.1 95.67,160.8 94.57,161.9 94.57,163.52 93.76,164.34 93.09,164.34 90.88,166.55 90.88,170.6 87.09,174.39 87.09,177.7 85.95,178.84 85.95,192.32 85.27,193 85.27,195.42 84.63,196.05 84.63,196.96 86.55,198.88 86.55,215.31 87.96,216.73 87.96,222.51 91.59,226.14 91.59,232.36 90,233.95 90,234.91 91.34,236.25 91.34,245.33 89.94,246.73 89.94,250.67 90.19,250.92 90.19,251.94 90.04,252.09 88.64,252.09 v1(88.13,251.59)
GPP_I_1_DDSP_HPD_1: length 272.3
  TOP w0.089: U6E1.AN10 v1(97.44,153.87)
  TOP w0.1: R2A70.1 v1(254.25,259.71)
  LAY5 w0.125: v1(254.25,259.71) 253.01,259.71 252.14,258.84 246.91,258.84 246.5,258.44 237,258.44 236.37,257.81 233.42,257.81 231.92,256.31 229.86,256.31 228.87,257.31 227.05,257.31 225.65,255.91 224.81,255.91 223.55,257.17 213.83,257.17 212.85,256.18 210.43,256.18 210.16,255.91 199.9,255.91 199.17,255.18 198.92,255.18 198.22,254.48 195.19,254.48 193.8,253.09 193.8,252.66 193.21,252.07 192.81,252.07 191.01,253.87 182.64,253.87 180.49,251.72 174.22,251.72 173.74,252.21 148.01,252.21 147.4,251.59 138,251.59 135.01,248.6 132.18,248.6 131.12,247.53 131.12,246.55 129.93,245.37 126.93,245.37 125.72,244.15 116.59,244.15 116.17,244.58 111.78,244.58 111.57,244.37 109.27,244.37 108.02,245.62 105.53,245.62 104.89,244.97 104.45,244.97 103.75,245.67 101.71,245.67 101,244.96 96.41,244.96 v1(96.01,245.36)
  BOTTOM w0.089: 96.39,160.24 96.7,159.93 96.7,158.64 96.7,156.65 96.82,156.53 97.06,156.29 97.06,155.64 97.24,155.45 97.32,155.37 97.32,155.01 97.56,154.78 97.56,154.43 97.44,154.31 v1(97.44,153.87)
  BOTTOM w0.1: 96.39,160.24 96.13,160.5 96.13,160.92 95.03,162.02 95.03,163.71 94.67,164.07 94.67,167.45 92.71,169.42 92.71,171.12 89.02,174.8 89.02,178.11 87.61,179.53 87.61,191.45 88.74,192.58 88.74,196.88 88.13,197.48 88.13,200.15 88.39,200.4 88.39,213.97 89.9,215.48 89.9,220.24 92.91,223.25 92.91,229.07 94.07,230.23 94.07,243.3 95.4,244.63 95.4,244.76 v1(96.01,245.36)
GPP_I_2_DDSP_HPD_2: length 187.5
  TOP w0.089: v1(97.13,154.6) U6E1.AP9
  TOP w0.1: v1(110.49,254.38) 111.41,253.45 126.04,253.45 127.13,252.36 145.34,252.36 147.67,254.69 152.75,254.69 154.83,256.76 156.56,256.76 R5B8.1 R5B2.1 R5B1.1
  LAY5 w0.125: v1(91.26,254) 91.77,253.49 92.83,253.49 93.05,253.7 93.05,255.86 93.67,256.49 99.03,256.49 99.26,256.25 100.2,256.25 102.47,253.98 103.31,253.98 103.95,254.63 107.44,254.63 107.95,254.11 110.22,254.11 v1(110.49,254.38)
  BOTTOM w0.089: 95.9,160.25 96.51,159.64 96.51,156.57 96.87,156.21 96.87,155.56 97.05,155.37 97.05,155.37 97.13,155.3 v1(97.13,154.6)
  BOTTOM w0.1: v1(91.26,254) 91.26,252.73 90.55,252.01 90.55,250.95 90.17,250.57 90.17,246.82 91.57,245.43 91.57,235.97 90.23,234.63 90.23,234.05 91.82,232.45 91.82,226.05 88.19,222.42 88.19,216.5 86.77,215.09 86.77,198.78 84.86,196.87 84.86,196.14 85.5,195.51 85.5,193.1 86.18,192.41 86.18,178.93 87.31,177.8 87.31,174.49 91.18,170.62 91.18,166.88 92.71,165.35 93.59,165.35 94.1,164.84 94.1,164.32 94.8,163.62 94.8,161.96 95.9,160.86 95.9,160.25
GPP_K_9_FOXLAN_PWR_EN: length 237.2
  TOP w0.089: U6E1.V47 105.53,135.86 105.61,135.78 105.61,135.44 105.52,135.35 105.52,129.35 106.3,128.57
  TOP w0.1: v1(101.21,275.72) 101.21,275.59 102.1,274.7 108.83,274.7 R6A40.1 ; v1(107.44,113.25) 108.13,113.94 108.13,121.09 107.59,121.63 107.59,127.28 106.3,128.57
  LAY5 w0.125: v1(107.44,113.25) 107.86,113.67 107.86,116.77 120.65,129.55 120.65,133.99 123.18,136.52 123.18,149.6 124.33,150.75 124.33,156.34 123.3,157.37 123.3,162.93 121.92,164.31 121.92,166.5 123.06,167.64 123.06,174.32 122.14,175.23 122.14,185.07 v1(119.88,187.32)
  LAY6 w0.125: v1(101.09,265.81) 101.09,265.94 101.28,266.13 104.83,266.13 106.55,264.41 106.55,263.52 106.8,263.27 106.8,259.71 108.2,258.31 108.2,255.42 110.51,253.11 112.67,253.11 114.04,251.74 114.04,249.15 113.17,248.28 110.76,248.28 108.2,245.72 108.2,241.3 109.22,240.28 109.22,236.5 103.85,231.14 101.85,231.14 101.34,230.63 101.34,229.21 102,228.55 102,226.88 102.5,226.37 102.5,213.29 103.88,211.91 103.88,203.45 114.42,192.91 116.84,192.91 119.26,190.49 119.26,187.95 v1(119.88,187.32)
  BOTTOM w0.1: v1(101.21,275.72) 100.45,274.95 100.45,267.08 101.09,266.44 v1(101.09,265.81) ; v1(107.44,113.25) 107.44,110.99 108.58,109.85
GPP_K_14_EDP_ALS_INT_N: length 32.8
  TOP w0.089: 105.03,129.04 105.03,129.3 105.14,129.41 105.14,135.44 105.14,135.44 105.14,135.76 105.24,135.86 105.24,135.92 105.25,135.92 105.25,136.22 105.24,136.22 105.24,136.27 U6E1.W46
  TOP w0.1: R6F31.1 106.47,105.59 106.47,108.76 106.69,108.98 106.69,111.75 106.49,111.96 106.49,113.64 107.18,114.33 107.18,120.69 106.64,121.23 106.64,125.17 106.17,125.64 106.17,127.74 105.03,128.89 105.03,129.04
GPP_K_19_SMI_N: length 124.4
  TOP w0.089: 109.24,127.89 109.24,128.25 106.75,130.73 106.75,135.33 U6E1.T48
  TOP w0.1: 109.24,127.89 109.24,110.9 108.35,110.02 108.35,108.17 108.12,107.94 108.12,105.49 v1(108.83,104.77)
  LAY6 w0.125: v1(114.65,30.86) 115.16,30.86 115.89,31.6 116.17,31.6 122.3,37.73 122.3,48.98 121.37,49.91 121.37,57.41 118.24,60.55 118.24,70.01 120.27,72.04 120.27,76.74 118.29,78.72 118.29,82.22 112.92,87.59 112.92,98.48 109.6,101.8 109.6,104.01 v1(108.83,104.77)
  BOTTOM w0.1: v1(114.65,30.86) 113.15,30.86 109.85,27.56 R6W1.1
GPP_K_19_SMI_R_N: length 5.7
  TOP w0.1: J7J1.25 108.83,26.01 108.98,25.86 v1(108.98,25.13)
  BOTTOM w0.1: R6W2.2 R6W1.2 108.83,26.03 108.98,25.89 v1(108.98,25.13)
GPPC_B2_UART_BT_WAKE_N: length 106.1
  TOP w0.1: v1(77.72,139.19) 78.35,139.19 R7E38.1 ; v1(82.16,228.6) 82.16,229.23 81.28,230.12 79.75,230.12 R7B77.1 77.79,231.07 J7C1.20
  LAY5 w0.125: v1(79.37,202.06) 78.74,201.42 78.74,200.79 79.25,200.28 79.25,187.14 82.94,183.44 82.94,175.13 80.89,173.08 80.89,165.1 81.66,164.34 81.66,159.82 81.3,159.46 81.3,154.45 79.57,152.73 79.57,150.19 78.23,148.84 78.23,145.54 78.99,144.78 78.99,140.46 v1(77.72,139.19)
  LAY6 w0.125: v1(79.37,202.06) 78.11,203.31 78.11,217.32 79.62,218.83 79.62,227.2 80.51,228.09 81.66,228.09 v1(82.16,228.6)
GPPJ_RCOMP: length 5
  TOP w0.2: U6E1.BE2 92.18,158.33 U6E1.BE1 91.97,158.72 v1(91.97,159.01)
  TOP w0.254: U6E1.BD1 92.69,158.57 92.25,159.01 v1(91.97,159.01)
  BOTTOM w0.38: R7R4.1 90.32,160.65 v1(91.97,159.01)
GSPI2_MISO_BSSB_CLK: length 83
  TOP w0.1: R9D40.1 R9D41.1 17.9,163.7 19.01,163.7 19.55,163.16 19.55,161.54 20.19,160.91 23.47,160.91 24.07,160.31 30.42,160.31 31.25,161.14 31.25,165.17 v1(31.3,165.23)
  BOTTOM w0.1: v1(31.3,165.23) 31.56,165.48 31.75,165.48 31.96,165.7 35.26,165.7 35.68,166.11 41.73,166.11 43.26,164.59 43.81,164.59 44.57,165.35 44.57,165.99 45.3,166.72 52.45,166.72 58.58,160.59 62.01,160.59 64.35,158.25 66.43,158.25 67.72,156.96 72.9,156.96 73.66,156.2 74.93,156.2 75.07,156.06 75.65,155.48 80.22,155.48 82.8,152.91 R7R21.2
GSPI2_MOSI_BSSB_DI: length 81.9
  TOP w0.1: v1(32.25,166.37) 32.13,166.5 31.24,166.5 30.78,166.04 30.78,161.34 30.22,160.78 26.41,160.78 23.87,163.32 20.7,163.32 19.05,164.97 18.03,164.97 R9D39.1 R9D38.1
  BOTTOM w0.1: v1(32.25,166.37) 32.51,166.62 42.92,166.62 43.18,166.37 43.88,166.37 44.7,167.19 52.89,167.19 54.75,165.33 56.16,165.33 56.89,164.59 56.89,163.32 58.44,161.77 58.95,161.77 59.43,161.29 62.3,161.29 64.64,158.95 66.72,158.95 68.01,157.66 73.19,157.66 73.95,156.9 75.22,156.9 75.36,156.76 75.94,156.19 81.04,156.19 82.55,154.68 82.93,154.68 83.43,154.18 R7R15.2
GSVTT_PWROK_BJT: length 1.8
  TOP w0.1: Q8C7.6 32.38,207.77 32.13,207.52 R8C41.1
H8S_EEPROM_WP: length 2.8
  TOP w0.1: U7H3.7 66.04,47.62 67.05,48.64 R7H57.1
H_CATERR_N: length 272.1
  TOP w0.1: v1(120.52,87.22) 118.89,87.22 118.36,87.76 116.91,87.76 v1(115.44,89.23) ; EU8H2.4 58.42,48.39 58.16,48.13 R8H37.2 57.78,47.75 57.53,48 57.02,48 v1(57.02,48.89) ; J3D1.D16 v1(217.72,196.72)
  LAY5 w0.089: 208.05,184.02 208.05,185.06 208.78,185.8 210.31,185.8 210.82,186.31 210.82,188.72 211.07,188.97 217.17,188.97 218.16,189.96 218.16,196.28 v1(217.72,196.72)
  LAY5 w0.1: 208.05,184.02 208.05,183.67 207.84,183.46 207.41,183.46 207.23,183.28
  LAY5 w0.125: v1(120.52,87.22) 120.7,87.4 120.7,94.16 125.34,98.8 131.39,98.8 132.83,100.24 144.04,100.24 146.92,103.12 147.7,103.12 153.16,108.58 153.16,114.81 155.01,116.66 155.01,120.78 155.19,120.96 155.19,132.79 155.39,132.99 157.25,132.99 158.49,134.24 158.49,142.87 157.98,143.38 157.98,147.19 159.51,148.72 162.3,148.72 164.08,150.49 164.08,154.43 172.59,162.94 173.99,162.94 179.59,168.55 179.59,169.79 180.24,170.43 181.47,170.43 183.51,172.46 189.66,172.46 194.27,177.07 194.27,180.56 197,183.28 207.23,183.28
  BOTTOM w0.1: v1(115.44,89.23) 113.66,87.45 113.66,83.18 111.63,81.15 107.06,81.15 104.64,78.74 104.64,74.8 94.44,64.6 82.32,64.6 81.6,63.89 68.23,63.89 63.11,58.77 63.11,57.91 58.67,53.47 58.67,50.93 57.02,49.27 v1(57.02,48.89)
H_CPU_SVIDALRT_R_N: length 331.8
  TOP w0.1: R4C2.2 v1(176.27,224.61) R4C8.2 ; R1G6.1 296.98,70.17 297.81,70.99 300.22,70.99 J1G4.1
  LAY6 w0.125: J1G4.1 302.27,73.04 302.27,105.36 302.77,105.86 302.77,107.69 302.27,108.19 302.27,118.93 295.31,125.89 295.31,132.72 295.63,133.04 295.63,158.15 296.93,159.45 296.93,169.47 296.56,169.84 296.56,171.57 296.03,172.09 296.03,173.47 296.53,173.97 296.53,179.49 295.53,180.49 295.53,196.01 293.23,198.31 293.23,207 293.87,207.64 293.87,213.14 295.78,215.05 v1(295.78,215.07)
  LAY8 w0.1: v1(295.78,215.07) 296.25,215.07 297.9,216.72 297.9,218.63 294.96,221.58 293.82,221.58 287.11,228.29 287.11,229.05 285.05,231.1 277.31,231.1 273.14,235.27 273.14,238.19 271.49,239.84 271.49,248.99 270.04,250.44 207.96,250.44 207.71,250.18 194.15,250.18 193.82,250.51 181.89,250.51 177,245.62 177,239.2 175.48,237.67 175.48,233.74 174.08,232.34 174.08,230.95 175.6,229.43 175.6,226.94 177.57,224.97 177.57,224.35 177.34,224.12 176.76,224.12 v1(176.27,224.61)
H_CPU_SVIDCLK_R: length 337.6
  TOP w0.1: J1G5.1 300.22,64.64 296.6,64.64 R1H2.1 ; R4C9.2 v1(177.03,224.61) R4C3.2
  LAY6 w0.125: v1(295.77,213.68) 295.11,213.68 294.51,213.07 294.51,207.4 293.85,206.74 293.85,198.4 296.03,196.21 296.03,180.7 297.03,179.7 297.03,173.76 296.8,173.54 296.8,172.03 297.06,171.77 297.06,170.05 297.43,169.68 297.43,159.24 296.16,157.97 296.16,132.86 295.84,132.54 295.84,126.1 302.77,119.17 302.77,108.45 303.27,107.95 303.27,105.65 302.77,105.15 302.77,67.19 J1G5.1
  LAY8 w0.1: v1(177.03,224.61) 177.03,224.84 175.13,226.75 175.13,229.23 173.6,230.76 173.6,232.54 175,233.93 175,237.87 176.53,239.39 176.53,245.82 181.7,250.99 194.02,250.99 194.35,250.66 207.51,250.66 207.77,250.91 270.24,250.91 271.3,249.84 271.3,249.84 271.96,249.19 271.96,240.04 273.61,238.39 273.61,235.47 277.5,231.58 285.25,231.58 287.58,229.25 287.58,228.48 294.01,222.05 295.16,222.05 298.38,218.83 298.38,216.52 296.32,214.47 296.32,214.23 v1(295.77,213.68)
H_CPU_SVIDDAT_R: length 326.5
  TOP w0.1: R4C7.2 175.51,224.03 v1(174.87,224.66) 175.51,225.3 R4C1.2 ; J1G3.1 300.22,77.34 297.97,77.34 296.64,76.01 R1G5.1
  LAY6 w0.125: J1G3.1 301.77,78.89 301.77,105.57 302.27,106.07 302.27,107.29 301.77,107.79 301.77,118.73 294.81,125.69 294.81,132.93 295.13,133.25 295.13,158.36 296.03,159.26 296.03,171.39 295.52,171.89 295.52,173.67 296.03,174.18 296.03,179.28 295.03,180.28 295.03,195.8 292.73,198.1 292.73,207.25 293.37,207.9 293.37,213.37 295.65,215.64 v1(296.16,215.64)
  LAY8 w0.1: v1(174.87,224.66) 175.89,223.65 177.54,223.65 178.05,224.15 178.05,225.17 176.08,227.14 176.08,229.63 174.55,231.15 174.55,232.14 175.95,233.54 175.95,237.48 177.48,239 177.48,245.42 182.09,250.04 193.63,250.04 193.96,249.71 207.91,249.71 208.16,249.96 269.84,249.96 270.63,249.17 271.01,248.79 271.01,239.65 272.66,238 272.66,235.08 277.11,230.63 284.86,230.63 286.63,228.85 286.63,228.09 293.62,221.11 294.76,221.11 297.43,218.44 297.43,216.91 v1(296.16,215.64)
H_PECI: length 668.5
  TOP w0.089: 216.33,201.55 216.33,200.64 216.29,200.6 J3D1.A15
  TOP w0.1: v1(62.35,129.28) 62.92,129.85 62.92,133.14 60.74,135.32 60.74,140.05 59.52,141.26 59.52,145.71 59.3,145.92 59.3,147.83 59.92,148.44 59.92,151.08 58.68,152.32 58.68,160.01 55.62,163.07 55.62,164.97 56.18,165.53 56.18,167.19 57.55,168.55 61.36,168.55 65.53,172.72 65.53,177.29 63.75,179.07 63.75,180.47 65.65,182.37 65.65,184.91 67.06,186.31 79.49,186.31 80.73,185.08 92.62,185.08 v1(93.78,186.24) ; 216.33,201.55 216.33,203.52 216.12,203.73 216.12,204.17 207.28,213.01 196.15,213.01 194.66,214.49 187.2,214.49 186.69,215.01 186.69,216.03 187.45,216.79 187.45,219.45 185.54,221.36 183.13,221.36 181.1,219.33 179.83,219.33 179.16,220 179.16,222.8 179.55,223.19 179.55,224.87 179.05,225.37 179.05,227.58 178.38,228.26 174.86,228.26 174.28,228.83 174.28,229.44 172.84,230.88 v1(172.84,231.27) ; R8G24.1 v1(31.24,86.36) ; v1(136.9,214.25) 135.93,213.28 129.86,213.28 128.69,212.11 126.88,212.11 126.38,212.61 125.63,212.61 124.48,213.76 122.73,213.76 121.84,212.88 102.21,212.88 95.73,206.39 95.73,191.92 95.06,191.25 95.06,187.92 95.61,187.37 v1(95.61,184.66) 95.61,181.25 97.02,179.83 R7D24.1
  LAY5 w0.125: v1(32.13,43.18) 32.51,42.8 36.32,42.8 37.33,41.78 38.35,41.78 38.97,42.4 42.07,42.4 42.68,43.01 45.29,43.01 46.1,43.81 46.86,43.81 47.25,43.42 49.1,43.42 49.32,43.2 59.66,43.2 60.65,44.19 71.74,44.19 71.9,44.35 82.24,44.35 82.84,44.94 85.96,44.94 86.36,45.34 89.18,45.34 92.77,48.93 94.71,48.93 95.38,49.6 98.27,49.6 98.88,50.21 103.06,50.21 105.06,48.21 107.64,48.21 109.97,50.54 120.66,50.54 122.47,48.73 122.47,48.16 122.96,47.67 123.84,47.67 124.57,46.94 127.39,46.94 128.22,47.77 135.39,47.77 135.5,47.88 145.31,47.88 148.66,51.23 163.27,51.23 170.2,58.15 171.31,58.15 173.82,60.67 173.82,64.15 179.57,69.89 197.99,69.89 198.85,70.75 209.45,70.75 210.06,70.14 217.41,70.14 218.02,70.75 230.79,70.75 234.12,67.43 238.89,67.43 v1(241.8,64.51)
  LAY6 w0.125: v1(31.24,86.36) 31.24,80.64 31.11,80.52 31.11,76.34 33.24,74.21 33.24,72.29 32.55,71.6 32.55,69.05 31.77,68.27 31.77,67.1 33.61,65.26 33.61,54.12 33.48,54 33.48,52.02 34.37,51.13 34.37,49.39 31.26,46.29 31.26,45.44 32.13,44.58 v1(32.13,43.18) ; v1(95.61,184.66) 95.37,184.66 v1(93.78,186.24)
  BOTTOM w0.1: v1(31.24,86.36) 29.84,87.76 29.21,87.76 28.19,88.77 28.19,90.04 28.82,90.68 30.86,90.68 32.63,92.45 32.63,94.49 32.13,94.99 31.49,94.99 30.59,95.89 27.23,95.89 26.64,96.49 26.64,101.83 27.11,102.3 27.91,102.3 29.48,103.87 29.48,104.81 30.48,105.8 30.48,107.31 33.16,110 33.16,111.4 34.9,113.14 38.39,113.14 42.22,116.97 43.56,116.97 45.87,119.28 54.63,119.28 62.35,127 v1(62.35,129.28) ; v1(136.9,214.25) 136.4,214.75 136.4,233.12 138.55,235.27 138.55,238 138.93,238.38 139.82,238.38 140.84,239.39 143.97,239.39 144.77,238.89 145.28,238.38 146.17,238.38 146.55,238 146.55,235.77 148.8,233.53 149.69,233.53 150.89,232.33 151.79,232.33 152.3,232.84 152.3,234.02 153.68,235.4 159.74,235.4 160.31,234.83 164.14,234.83 167.83,231.14 172.72,231.14 v1(172.84,231.27)
H_PM_DOWN: length 167
  TOP w0.089: U6E1.AE2 102.11,157.91 102.14,157.94 102.14,160.86 102.03,160.97 102.03,164.26 102.13,164.36 102.13,164.43
  TOP w0.1: v1(136.9,211.96) 136.67,211.73 130,211.73 128.49,210.21 127.08,210.21 125.88,211.41 102.44,211.41 96.93,205.9 96.93,191.42 96.26,190.75 96.26,188.41 97.3,187.38 97.3,181.26 98.33,180.22 98.33,174.63 101.77,171.19 101.77,168.33 102.13,167.97 102.13,164.43 ; R4C6.2 R4C5.1 178.13,225.4 178.25,225.52 178.25,227.25 178.05,227.46 176.78,227.46 176.14,226.82 175.13,226.82 174.87,226.57 173.9,226.57 173.41,227.06 173.41,229.29 v1(173.48,229.36)
  BOTTOM w0.1: v1(136.9,211.96) 138.55,213.61 138.55,217.04 138.3,217.3 138.3,232.03 139.06,232.79 140.08,232.79 140.69,233.4 141.73,233.4 141.96,233.17 143.25,233.17 144.52,234.44 146.04,234.44 148.31,232.17 149.31,232.17 150.37,231.11 152.43,231.11 153.55,232.23 153.55,232.81 154.36,233.63 163.65,233.63 167.41,229.87 172.97,229.87 v1(173.48,229.36)
