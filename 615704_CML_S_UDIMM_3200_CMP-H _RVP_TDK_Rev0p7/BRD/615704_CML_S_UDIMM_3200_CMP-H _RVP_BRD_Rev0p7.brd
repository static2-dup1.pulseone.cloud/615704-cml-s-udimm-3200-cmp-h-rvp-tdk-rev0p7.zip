# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
PCIEX4_SJR_2X37_2EM_2M_MB
  round 0.254 hole 1.092 unplated: (-4.729,0.75)
  round 0.254 hole 1.6 unplated: (-4.729,-19.25)
  rect 1.549x0.305 smd: 1(0,0) 2(-6.452,-0.25) 3(0,-0.5) 4(-6.452,-0.75) 5(0,-1) 6(-6.452,-1.25) 7(0,-1.5) 8(-6.452,-1.75) 9(0,-2) 10(-6.452,-2.25) 11(0,-2.5) 12(-6.452,-2.75) 13(0,-3) 14(-6.452,-3.25) 15(0,-3.5) 16(-6.452,-3.75) 17(0,-4) 18(-6.452,-4.25) 19(0,-4.5) 20(-6.452,-4.75) 21(0,-5) 22(-6.452,-5.25) 23(0,-5.5) 24(-6.452,-5.75) 25(0,-6) 26(-6.452,-6.25) 27(0,-6.5) 28(-6.452,-6.75) 29(0,-7) 30(-6.452,-7.25) 31(0,-7.5) 32(-6.452,-7.75) 33(0,-8) 34(-6.452,-8.25) 35(0,-8.5) 36(-6.452,-8.75) 37(0,-9) 38(-6.452,-9.25) 39(0,-9.5) 40(-6.452,-9.75) 41(0,-10) 42(-6.452,-10.25) 43(0,-10.5) 44(-6.452,-10.75) 45(0,-11) 46(-6.452,-11.25) 47(0,-11.5) 48(-6.452,-11.75) 49(0,-12) 50(-6.452,-12.25) 51(0,-12.5) 52(-6.452,-12.75) 53(0,-13) 54(-6.452,-13.25) 55(0,-13.5) 56(-6.452,-13.75) 57(0,-14) 58(-6.452,-14.25) 67(0,-16.5) 68(-6.452,-16.75) 69(0,-17) 70(-6.452,-17.25) 71(0,-17.5) 72(-6.452,-17.75) 73(0,-18) 74(-6.452,-18.25) 75(0,-18.5)
  rect 2.743x1.194 smd: MP1(-0.229,1.1) MP2(-0.229,-19.6)
PWR_TPV_2X2_1M_420MA
  round 0.254 hole 2.997 unplated: (-5.04,4.7)
  rect 1.778x1.778 hole 1.397: 1(0,0)
  round 1.778 hole 1.397: 2(0,-4.2) 3(-5.5,0) 4(-5.5,-4.2)
PWR_TPV_2X4_1M_420MA
  round 0.254 hole 2.997 unplated: (-5.04,4.7)
  rect 1.905x1.905 hole 1.397: 1(0,0)
  round 1.905 hole 1.397: 2(0,-4.2) 3(0,-8.4) 4(0,-12.6) 5(-5.5,0) 6(-5.5,-4.2) 7(-5.5,-8.4) 8(-5.5,-12.6)
PWR_TPV_2X12_2M_420MA
  round 0.254 hole 2.997 unplated: (-5.04,4.7) (-5.04,-50.9)
  rect 1.778x1.778 hole 1.397: 1(0,0)
  round 1.778 hole 1.397: 2(0,-4.2) 3(0,-8.4) 4(0,-12.6) 5(0,-16.8) 6(0,-21) 7(0,-25.2) 8(0,-29.4) 9(0,-33.6) 10(0,-37.8) 11(0,-42) 12(0,-46.2) 13(-5.5,0) 14(-5.5,-4.2) 15(-5.5,-8.4) 16(-5.5,-12.6) 17(-5.5,-16.8) 18(-5.5,-21) 19(-5.5,-25.2) 20(-5.5,-29.4) 21(-5.5,-33.6) 22(-5.5,-37.8) 23(-5.5,-42) 24(-5.5,-46.2)
RJ45_SHLD_TJR_12P_2LED_2EM_2M_08IA
  round 0.254 hole 3.251 unplated: (6.604,-0.254) (6.604,-9.906)
  rect 1.27x1.27 hole 0.889: 1(0,0)
  round 1.27 hole 0.889: 2(0,-2.032) 3(0,-4.064) 4(0,-6.096) 5(0,-8.128) 6(0,-10.16) 7(-2.54,1.016) 8(-2.54,-1.016) 9(-2.54,-3.048) 10(-2.54,-7.112) 11(-2.54,-9.144) 12(-2.54,-11.176)
  round 1.524 hole 1.143: 17(10.414,2.438) 18(12.954,2.438) 19(10.414,-12.598) 20(12.954,-12.598)
  round 1.956 hole 1.575: MH1(6.604,3.708) MH2(6.604,-13.868)
SASHD_TJR_4X9_2EM_75MA
  round 0.6 hole 0.37: A1(0,0) A2(-1.4,-0.75) A3(-0.7,-1.5) A4(0,-2.25) A5(-1.4,-3) A6(-0.7,-3.75) A7(0,-4.5) A8(-1.4,-5.25) A9(-0.7,-6) B1(3.8,0) B2(2.4,-0.75) B3(3.1,-1.5) B4(3.8,-2.25) B5(2.4,-3) B6(3.1,-3.75) B7(3.8,-4.5) B8(2.4,-5.25) B9(3.1,-6) C1(7.6,0) C2(6.2,-0.75) C3(6.9,-1.5) C4(7.6,-2.25) C5(6.2,-3) C6(6.9,-3.75) C7(7.6,-4.5) C8(6.2,-5.25) C9(6.9,-6) D1(11.4,0) D2(10,-0.75) D3(10.7,-1.5) D4(11.4,-2.25) D5(10,-3) D6(10.7,-3.75) D7(11.4,-4.5) D8(10,-5.25) D9(10.7,-6)
  round 2.6 hole 2.2: MH1(-2.15,3) MH2(-2.15,-9)
SATA_SPR_1X22_2E_2M_IA
  round 0.254 hole 1.6 unplated: (3,0.716) (3,-32.471)
  rect 2.388x0.889 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(0,-5.08) 6(0,-6.35) 7(0,-7.62) 8(0,-13.975) 9(0,-15.245) 10(0,-16.515) 11(0.5,-17.785) 12(0,-19.055) 13(0,-20.325) 14(0,-21.595) 15(0,-22.865) 16(0,-24.135) 17(0,-25.405) 18(0,-26.675) 19(0.5,-27.945) 20(0,-29.215) 21(0,-30.485) 22(0,-31.755)
  oval 2.87x1.803 hole 2.083x1.016: M1(2.24,2.832) M2(2.24,-34.587)
SATA_TPV_1X7_2EM_MA
  rect 0.975x0.975 hole 0.6: 1(0,0)
  round 0.975 hole 0.6: 2(-1.055,1.5) 3(-2.755,1.5) 4(-3.81,0) 5(-4.865,1.5) 6(-6.565,1.5) 7(-7.62,0)
  round 1.725 hole 1.35: MH1(2.46,0) MH2(-10.37,1)
SC70_5_20X13MA
  rect 1.041x0.406 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(1.88,-1.3) 5(1.88,0)
SC70_6_20X13MA
  rect 1.016x0.406 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(1.905,-1.3) 5(1.905,-0.65) 6(1.905,0)
SC88_6_135X220_65MA
  rect 0.9x0.4 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(1.75,-1.3) 5(1.75,-0.65) 6(1.75,0)
SCCA8_32X16MA
  rect 0.8x0.4 smd: 1(-0.002,0) 2(-0.002,-0.8) 3(-0.002,-1.6) 4(-0.002,-2.4) 5(1.399,-2.4) 6(1.399,-1.6) 7(1.399,-0.8) 8(1.399,0)
SCH_MTG_NLX_N156_PCCG
  round 1.016 hole 3.962 unplated: (0,0)
  round 0.66 hole 0.356: 1(-1.88,4.028) 2(1.519,4.176) 3(4.028,1.88) 4(4.176,-1.519) 5(1.88,-4.028) 6(-1.519,-4.176) 7(-4.028,-1.88) 8(-4.176,1.519)
SCR28X19MA
  rect 1.3x1.6 smd: 1(0,0) 2(2.9,0)
SCR0603ME
  rect 0.225x0.325 smd: 1(0,0) 2(0.4,0)
SCR0603MF
  rect 0.225x0.325 smd: 1(0,0) 2(0.4,0)
SFB0402IA
  rect 0.508x0.508 smd: 1(0,0) 2(0.889,0)
SFB0603IA
  rect 0.889x0.762 smd: 1(0,0) 2(1.27,0)
SFB0603IB
  rect 0.94x0.94 smd: 1(0,0) 2(1.448,0)
SFB0805MA
  rect 1.016x1.27 smd: 1(0,0) 2(1.778,0)
SFB1608MB
  rect 0.9x0.95 smd: 1(0,0) 2(1.4,0)
SFU0603IB
  rect 0.889x0.991 smd: 1(0,0) 2(1.397,0)
SFU1206IA
  rect 1.448x1.803 smd: 1(0,0) 2(2.946,0)
SFU1206IE
  rect 1x1.8 smd: 1(0,0) 2(2.8,0)
SFU1812MA
  rect 1.3x3.3 smd: 1(0,0) 2(4.025,0)
SHDR_SPV_SHF_2X10_127MA
  rect 2.794x0.737 smd: 1(0,0) 2(4.064,0) 3(0,-1.27) 4(4.064,-1.27) 5(0,-2.54) 6(4.064,-2.54) 7(0,-3.81) 8(4.064,-3.81) 9(0,-5.08) 10(4.064,-5.08) 11(0,-6.35) 12(4.064,-6.35) 13(0,-7.62) 14(4.064,-7.62) 15(0,-8.89) 16(4.064,-8.89) 17(0,-10.16) 18(4.064,-10.16) 19(0,-11.43) 20(4.064,-11.43)
SLED_24357IA
  rect 1.143x2.286 smd: 1(0,0) 2(1.44,0) 3(2.88,0) 4(4.321,0) 5(5.761,0) 6(5.761,9.144) 7(4.321,9.144) 8(2.88,9.144) 9(1.44,9.144) 10(0,9.144)
SLEDR2012MA
  rect 0.89x1.27 smd: 1(0,0) 2(1.91,0)
SMC0201IA
  rect 0.33x0.305 smd: 1(0,0) 2(0.533,0)
SMC0402IA
  rect 0.508x0.508 smd: 1(0,0) 2(0.889,0)
SMC0402IB
  rect 0.737x0.559 smd: 1(0,0) 2(0.94,0)
SMC0402MA
  rect 0.508x0.508 smd: 1(0,0) 2(0.889,0)
SMC0402MC
  rect 0.5x0.7 smd: 1(0.007,0) 2(0.882,0)
SMC0603IA
  rect 0.889x0.762 smd: 1(0,0) 2(1.397,0)
SMC0603IB
  rect 0.889x0.94 smd: 1(0,0) 2(1.397,0)
SMC0603ID
  rect 0.889x0.991 smd: 1(0,0) 2(1.397,0)
SMC0805IA
  rect 1.016x1.27 smd: 1(0,0) 2(1.778,0)
SMC0805MA
  rect 1.016x1.397 smd: 1(0,0) 2(1.778,0)
SMC1005MB
  rect 0.5x0.55 smd: 1(0,0) 2(0.875,0)
SMC1206IA
  rect 1.016x1.524 smd: 1(0,0) 2(2.794,0)
SMC7343_TANT_PMC
  rect 2.286x2.794 smd: 1(0,0) 2(5.816,0)
SMI4_13X10MA
  rect 0.575x0.35 smd: 1(0,0) 2(1.275,0) 3(1.275,-0.55) 4(0,-0.55)
SMI4_50X65MA
  rect 0.225x0.275 smd: 1(0,0) 2(0.425,0) 3(0.425,-0.525) 4(0,-0.525)
SMI4_79X47IA
  rect 0.889x0.508 smd: 1(0,0) 2(0,-0.787) 3(1.651,-0.787) 4(1.651,0)
SMI4_0605MA
  rect 0.3x0.2 smd: 1(0,0) 2(0,-0.4) 3(0.5,-0.4) 4(0.5,0)
SMI22X18MA
  rect 1.015x1.4 smd: 1(0,0) 2(1.78,0)
SMI26X25IA
  rect 1.549x5.613 smd: 1(0,0) 2(4.089,0)
SMI40X40MA
  rect 0.98x3.7 smd: 1(0,0) 2(2.37,0)
SMI40X40MB
  rect 1.2x3.7 smd: 1(0,0) 2(2.8,0)
SMI53X55MB
  rect 1.3x4.66 smd: 1(0,0) 2(3.36,0)
SMI2012MB
  rect 0.914x1.499 smd: 1(0,0) 2(1.676,0)
SMI2020MA
  rect 0.65x2 smd: 1(0,0) 2(1.35,0)
SMI2520MD
  rect 0.965x2.2 smd: 1(0,0) 2(2.235,0)
SMI_S29IA
  rect 1.956x6.502 smd: 1(0,0) 2(4.826,0)
SMI_S68_MA
  rect 2.67x3.73 smd: 1(0,0) 2(5.07,0)
SMR4_0603ID_RVP
  rect 0.94x1.016 smd: 1(0,0) 2(1.448,0)
  round 0.508 hole 0.254: 3(0.191,0) 4(1.257,0)
SMR4_0805IB_RVP
  rect 1.27x1.524 smd: 1(0,0) 2(1.778,0)
  round 0.508 hole 0.254: 3(0.356,0) 4(1.422,0)
SMR4_0805IC_RVP
  rect 0.889x1.524 smd: 1(0,0) 2(1.651,0)
  round 0.508 hole 0.254: 3(0.165,0) 4(1.486,0)
SMR4_1206IB_RVP
  rect 1.245x1.854 smd: 1(0,0) 2(2.667,0)
  round 0.508 hole 0.254: 3(0.343,0) 4(2.324,0)
SMR4_2512IG_RVP
  rect 2.921x3.429 smd: 1(0,0) 2(4.191,0)
  round 0.508 hole 0.254: 3(1.181,0) 4(3.01,0)
SMR0201IA
  rect 0.33x0.305 smd: 1(0,0) 2(0.533,0)
SMR0402IA
  rect 0.508x0.508 smd: 1(0,0) 2(0.889,0)
SMR0402IC
  rect 0.508x0.559 smd: 1(0,0) 2(0.889,0)
SMR0603A
  rect 0.889x0.762 smd: 1(0,0) 2(1.397,0)
SMR0603IA
  rect 0.889x0.762 smd: 1(0,0) 2(1.397,0)
SMR0603IB
  rect 0.94x0.94 smd: 1(0,0) 2(1.448,0)
SMR0603IC
  rect 0.762x1.016 smd: 1(0,0) 2(1.27,0)
SMR0603MA
  rect 0.889x0.762 smd: 1(0,0) 2(1.397,0)
SMR0805IA
  rect 1.016x1.27 smd: 1(0,0) 2(1.778,0)
SMR0805IC
  rect 0.889x1.524 smd: 1(0,0) 2(1.651,0)
SMR1005MA
  rect 0.5x0.55 smd: 1(0,0) 2(0.875,0)
SMR1005MD
  rect 0.5x0.55 smd: 1(0,0) 2(0.875,0)
SMR1206A
  rect 1.016x1.524 smd: 1(0,0) 2(2.794,0)
SMR1206IA
  rect 1.016x1.524 smd: 1(0,0) 2(2.794,0)
SMR1206IB
  rect 1.245x1.854 smd: 1(0,0) 2(2.667,0)
SMR2512A
  rect 1.905x3.302 smd: 1(0,0) 2(6.477,0)
SMRT0402IA
  rect 0.508x0.508 smd: 1(0,0) 2(0,-0.889)
SMY4_25X20MA
  rect 1x1.2 smd: 1(0,0) 2(0,-1.7) 3(1.3,-1.7) 4(1.3,0)
SMY4_32X25MA
  rect 1.194x1.397 smd: 1(0,0) 2(0,-2.197) 3(1.6,-2.197) 4(1.6,0)
SMY32X15MA
  rect 0.991x1.803 smd: 1(0,0) 2(2.489,0)
SOD123IB
  rect 1.041x0.965 smd: 1(0,0) 2(3.327,0)
SOD123MA
  rect 1.041x0.965 smd: 1(0,0) 2(3.33,0)
SOD523MC
  rect 0.525x0.45 smd: 1(0,0) 2(1.425,0)
SOD962MA
  rect 0.2x0.3 smd: 1(0,0) 2(0.4,0)
SOI8_19X15_50IA
  rect 2.286x0.635 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(4.572,-3.81) 6(4.572,-2.54) 7(4.572,-1.27) 8(4.572,0)
SOI8_49X39_127MA
  rect 1.575x0.635 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(5.131,-3.81) 6(5.131,-2.54) 7(5.131,-1.27) 8(5.131,0)
SOI8_49X39_127MB
  rect 1.575x0.635 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(5.125,-3.81) 6(5.125,-2.54) 7(5.125,-1.27) 8(5.125,0)
SOI8_S52_127MB
  rect 1.52x0.635 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(7.11,-3.81) 6(7.11,-2.54) 7(7.11,-1.27) 8(7.11,0)
SOI16_40X30_05IA
  rect 2.032x0.635 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(0,-5.08) 6(0,-6.35) 7(0,-7.62) 8(0,-8.89) 9(9.144,-8.89) 10(9.144,-7.62) 11(9.144,-6.35) 12(9.144,-5.08) 13(9.144,-3.81) 14(9.144,-2.54) 15(9.144,-1.27) 16(9.144,0)
SOT23_5MB
  rect 1.397x0.508 smd: 1(0,0) 2(0,-0.95) 3(0,-1.9) 4(2.667,-1.9) 5(2.667,0)
SOT23_5ME
  rect 1.145x0.635 smd: 1(0,0) 2(0,-0.95) 3(0,-1.9) 4(2.355,-1.9) 5(2.355,0)
SOT23_5MG
  rect 1.145x0.635 smd: 1(0,0) 2(0,-0.95) 3(0,-1.9) 4(2.355,-1.9) 5(2.355,0)
SOT23_6MI
  rect 1.145x0.635 smd: 1(0,0) 2(0,-0.95) 3(0,-1.9) 4(2.355,-1.9) 5(2.355,-0.95) 6(2.355,0)
SOT23IA
  rect 1.143x0.61 smd: 1(0,0) 2(0,-1.905) 3(2.159,-0.953)
SOT23MA
  rect 1.143x0.508 smd: 1(0,0) 2(0,-1.905) 3(2.159,-0.953)
SOT23MH
  rect 0.975x0.8 smd: 1(0,0) 2(0,-1.915) 3(1.975,-0.958)
SOT23MJ
  rect 0.975x0.8 smd: 1(0,0) 2(0,-1.915) 3(1.975,-0.958)
SOT363MB
  rect 1x0.4 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(1.9,-1.3) 5(1.9,-0.65) 6(1.9,0)
SOT457MA
  rect 1.219x0.635 smd: 1(0,0) 2(0,-0.95) 3(0,-1.9) 4(2.286,-1.9) 5(2.286,-0.95) 6(2.286,0)
SOT563MB
  rect 0.65x0.3 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(1.525,-1) 5(1.525,-0.5) 6(1.525,0)
SOT723MA
  rect 0.66x0.406 smd: 1(0,0) 2(0,-0.8)
  rect 0.66x0.508 smd: 3(1.36,-0.4)
SSOP6_20X13_65MA
  rect 1.016x0.406 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(1.905,-1.3) 5(1.905,-0.65) 6(1.905,0)
SSOP8_23X20_50MA
  rect 0.762x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(2.95,-1.5) 6(2.95,-1) 7(2.95,-0.5) 8(2.95,0)
SSOP8_290X315_65MA
  rect 1.175x0.4 smd: 1(-1.791,0.975) 2(-1.791,0.325) 3(-1.791,-0.325) 4(-1.791,-0.975) 5(1.791,-0.975) 6(1.791,-0.325) 7(1.791,0.325) 8(1.791,0.975)
SSOP14_4P4_65MA
  rect 1.778x0.381 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(0,-2.6) 6(0,-3.25) 7(0,-3.9) 8(5.842,-3.9) 9(5.842,-3.25) 10(5.842,-2.6) 11(5.842,-1.95) 12(5.842,-1.3) 13(5.842,-0.65) 14(5.842,0)
SSOP16_199X157_25IA
  rect 2.159x0.381 smd: 1(0,0) 2(0,-0.635) 3(0,-1.27) 4(0,-1.905) 5(0,-2.54) 6(0,-3.175) 7(0,-3.81) 8(0,-4.445) 9(5.461,-4.445) 10(5.461,-3.81) 11(5.461,-3.175) 12(5.461,-2.54) 13(5.461,-1.905) 14(5.461,-1.27) 15(5.461,-0.635) 16(5.461,0)
SSW4_VP37X31_145MA
  rect 1.15x1.05 smd: 1(0,0) 2(3.35,0) 3(0,-1.45) 4(3.35,-1.45)
SSW4VPS244_157IA
  rect 3.302x0.991 smd: 1(0,0) 2(6.299,0) 3(0,-4.013) 4(6.299,-4.013)
SSW8_VD63X45_127MA
  rect 1.25x0.76 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(6.15,-3.81) 6(6.15,-2.54) 7(6.15,-1.27) 8(6.15,0)
STR0402MA
  rect 0.5x0.55 smd: 1(0,0) 2(0.875,0)
TK0_BGA337_TITAN_RIDGE_MA
  round 0.25 smd: A1(-5.06,5.06) A23(5.06,5.06) AA2(-4.6,-4.14) AA22(4.6,-4.14) AB2(-4.6,-4.6) AB3(-4.14,-4.6) AB4(-3.68,-4.6) AB5(-3.22,-4.6) AB6(-2.76,-4.6) AB7(-2.3,-4.6) AB8(-1.84,-4.6) AB9(-1.38,-4.6) AB10(-0.92,-4.6) AB11(-0.46,-4.6) AB12(0,-4.6) AB13(0.46,-4.6) AB14(0.92,-4.6) AB15(1.38,-4.6) AB16(1.84,-4.6) AB17(2.3,-4.6) AB18(2.76,-4.6) AB19(3.22,-4.6) AB20(3.68,-4.6) AB21(4.14,-4.6) AB22(4.6,-4.6) AC1(-5.06,-5.06) AC23(5.06,-5.06) B2(-4.6,4.6) B3(-4.14,4.6) B4(-3.68,4.6) B5(-3.22,4.6) B6(-2.76,4.6) B7(-2.3,4.6) B8(-1.84,4.6) B9(-1.38,4.6) B10(-0.92,4.6) B11(-0.46,4.6) B12(0,4.6) B13(0.46,4.6) B14(0.92,4.6) B15(1.38,4.6) B16(1.84,4.6) B17(2.3,4.6) B18(2.76,4.6) B19(3.22,4.6) B20(3.68,4.6) B21(4.14,4.6) B22(4.6,4.6) C2(-4.6,4.14) C22(4.6,4.14) D2(-4.6,3.68) D4(-3.9,3.9) D5(-3.25,3.9) D6(-2.6,3.9) D8(-1.95,3.9) D9(-1.3,3.9) D11(-0.65,3.9) D12(0,3.9) D13(0.65,3.9) D15(1.3,3.9) D16(1.95,3.9) D18(2.6,3.9) D19(3.25,3.9) D20(3.9,3.9) D22(4.6,3.68) E2(-4.6,3.22) E4(-3.9,3.25) E5(-3.25,3.25) E6(-2.6,3.25) E8(-1.95,3.25) E9(-1.3,3.25) E11(-0.65,3.25) E12(0,3.25) E13(0.65,3.25) E15(1.3,3.25) E16(1.95,3.25) E18(2.6,3.25) E19(3.25,3.25) E20(3.9,3.25) E22(4.6,3.22) F2(-4.6,2.76) F4(-3.9,2.6) F5(-3.25,2.6) F6(-2.6,2.6) F8(-1.95,2.6) F9(-1.3,2.6) F11(-0.65,2.6) F12(0,2.6) F13(0.65,2.6) F15(1.3,2.6) F16(1.95,2.6) F18(2.6,2.6) F19(3.25,2.6) F20(3.9,2.6) F22(4.6,2.76) G2(-4.6,2.3) G22(4.6,2.3) H2(-4.6,1.84) H4(-3.9,1.95) H5(-3.25,1.95) H6(-2.6,1.95) H8(-1.95,1.95) H9(-1.3,1.95) H11(-0.65,1.95) H12(0,1.95) H13(0.65,1.95) H15(1.3,1.95) H16(1.95,1.95) H18(2.6,1.95) H19(3.25,1.95) H20(3.9,1.95) H22(4.6,1.84) J2(-4.6,1.38) J4(-3.9,1.3) J5(-3.25,1.3) J6(-2.6,1.3) J8(-1.95,1.3) J9(-1.3,1.3) J11(-0.65,1.3) J12(0,1.3) J13(0.65,1.3) J15(1.3,1.3) J16(1.95,1.3) J18(2.6,1.3) J19(3.25,1.3) J20(3.9,1.3) J22(4.6,1.38) K2(-4.6,0.92) K22(4.6,0.92) L2(-4.6,0.46) L4(-3.9,0.65) L5(-3.25,0.65) L6(-2.6,0.65) L8(-1.95,0.65) L9(-1.3,0.65) L11(-0.65,0.65) L12(0,0.65) L13(0.65,0.65) L15(1.3,0.65) L16(1.95,0.65) L18(2.6,0.65) L19(3.25,0.65) L20(3.9,0.65) L22(4.6,0.46) M2(-4.6,0) M4(-3.9,0) M5(-3.25,0) M6(-2.6,0) M8(-1.95,0) M9(-1.3,0) M11(-0.65,0) M12(0,0) M13(0.65,0) M15(1.3,0) M16(1.95,0) M18(2.6,0) M19(3.25,0) M20(3.9,0) M22(4.6,0) N2(-4.6,-0.46) N4(-3.9,-0.65) N5(-3.25,-0.65) N6(-2.6,-0.65) N8(-1.95,-0.65) N9(-1.3,-0.65) N11(-0.65,-0.65) N12(0,-0.65) N13(0.65,-0.65) N15(1.3,-0.65) N16(1.95,-0.65) N18(2.6,-0.65) N19(3.25,-0.65) N20(3.9,-0.65) N22(4.6,-0.46) P2(-4.6,-0.92) P22(4.6,-0.92) R2(-4.6,-1.38) R4(-3.9,-1.3) R5(-3.25,-1.3) R6(-2.6,-1.3) R8(-1.95,-1.3) R9(-1.3,-1.3) R11(-0.65,-1.3) R12(0,-1.3) R13(0.65,-1.3) R15(1.3,-1.3) R16(1.95,-1.3) R18(2.6,-1.3) R19(3.25,-1.3) R20(3.9,-1.3) R22(4.6,-1.38) T2(-4.6,-1.84) T4(-3.9,-1.95) T5(-3.25,-1.95) T6(-2.6,-1.95) T8(-1.95,-1.95) T9(-1.3,-1.95) T11(-0.65,-1.95) T12(0,-1.95) T13(0.65,-1.95) T15(1.3,-1.95) T16(1.95,-1.95) T18(2.6,-1.95) T19(3.25,-1.95) T20(3.9,-1.95) T22(4.6,-1.84) U2(-4.6,-2.3) U22(4.6,-2.3) V2(-4.6,-2.76) V4(-3.9,-2.6) V5(-3.25,-2.6) V6(-2.6,-2.6) V8(-1.95,-2.6) V9(-1.3,-2.6) V11(-0.65,-2.6) V12(0,-2.6) V13(0.65,-2.6) V15(1.3,-2.6) V16(1.95,-2.6) V18(2.6,-2.6) V19(3.25,-2.6) V20(3.9,-2.6) V22(4.6,-2.76) W2(-4.6,-3.22) W4(-3.9,-3.25) W5(-3.25,-3.25) W6(-2.6,-3.25) W8(-1.95,-3.25) W9(-1.3,-3.25) W11(-0.65,-3.25) W12(0,-3.25) W13(0.65,-3.25) W15(1.3,-3.25) W16(1.95,-3.25) W18(2.6,-3.25) W19(3.25,-3.25) W20(3.9,-3.25) W22(4.6,-3.22) Y2(-4.6,-3.68) Y4(-3.9,-3.9) Y5(-3.25,-3.9) Y6(-2.6,-3.9) Y8(-1.95,-3.9) Y9(-1.3,-3.9) Y11(-0.65,-3.9) Y12(0,-3.9) Y13(0.65,-3.9) Y15(1.3,-3.9) Y16(1.95,-3.9) Y18(2.6,-3.9) Y19(3.25,-3.9) Y20(3.9,-3.9) Y22(4.6,-3.68)
  oval 0.178x0.33 smd: A2(-4.6,5.06) A3(-4.14,5.06) A4(-3.68,5.06) A5(-3.22,5.06) A6(-2.76,5.06) A7(-2.3,5.06) A8(-1.84,5.06) A9(-1.38,5.06) A10(-0.92,5.06) A11(-0.46,5.06) A12(0,5.06) A13(0.46,5.06) A14(0.92,5.06) A15(1.38,5.06) A16(1.84,5.06) A17(2.3,5.06) A18(2.76,5.06) A19(3.22,5.06) A20(3.68,5.06) A21(4.14,5.06) A22(4.6,5.06) AC2(-4.6,-5.06) AC3(-4.14,-5.06) AC4(-3.68,-5.06) AC5(-3.22,-5.06) AC6(-2.76,-5.06) AC7(-2.3,-5.06) AC8(-1.84,-5.06) AC9(-1.38,-5.06) AC10(-0.92,-5.06) AC11(-0.46,-5.06) AC12(0,-5.06) AC13(0.46,-5.06) AC14(0.92,-5.06) AC15(1.38,-5.06) AC16(1.84,-5.06) AC17(2.3,-5.06) AC18(2.76,-5.06) AC19(3.22,-5.06) AC20(3.68,-5.06) AC21(4.14,-5.06) AC22(4.6,-5.06)
  oval 0.33x0.178 smd: AA1(-5.06,-4.14) AA23(5.06,-4.14) AB1(-5.06,-4.6) AB23(5.06,-4.6) B1(-5.06,4.6) B23(5.06,4.6) C1(-5.06,4.14) C23(5.06,4.14) D1(-5.06,3.68) D23(5.06,3.68) E1(-5.06,3.22) E23(5.06,3.22) F1(-5.06,2.76) F23(5.06,2.76) G1(-5.06,2.3) G23(5.06,2.3) H1(-5.06,1.84) H23(5.06,1.84) J1(-5.06,1.38) J23(5.06,1.38) K1(-5.06,0.92) K23(5.06,0.92) L1(-5.06,0.46) L23(5.06,0.46) M1(-5.06,0) M23(5.06,0) N1(-5.06,-0.46) N23(5.06,-0.46) P1(-5.06,-0.92) P23(5.06,-0.92) R1(-5.06,-1.38) R23(5.06,-1.38) T1(-5.06,-1.84) T23(5.06,-1.84) U1(-5.06,-2.3) U23(5.06,-2.3) V1(-5.06,-2.76) V23(5.06,-2.76) W1(-5.06,-3.22) W23(5.06,-3.22) Y1(-5.06,-3.68) Y23(5.06,-3.68)
TK0_LCC5_S3100_650_DF2450X2280_MA_VR
  rect 0.5x0.35 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975)
  custom 0.57x0.57 smd: 5(0,0)
TK0_LCC8_1050X1250_400_MA_VR
  rect 0.38x0.19 smd: 1(-0.46,0.4) 3(-0.46,-0.4) 5(0.46,-0.4) 6(0.46,0) 7(0.46,0.4)
  rect 0.505x0.19 smd: 2(-0.398,0)
  rect 0.19x0.38 smd: 4(0,-0.56) 8(0,0.56)
TK0_LCC10_1050X2550_500_MA
  custom 0.055x0.055 smd: 1(-0.362,1) 2(-0.362,0.5) 4(-0.362,-0.5) 5(-0.362,-1) 6(0.362,-1) 7(0.362,-0.5) 9(0.362,0.5) 10(0.362,1)
  rect 1.3x0.4 smd: 3(0,0)
TK0_LCC10_S3050_DF1625X2475_500_MA
  rect 0.61x0.264 smd: 1(-1.345,1) 2(-1.345,0.5) 3(-1.345,0) 4(-1.345,-0.5) 5(-1.345,-1) 6(1.345,-1) 7(1.345,-0.5) 8(1.345,0) 9(1.345,0.5) 10(1.345,1)
  rect 1.625x2.475 smd: 11(0,0)
TK0_LCC16_S3050_DFS1525_500_MA
  rect 0.61x0.264 smd: 1(-1.345,0.75) 2(-1.345,0.25) 3(-1.345,-0.25) 4(-1.345,-0.75) 9(1.345,-0.75) 10(1.345,-0.25) 11(1.345,0.25) 12(1.345,0.75)
  rect 0.264x0.61 smd: 5(-0.75,-1.345) 6(-0.25,-1.345) 7(0.25,-1.345) 8(0.75,-1.345) 13(0.75,1.345) 14(0.25,1.345) 15(-0.25,1.345) 16(-0.75,1.345)
  rect 1.525x1.525 smd: 17(0,0)
TK0_LCC28_S4100_400_DFS2400_MA
  rect 0.638x0.22 smd: 1(-1.845,1.2) 2(-1.845,0.8) 3(-1.845,0.4) 4(-1.845,0) 5(-1.845,-0.4) 6(-1.845,-0.8) 7(-1.845,-1.2) 15(1.845,-1.2) 16(1.845,-0.8) 17(1.845,-0.4) 18(1.845,0) 19(1.845,0.4) 20(1.845,0.8) 21(1.845,1.2)
  rect 0.22x0.638 smd: 8(-1.2,-1.845) 9(-0.8,-1.845) 10(-0.4,-1.845) 11(0,-1.845) 12(0.4,-1.845) 13(0.8,-1.845) 14(1.2,-1.845) 22(1.2,1.845) 23(0.8,1.845) 24(0.4,1.845) 25(0,1.845) 26(-0.4,1.845) 27(-0.8,1.845) 28(-1.2,1.845)
  rect 2.4x2.4 smd: 29(0,0)
TK0_LCC40_6100X4100_400_DF4700X2700_MA
  custom 0.055x0.055 smd: 1(-2.857,1.4) 2(-2.857,1) 3(-2.857,0.6) 4(-2.857,0.2) 5(-2.857,-0.2) 6(-2.857,-0.6) 7(-2.857,-1) 8(-2.857,-1.4) 9(-2.2,-1.857) 10(-1.8,-1.857) 11(-1.4,-1.857) 12(-1,-1.857) 13(-0.6,-1.857) 14(-0.2,-1.857) 15(0.2,-1.857) 16(0.6,-1.857) 17(1,-1.857) 18(1.4,-1.857) 19(1.8,-1.857) 20(2.2,-1.857) 21(2.857,-1.4) 22(2.857,-1) 23(2.857,-0.6) 24(2.857,-0.2) 25(2.857,0.2) 26(2.857,0.6) 27(2.857,1) 28(2.857,1.4) 29(2.2,1.857) 30(1.8,1.857) 31(1.4,1.857) 32(1,1.857) 33(0.6,1.857) 34(0.2,1.857) 35(-0.2,1.857) 36(-0.6,1.857) 37(-1,1.857) 38(-1.4,1.857) 39(-1.8,1.857) 40(-2.2,1.857)
  rect 4.7x2.7 smd: 41(0,0)
TK0_LCC42_3600X9100_500_DF2050X7550_MA
  custom 0.068x0.068 smd: 1(-1.585,4) 2(-1.585,3.5) 3(-1.585,3) 4(-1.585,2.5) 5(-1.585,2) 6(-1.585,1.5) 7(-1.585,1) 8(-1.585,0.5) 9(-1.585,0) 10(-1.585,-0.5) 11(-1.585,-1) 12(-1.585,-1.5) 13(-1.585,-2) 14(-1.585,-2.5) 15(-1.585,-3) 16(-1.585,-3.5) 17(-1.585,-4) 18(-0.75,-4.335) 19(-0.25,-4.335) 20(0.25,-4.335) 21(0.75,-4.335) 22(1.585,-4) 23(1.585,-3.5) 24(1.585,-3) 25(1.585,-2.5) 26(1.585,-2) 27(1.585,-1.5) 28(1.585,-1) 29(1.585,-0.5) 30(1.585,0) 31(1.585,0.5) 32(1.585,1) 33(1.585,1.5) 34(1.585,2) 35(1.585,2.5) 36(1.585,3) 37(1.585,3.5) 38(1.585,4) 39(0.75,4.335) 40(0.25,4.335) 41(-0.25,4.335) 42(-0.75,4.335)
  rect 2.05x7.55 smd: 43(0,0)
TK0_LCC60_S7100_DFS5700_400_MA
  custom 0.055x0.055 smd: 1(-3.357,2.8) 2(-3.357,2.4) 3(-3.357,2) 4(-3.357,1.6) 5(-3.357,1.2) 6(-3.357,0.8) 7(-3.357,0.4) 8(-3.357,0) 9(-3.357,-0.4) 10(-3.357,-0.8) 11(-3.357,-1.2) 12(-3.357,-1.6) 13(-3.357,-2) 14(-3.357,-2.4) 15(-3.357,-2.8) 16(-2.8,-3.357) 17(-2.4,-3.357) 18(-2,-3.357) 19(-1.6,-3.357) 20(-1.2,-3.357) 21(-0.8,-3.357) 22(-0.4,-3.357) 23(0,-3.357) 24(0.4,-3.357) 25(0.8,-3.357) 26(1.2,-3.357) 27(1.6,-3.357) 28(2,-3.357) 29(2.4,-3.357) 30(2.8,-3.357) 31(3.357,-2.8) 32(3.357,-2.4) 33(3.357,-2) 34(3.357,-1.6) 35(3.357,-1.2) 36(3.357,-0.8) 37(3.357,-0.4) 38(3.357,0) 39(3.357,0.4) 40(3.357,0.8) 41(3.357,1.2) 42(3.357,1.6) 43(3.357,2) 44(3.357,2.4) 45(3.357,2.8) 46(2.8,3.357) 47(2.4,3.357) 48(2,3.357) 49(1.6,3.357) 50(1.2,3.357) 51(0.8,3.357) 52(0.4,3.357) 53(0,3.357) 54(-0.4,3.357) 55(-0.8,3.357) 56(-1.2,3.357) 57(-1.6,3.357) 58(-2,3.357) 59(-2.4,3.357) 60(-2.8,3.357)
  rect 5.7x5.7 smd: 61(0,0)
TK0_SHDR_SHLD_SJV_1X44_11EM_2M_500_MA
  round 0.25 hole 0.7 unplated: (0,11.625)
  round 0.25 hole 1 unplated: (0,-11.625)
  rect 2.5x0.25 smd: 1(1.75,10.75) 2(1.75,10.25) 3(1.75,9.75) 4(1.75,9.25) 5(1.75,8.75) 6(1.75,8.25) 7(1.75,7.75) 8(1.75,7.25) 9(1.75,6.75) 10(1.75,6.25) 11(1.75,5.75) 12(1.75,5.25) 13(1.75,4.75) 14(1.75,4.25) 15(1.75,3.75) 16(1.75,3.25) 17(1.75,2.75) 18(1.75,2.25) 19(1.75,1.75) 20(1.75,1.25) 21(1.75,0.75) 22(1.75,0.25) 23(1.75,-0.25) 24(1.75,-0.75) 25(1.75,-1.25) 26(1.75,-1.75) 27(1.75,-2.25) 28(1.75,-2.75) 29(1.75,-3.25) 30(1.75,-3.75) 31(1.75,-4.25) 32(1.75,-4.75) 33(1.75,-5.25) 34(1.75,-5.75) 35(1.75,-6.25) 36(1.75,-6.75) 37(1.75,-7.25) 38(1.75,-7.75) 39(1.75,-8.25) 40(1.75,-8.75) 41(1.75,-9.25) 42(1.75,-9.75) 43(1.75,-10.25) 44(1.75,-10.75)
  rect 1.4x2.1 smd: MH1(2.3,12.4) MH2(-2.3,12.4) MH10(-2.3,-12.4) MH11(2.3,-12.4)
  rect 1.4x1.1 smd: MH3(-2.3,9.75) MH4(-2.3,6.75) MH5(-2.3,3.75) MH6(-2.3,0) MH7(-2.3,-3.75) MH8(-2.3,-6.75) MH9(-2.3,-9.75)
TK0_SLED4_3400X2900_MA_VR
  rect 0.75x1.1 smd: 1(1.425,0.7) 2(-1.425,0.7) 3(1.425,-0.7) 4(-1.425,-0.7)
TK0_SM0805_2200X1450_MC
  rect 1.15x1.47 smd: 1(-0.835,0) 2(0.835,0)
TK0_SM_7300X6800_MC
  rect 2.5x3.3 smd: 1(-2.8,0) 2(2.8,0)
TK0_SMC7343_7500X4500_ALEL_MA
  rect 1.996x2.429 smd: 1(-3.11,0) 2(3.11,0)
TK0_SMY4_2600X3300_MF
  rect 1.002x1.102 smd: 1(-0.855,1.155) 2(-0.855,-1.155) 3(0.855,-1.155) 4(0.855,1.155)
TK0_SOS4_2600X3300_MA
  rect 0.852x1.102 smd: 1(-0.93,1.155) 2(-0.93,-1.155) 3(0.93,-1.155) 4(0.93,1.155)
TP_C25
  round 0.635 smd: 1(0,0)
TP_C29P14A51_IA
  round 0.737 hole 0.356: 1(0,0)
TPS16
  rect 0.406x0.406 smd: 1(0,0)
TSOT23_8_29X16_65MB
  rect 1.125x0.45 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(2.375,-1.95) 6(2.375,-1.3) 7(2.375,-0.65) 8(2.375,0)
TSSOP5_21X13_65MA
  rect 1.27x0.305 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(2.286,-1.3) 5(2.286,0)
TSSOP8_S30_65MA
  rect 1.778x0.457 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(4.572,-1.95) 6(4.572,-1.3) 7(4.572,-0.65) 8(4.572,0)
TSSOP16_50X44_65MA
  rect 1.778x0.305 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(0,-2.6) 6(0,-3.25) 7(0,-3.9) 8(0,-4.55) 9(5.842,-4.55) 10(5.842,-3.9) 11(5.842,-3.25) 12(5.842,-2.6) 13(5.842,-1.95) 14(5.842,-1.3) 15(5.842,-0.65) 16(5.842,0)
TSSOP24_78X44_65MA
  rect 2.032x0.305 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(0,-2.6) 6(0,-3.25) 7(0,-3.9) 8(0,-4.55) 9(0,-5.2) 10(0,-5.85) 11(0,-6.5) 12(0,-7.15) 13(5.842,-7.15) 14(5.842,-6.5) 15(5.842,-5.85) 16(5.842,-5.2) 17(5.842,-4.55) 18(5.842,-3.9) 19(5.842,-3.25) 20(5.842,-2.6) 21(5.842,-1.95) 22(5.842,-1.3) 23(5.842,-0.65) 24(5.842,0)
unnamed#2
  round 4 hole 3.175 unplated: (0,0)
unnamed#3
  round 1.61 hole 1.61 unplated: (-4.865,4.862) (-4.865,-4.862) (4.86,4.862) (4.86,-4.862)
  round 0.85 hole 0.85 unplated: (-2.865,4.862) (1.86,-4.862)
unnamed#4
  round 0 smd: 1(0,0)
USB3_SHLD_TJR_26P_6EM_200MA
  rect 1.075x1.075 hole 0.7: 11(0,0)
  round 1.075 hole 0.7: 12(2.5,0) 13(4.5,0) 14(7,0) 15(7.5,1.5) 16(5.5,1.5) 17(3.5,1.5) 18(1.5,1.5) 19(-0.5,1.5) 21(0,3.2) 22(2.5,3.2) 23(4.5,3.2) 24(7,3.2) 25(7.5,4.7) 26(5.5,4.7) 27(3.5,4.7) 28(1.5,4.7) 29(-0.5,4.7) 31(0,6.4) 32(2.5,6.4) 33(4.5,6.4) 34(7,6.4) 35(0,9.6) 36(2.5,9.6) 37(4.5,9.6) 38(7,9.6)
  oval 1.575x2.675 hole 1.2x2.3: MH1(-2.9,9.18) MH2(9.9,9.18)
  round 2.675 hole 2.3: MH3(-3.07,3.68) MH4(10.07,3.68) MH5(-3.07,-2) MH6(10.07,-2)
USB3A_SHIELD_TJV_9P_4EM_200MA
  rect 1.4x1.4 hole 0.8: 1(0,0)
  round 1.4 hole 0.8: 2(0,-2.5) 3(0,-4.5) 4(0,-7) 5(2.5,-7.5) 6(2.5,-5.5) 7(2.5,-3.5) 8(2.5,-1.5) 9(2.5,0.5)
  oval 3.3x1.4 hole 2.7x0.8: MH1(-1,2.9) MH2(-1,-9.9)
  oval 2.8x1.4 hole 2.2x0.8: MH3(3,-9.9) MH4(3,2.9)
USB3P1_MPV_2X10_6EM_2M_80MA
  round 0.25 hole 1.15 unplated: (-2.5,1.025)
  round 0.254 hole 0.85 unplated: (-2.5,-8.625)
  round 0.991 hole 0.61: MH1(1.78,-2.4) MH2(1.78,-4.8) MH3(-6.78,-5.2) MH4(-6.78,-2.8)
  oval 2.6x1 hole 2x0.4: MH5(-2.5,2.625) MH6(-2.5,-10.225)
  rect 1.35x0.45 smd: P1(0,0) P2(0,-0.8) P3(0,-1.6) P4(0,-2.4) P5(0,-3.2) P6(0,-4) P7(0,-4.8) P8(0,-5.6) P9(0,-6.4) P10(0,-7.2) P11(-5,-7.6) P12(-5,-6.8) P13(-5,-6) P14(-5,-5.2) P15(-5,-4.4) P16(-5,-3.6) P17(-5,-2.8) P18(-5,-2) P19(-5,-1.2) P20(-5,-0.4)
USB3P1_MPV_2X10_6EM_2M_80MB
  round 0.25 hole 1.15 unplated: (-2.5,1.325)
  round 0.254 hole 0.85 unplated: (-2.5,-8.925)
  round 1 hole 0.7: MH1(1.78,-2.4) MH2(1.78,-4.8) MH3(-6.78,-5.2) MH4(-6.78,-2.8)
  oval 2.6x1 hole 2x0.4: MH5(-2.5,2.625) MH6(-2.5,-10.225)
  rect 1.35x0.45 smd: P1(0,0) P2(0,-0.8) P3(0,-1.6) P4(0,-2.4) P5(0,-3.2) P6(0,-4) P7(0,-4.8) P8(0,-5.6) P9(0,-6.4) P10(0,-7.2) P11(-5,-7.6) P12(-5,-6.8) P13(-5,-6) P14(-5,-5.2) P15(-5,-4.4) P16(-5,-3.6) P17(-5,-2.8) P18(-5,-2) P19(-5,-1.2) P20(-5,-0.4)
USBC_SHLD_SJR_24P_6EM_2M_MB_PIP
  round 0.25 hole 0.6 unplated: (-0.975,-2.7)
  round 0.25 hole 0.85x0.6 unplated: (6.225,-2.7)
  rect 0.27x0.9 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  rect 0.27x0.8 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
  oval 1.3x2.6 hole 0.7x2: MH1(-1.695,-5.75) MH2(6.945,-5.75)
  oval 1.2x2.3 hole 0.6x1.9: MH3(-1.695,-0.7) MH5(6.945,-0.7)
  oval 1.45x1.1 hole 1.25x0.7: MH4(-1.37,-1.3) MH6(6.62,-1.3)
USBX32_SHLD_RJV_5X7_8M_IB
  rect 1.321x1.321 hole 0.94: 1(0,0)
  round 1.321 hole 0.94: 2(2.489,0) 3(4.496,0) 4(6.985,0) 5(7.506,1.499) 6(5.499,1.499) 7(3.493,1.499) 8(1.486,1.499) 9(-0.521,1.499) 10(0,3.2) 11(2.489,3.2) 12(4.496,3.2) 13(6.985,3.2) 14(7.506,4.699) 15(5.499,4.699) 16(3.493,4.699) 17(1.486,4.699) 18(-0.521,4.699) 19(9.207,8.788) 20(7.938,11.328) 21(6.668,8.788) 22(5.397,11.328) 23(4.128,8.788) 24(2.857,11.328) 25(1.587,8.788) 26(0.318,11.328) 27(-0.953,8.788) 28(-2.223,11.328) 29(-3.708,14.173) 30(-1.168,14.173) 31(8.153,14.173) 32(10.693,14.173)
  round 2.692 hole 2.311: 33(-5.855,6.948) 34(-3.073,3.683) 35(-3.073,-2.007) 36(-5.855,-4.66) 37(12.84,-4.66) 38(10.058,-2.007) 39(10.058,3.683) 40(12.84,8.675)
VQFP128_S1420_40MA
  rect 1.45x0.2 smd: 1(-7.625,6.2) 2(-7.625,5.8) 3(-7.625,5.4) 4(-7.625,5) 5(-7.625,4.6) 6(-7.625,4.2) 7(-7.625,3.8) 8(-7.625,3.4) 9(-7.625,3) 10(-7.625,2.6) 11(-7.625,2.2) 12(-7.625,1.8) 13(-7.625,1.4) 14(-7.625,1) 15(-7.625,0.6) 16(-7.625,0.2) 17(-7.625,-0.2) 18(-7.625,-0.6) 19(-7.625,-1) 20(-7.625,-1.4) 21(-7.625,-1.8) 22(-7.625,-2.2) 23(-7.625,-2.6) 24(-7.625,-3) 25(-7.625,-3.4) 26(-7.625,-3.8) 27(-7.625,-4.2) 28(-7.625,-4.6) 29(-7.625,-5) 30(-7.625,-5.4) 31(-7.625,-5.8) 32(-7.625,-6.2) 65(7.625,-6.2) 66(7.625,-5.8) 67(7.625,-5.4) 68(7.625,-5) 69(7.625,-4.6) 70(7.625,-4.2) 71(7.625,-3.8) 72(7.625,-3.4) 73(7.625,-3) 74(7.625,-2.6) 75(7.625,-2.2) 76(7.625,-1.8) 77(7.625,-1.4) 78(7.625,-1) 79(7.625,-0.6) 80(7.625,-0.2) 81(7.625,0.2) 82(7.625,0.6) 83(7.625,1) 84(7.625,1.4) 85(7.625,1.8) 86(7.625,2.2) 87(7.625,2.6) 88(7.625,3) 89(7.625,3.4) 90(7.625,3.8) 91(7.625,4.2) 92(7.625,4.6) 93(7.625,5) 94(7.625,5.4) 95(7.625,5.8) 96(7.625,6.2)
  rect 0.2x1.45 smd: 33(-6.2,-7.625) 34(-5.8,-7.625) 35(-5.4,-7.625) 36(-5,-7.625) 37(-4.6,-7.625) 38(-4.2,-7.625) 39(-3.8,-7.625) 40(-3.4,-7.625) 41(-3,-7.625) 42(-2.6,-7.625) 43(-2.2,-7.625) 44(-1.8,-7.625) 45(-1.4,-7.625) 46(-1,-7.625) 47(-0.6,-7.625) 48(-0.2,-7.625) 49(0.2,-7.625) 50(0.6,-7.625) 51(1,-7.625) 52(1.4,-7.625) 53(1.8,-7.625) 54(2.2,-7.625) 55(2.6,-7.625) 56(3,-7.625) 57(3.4,-7.625) 58(3.8,-7.625) 59(4.2,-7.625) 60(4.6,-7.625) 61(5,-7.625) 62(5.4,-7.625) 63(5.8,-7.625) 64(6.2,-7.625) 97(6.2,7.625) 98(5.8,7.625) 99(5.4,7.625) 100(5,7.625) 101(4.6,7.625) 102(4.2,7.625) 103(3.8,7.625) 104(3.4,7.625) 105(3,7.625) 106(2.6,7.625) 107(2.2,7.625) 108(1.8,7.625) 109(1.4,7.625) 110(1,7.625) 111(0.6,7.625) 112(0.2,7.625) 113(-0.2,7.625) 114(-0.6,7.625) 115(-1,7.625) 116(-1.4,7.625) 117(-1.8,7.625) 118(-2.2,7.625) 119(-2.6,7.625) 120(-3,7.625) 121(-3.4,7.625) 122(-3.8,7.625) 123(-4.2,7.625) 124(-4.6,7.625) 125(-5,7.625) 126(-5.4,7.625) 127(-5.8,7.625) 128(-6.2,7.625)
XDP_SJV_2X30_2M_MB
  round 0.254 hole 1.016 unplated: (5.519,2.817) (5.519,-17.325)
  rect 2.286x0.279 smd: 1(0,0) 2(5.715,0) 3(0,-0.5) 4(5.715,-0.5) 5(0,-1) 6(5.715,-1) 7(0,-1.5) 8(5.715,-1.5) 9(0,-2) 10(5.715,-2) 11(0,-2.5) 12(5.715,-2.5) 13(0,-3) 14(5.715,-3) 15(0,-3.5) 16(5.715,-3.5) 17(0,-4) 18(5.715,-4) 19(0,-4.5) 20(5.715,-4.5) 21(0,-5) 22(5.715,-5) 23(0,-5.5) 24(5.715,-5.5) 25(0,-6) 26(5.715,-6) 27(0,-6.5) 28(5.715,-6.5) 29(0,-7) 30(5.715,-7) 31(0,-7.5) 32(5.715,-7.5) 33(0,-8) 34(5.715,-8) 35(0,-8.5) 36(5.715,-8.5) 37(0,-9) 38(5.715,-9) 39(0,-9.5) 40(5.715,-9.5) 41(0,-10) 42(5.715,-10) 43(0,-10.5) 44(5.715,-10.5) 45(0,-11) 46(5.715,-11) 47(0,-11.5) 48(5.715,-11.5) 49(0,-12) 50(5.715,-12) 51(0,-12.5) 52(5.715,-12.5) 53(0,-13) 54(5.715,-13) 55(0,-13.5) 56(5.715,-13.5) 57(0,-14) 58(5.715,-14) 59(0,-14.5) 60(5.715,-14.5)
XSEAF240_50MA
  round 0.254 hole 1.295 unplated: (-20.841,3.048) (20.841,0)
  round 0.635 smd: 1(-18.415,4.445) 2(-18.415,3.175) 3(-18.415,1.905) 4(-18.415,0.635) 5(-18.415,-0.635) 6(-18.415,-1.905) 7(-18.415,-3.175) 8(-18.415,-4.445) 9(-17.145,4.445) 10(-17.145,3.175) 11(-17.145,1.905) 12(-17.145,0.635) 13(-17.145,-0.635) 14(-17.145,-1.905) 15(-17.145,-3.175) 16(-17.145,-4.445) 17(-15.875,4.445) 18(-15.875,3.175) 19(-15.875,1.905) 20(-15.875,0.635) 21(-15.875,-0.635) 22(-15.875,-1.905) 23(-15.875,-3.175) 24(-15.875,-4.445) 25(-14.605,4.445) 26(-14.605,3.175) 27(-14.605,1.905) 28(-14.605,0.635) 29(-14.605,-0.635) 30(-14.605,-1.905) 31(-14.605,-3.175) 32(-14.605,-4.445) 33(-13.335,4.445) 34(-13.335,3.175) 35(-13.335,1.905) 36(-13.335,0.635) 37(-13.335,-0.635) 38(-13.335,-1.905) 39(-13.335,-3.175) 40(-13.335,-4.445) 41(-12.065,4.445) 42(-12.065,3.175) 43(-12.065,1.905) 44(-12.065,0.635) 45(-12.065,-0.635) 46(-12.065,-1.905) 47(-12.065,-3.175) 48(-12.065,-4.445) 49(-10.795,4.445) 50(-10.795,3.175) 51(-10.795,1.905) 52(-10.795,0.635) 53(-10.795,-0.635) 54(-10.795,-1.905) 55(-10.795,-3.175) 56(-10.795,-4.445) 57(-9.525,4.445) 58(-9.525,3.175) 59(-9.525,1.905) 60(-9.525,0.635) 61(-9.525,-0.635) 62(-9.525,-1.905) 63(-9.525,-3.175) 64(-9.525,-4.445) 65(-8.255,4.445) 66(-8.255,3.175) 67(-8.255,1.905) 68(-8.255,0.635) 69(-8.255,-0.635) 70(-8.255,-1.905) 71(-8.255,-3.175) 72(-8.255,-4.445) 73(-6.985,4.445) 74(-6.985,3.175) 75(-6.985,1.905) 76(-6.985,0.635) 77(-6.985,-0.635) 78(-6.985,-1.905) 79(-6.985,-3.175) 80(-6.985,-4.445) 81(-5.715,4.445) 82(-5.715,3.175) 83(-5.715,1.905) 84(-5.715,0.635) 85(-5.715,-0.635) 86(-5.715,-1.905) 87(-5.715,-3.175) 88(-5.715,-4.445) 89(-4.445,4.445) 90(-4.445,3.175) 91(-4.445,1.905) 92(-4.445,0.635) 93(-4.445,-0.635) 94(-4.445,-1.905) 95(-4.445,-3.175) 96(-4.445,-4.445) 97(-3.175,4.445) 98(-3.175,3.175) 99(-3.175,1.905) 100(-3.175,0.635) 101(-3.175,-0.635) 102(-3.175,-1.905) 103(-3.175,-3.175) 104(-3.175,-4.445) 105(-1.905,4.445) 106(-1.905,3.175) 107(-1.905,1.905) 108(-1.905,0.635) 109(-1.905,-0.635) 110(-1.905,-1.905) 111(-1.905,-3.175) 112(-1.905,-4.445) 113(-0.635,4.445) 114(-0.635,3.175) 115(-0.635,1.905) 116(-0.635,0.635) 117(-0.635,-0.635) 118(-0.635,-1.905) 119(-0.635,-3.175) 120(-0.635,-4.445) 121(0.635,4.445) 122(0.635,3.175) 123(0.635,1.905) 124(0.635,0.635) 125(0.635,-0.635) 126(0.635,-1.905) 127(0.635,-3.175) 128(0.635,-4.445) 129(1.905,4.445) 130(1.905,3.175) 131(1.905,1.905) 132(1.905,0.635) 133(1.905,-0.635) 134(1.905,-1.905) 135(1.905,-3.175) 136(1.905,-4.445) 137(3.175,4.445) 138(3.175,3.175) 139(3.175,1.905) 140(3.175,0.635) 141(3.175,-0.635) 142(3.175,-1.905) 143(3.175,-3.175) 144(3.175,-4.445) 145(4.445,4.445) 146(4.445,3.175) 147(4.445,1.905) 148(4.445,0.635) 149(4.445,-0.635) 150(4.445,-1.905) 151(4.445,-3.175) 152(4.445,-4.445) 153(5.715,4.445) 154(5.715,3.175) 155(5.715,1.905) 156(5.715,0.635) 157(5.715,-0.635) 158(5.715,-1.905) 159(5.715,-3.175) 160(5.715,-4.445) 161(6.985,4.445) 162(6.985,3.175) 163(6.985,1.905) 164(6.985,0.635) 165(6.985,-0.635) 166(6.985,-1.905) 167(6.985,-3.175) 168(6.985,-4.445) 169(8.255,4.445) 170(8.255,3.175) 171(8.255,1.905) 172(8.255,0.635) 173(8.255,-0.635) 174(8.255,-1.905) 175(8.255,-3.175) 176(8.255,-4.445) 177(9.525,4.445) 178(9.525,3.175) 179(9.525,1.905) 180(9.525,0.635) 181(9.525,-0.635) 182(9.525,-1.905) 183(9.525,-3.175) 184(9.525,-4.445) 185(10.795,4.445) 186(10.795,3.175) 187(10.795,1.905) 188(10.795,0.635) 189(10.795,-0.635) 190(10.795,-1.905) 191(10.795,-3.175) 192(10.795,-4.445) 193(12.065,4.445) 194(12.065,3.175) 195(12.065,1.905) 196(12.065,0.635) 197(12.065,-0.635) 198(12.065,-1.905) 199(12.065,-3.175) 200(12.065,-4.445) 201(13.335,4.445) 202(13.335,3.175) 203(13.335,1.905) 204(13.335,0.635) 205(13.335,-0.635) 206(13.335,-1.905) 207(13.335,-3.175) 208(13.335,-4.445) 209(14.605,4.445) 210(14.605,3.175) 211(14.605,1.905) 212(14.605,0.635) 213(14.605,-0.635) 214(14.605,-1.905) 215(14.605,-3.175) 216(14.605,-4.445) 217(15.875,4.445) 218(15.875,3.175) 219(15.875,1.905) 220(15.875,0.635) 221(15.875,-0.635) 222(15.875,-1.905) 223(15.875,-3.175) 224(15.875,-4.445) 225(17.145,4.445) 226(17.145,3.175) 227(17.145,1.905) 228(17.145,0.635) 229(17.145,-0.635) 230(17.145,-1.905) 231(17.145,-3.175) 232(17.145,-4.445) 233(18.415,4.445) 234(18.415,3.175) 235(18.415,1.905) 236(18.415,0.635) 237(18.415,-0.635) 238(18.415,-1.905) 239(18.415,-3.175) 240(18.415,-4.445)
XSOI8_S41_05IA
  rect 1.905x0.457 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(6.985,-3.81) 6(6.985,-2.54) 7(6.985,-1.27) 8(6.985,0)
Y82X31MA_PHG1
  rect 1.035x1.035 hole 0.66: 1(0,0)
  round 1.035 hole 0.66: 2(0,-1.1)

## Nets
5V_YLW_LED_BRD: Q8H5.4 R8H48.1
5V_YLW_LED_BRD_EN_N: Q8H5.5 R8H44.2(B)
5V_YLW_LED_BRD_R_N: Q8H5.6 R8H41.2(B) R8H44.1
5V_YLW_LED_HDR: Q8H1.4 R8H36.2(B)
5V_YLW_LED_HDR_N: Q8H1.5 R8H34.2(B)
5V_YLW_LED_HDR_R_N: Q8H1.6 R8H33.2(B) R8H34.1
5VDUAL_GATE: Q4G3.1 R4G17.2(B) R4G18.1
5VDUAL_NCH: Q4H1.6 R4G15.1 R4G17.1 R4H7.2(B)
5VDUAL_PCH: R4G16.1 R4H27.2(B) R4H47.2(B) R4H50.1
5VDUAL_SRC: Q4G3.3 R4G10.1 R4G14.1
+5VDUAL_PCH: C4G13.1 C4G14.1 EU4G1.5 Q4G2.5 R2G18.1 R5G16.1
+V1.05A_CPU_XDP_AB: C1C12.1 J1C1.43 R1C41.1
+V1.05A_CPU_XDP_CD: C1C15.1 J1C1.44(VCC_OBS_CD) R1C48.1
+V1.8DX_3.3DX_DMIC_SDW: C8B6.1 J9B1.4 R8B8.2(B) R8B9.2(B)
+V1.8DX_CORE_CODEC_FIL: C6A20.1 C6A25.1 EU6A1.17 FB6A2.2(B)
+V1P2_PCON_AVDD: C3L1.1 C3L2.1 C3L7.1 C3L9.1 C3L12.1 C3L14.1 FB3L1.2(B) R3A44.1 R3L4.1 U3A5.B4 U3A5.B5 U3A5.D6 U3A5.F4 U3A5.G5 U3A5.G7
+V1P2_PCON_DVDD: C3L4.1 C3L8.1 C3L13.1 FB3L1.1 R2A58.2 U3A5.B7 U3A5.F5
+V1P2S_ALS_D: C2L1.1 C2L2.1 C2L3.1 C2L4.1 C2L5.1 C2L6.1 C2L7.1 C2L8.1 EU2A7.6 EU2A7.11 EU2A7.15 EU2A7.18(VDDTX12_2) EU2A7.30 FB2L2.1 R2A47.2
+V1P2S_ALS_RX: C2L9.1 C2L10.1 C2L11.1 C2L12.1 EU2A7.43 EU2A7.46 FB2L2.2(B)
+V1P2S_HDMI_VR: C2A25.1 EU2B1.6(VOS) L2B1.2(INB) R2A47.1 R2A57.2(B) R2A58.1
+V1P05A: C4C12.1 C4C14.1 R4C20.1 R4C21.1 R6F30.1 R6F37.2 R6J30.1 U4C2.2 U4C2.4 U4C3.2 U4C3.4
+V1P05A_OUT: C5F17.1 C5F18.1 C5F19.1 C5F20.1 C5F21.1 C5F22.1 C5G5.1 C5G14.1 C6F5.1 C6F6.1 L5G1.2(INB) R6F37.1
+V1P05A_VAL: R1C41.2(B) R1C42.1 R1C48.2(B) R4C27.1 R4C28.1 R4C29.1 R4C30.1 R5F11.1 R6D33.1 R6D54.1 R6F13.1 R6H7.1 R6H33.1 R7E59.1 R8E50.2(B)
+V1P05A_VAL_OUT: C8E12.1 C8E13.1 L8E3.2(INB) R8E50.1 R8E64.1
+V1P8_AUDIO: C6A29.1 C6A30.1 C6A31.1 EU6A1.5 FB6A2.1 R5A3.1 R5A7.1 R6A29.2 R6A33.1 R6A36.1 R6A51.1 R6A54.1 R6A55.1 R6A61.1 R6A62.1 R6A63.1 R8A26.1 R8A32.1 R8B1.1 R8B2.1 R8B8.1 R8B23.1 R9A9.2(B) R9A19.2(B) U9A1.1 Y6A1.4(VDD)
+V1P8_AUDIO_I2S2: C8B25.1 J9B4.3 R8B23.2(B) R8B26.2(B)
+V1P8_AUDIO_R: R6A28.2(B) R6A29.1 U6A2.5
+V1P8_V3P3_AUDIO_DVDD: C9A2.1 J9A4.8 R9A19.1 R9A21.1
+V1P8_V3P3_AUDIO_DVDDIO: C9A1.1 J9A4.4 R9A4.1 R9A9.1
+V1P8_V3P3_I2S1: C8A5.1 J9A5.5 R8A25.2(B) R8A26.2(B)
+V1P8A: C6A12.1 C7H2.1 C8D12.1 C8G16.1 EU7H1.16 EU8G3.1 EU8G3.2 EU8G3.7 EU8G3.16 J7D3.2(IO2) Q8C14.2(SRC) R5C72.1 R5D42.1 R5J6.2(B) R6A28.1 R6A31.1 R6J14.2(B) R6J22.2(B) R6T16.1 R7C26.1 R7C49.1 R7D20.2(B) R7D21.2(B) R7D40.1 R7H21.1 R7H23.1 R7H30.1 R7H41.1 R7H45.1 R7P4.1 R7P10.1 R7R1.1 R7R3.1 R7R28.1 R7R29.1 R7R46.1 R7T7.1 R7T24.1 R7U19.1 R7W1.1 R8C70.1 R8D14.1 R8D57.2(B) R8F38.2 R8G60.1 R9C12.1 R9C14.1 R9F33.1 R9G4.1 U6A2.3 U8D2.3
+V1P8A_CC: C8D22.1 R8D57.1 U8D7.5
+V1P8A_EC: J6J2.91 J6J2.99 R9G2.1 R9G4.2(B) U8F6.54
+V1P8A_OUT: C7F10.1 C8F12.1 C8F13.1 C8F16.1 L8F2.2(INB) R8F38.1 R8F41.1
+V1P8A_PCH_VAL: R6T8.1 R7C51.1 R7P8.1 R7P11.1 R7R27.1 R7R30.1 R7R45.1 R7T1.1 R7T20.1 R8E15.2(B)
+V1P8A_PCH_VAL_OUT: C8E3.1 C8E4.1 L8E1.2(INB) R8E15.1 R8E23.1
+V1P8A_TCH_PNL: R7C49.2(B) U8C5.C2
+V1P8DX_TCH_PNL_IO: C8C23.1 Q8C14.3 R7D5.1 SW7C1.3
+V1P8S: R7C5.1 R7E33.1 R7R42.1 R8A28.1 R8C77.1 R9D8.1 R9H17.2(B) R9J1.2(B) R9J9.2(B) U8D2.5
+V3.3A_KBC_DIO: CR9E1.2 R9E25.2(B)
+V3.3A_MECC_SPI: CR6J1.1 J6J2.14
+V3.3A_SPI_EC: C8E10.1 C9E2.1 C9E3.1 CR9E1.1(CATHODE) EU9E1.8(VCC) J9E9.6 R8E45.1 R9E29.1 R9E30.1 R9E31.1
+V3.3M_LAN_ESD1_FOX: EU7A2.5 R7A12.2(B)
+V3.3M_LAN_ESD2_FOX: EU7A1.5 R7A10.2(B)
+V3P3_AUDIO: Q8A1.1 R8A11.2 R8A25.1 R8A31.1 R8B9.1 R8B26.1 R9A4.2(B) R9A21.2(B)
+V3P3_AUDIO_R: R8A10.2(B) R8A11.1 U8A1.5
+V3P3_DUAL: C5G15.1 C7B15.1 C7H3.2(B) C7W2.1 C8C26.1 C8E15.1 C8E16.1 C8F2.1 C8G12.1 C8G15.1 C9C7.1 J7J1.9(IO9) R5A18.1 R5B20.1 R5B23.1 R5C7.1 R5C9.2(B) R5E3.1 R5G19.1 R5G24.1 R6A86.1 R6A88.1 R6D64.1 R6F7.1 R6F12.1 R6F40.1 R6F41.1 R6H20.1 R6J32.1 R6V1.1 R6W2.1 R7B21.1 R7B67.1 R7B73.2(B) R7C1.2(B) R7D16.1 R7E35.2(B) R7E40.1 R7E57.1 R7F40.1 R7F41.1 R7R53.1 R7T6.1 R7T19.1 R8B33.1 R8C8.1 R8C11.1 R8C45.2(B) R8C67.1 R8F28.1 R8F32.1 R8G45.1 R8G69.2 R8G78.1 R8G81.1 R8H8.1 R8L3.1 R9C18.1 R9D32.1 R9D35.1 U5C1.5 U5G2.5 U7B3.5 U7H1.5 U8C4.5 U8F1.5 U8F2.5 U8F5.5 U8G1.5 U8G3.3 U9C2.5
+V3P3_EC: C7G12.1 C8F8.1 C8F11.1 C8F20.1 C8G3.1 C8G6.1 C8L4.1 C9E1.1 C9F2.1 C9G1.1 C9G2.1 J7G1.12 J9F5.2 Q9F1.1 R6J1.1 R7G14.1 R7L1.1 R7U31.1 R8E19.1 R8E21.1 R8E25.1 R8E33.1 R8E36.1 R8F13.1 R8F14.1 R8F19.1 R8F23.1 R8F24.1 R8F25.1 R8F27.1 R8G10.1 R8G14.1 R8G17.1 R8G21.1 R8G22.1 R8G23.1 R8G29.1 R8G56.2(B) R8G68.2(B) R8H54.1 R8L1.1 R9E2.1 R9E4.1 R9E6.1 R9E7.1 R9E9.1 R9E12.1 R9E15.1 R9E17.1 R9E19.1 R9E20.1 R9E22.1 R9E24.1 R9E25.1 R9F5.1 R9F12.1 R9F14.1 R9F15.1 R9F21.1 R9F27.1 R9F29.1 R9F30.1 R9F31.1 R9F32.1 R9F36.1 R9G2.2(B) R9G3.1 R9G5.1 R9G14.1 R9G15.1 R9G18.1 R9G26.1 R9G27.1 R9G28.1 U7U1.12 U8E3.24 U8F6.5 U8F6.19 U8F6.65 U8F6.82 U8F6.103 U8F6.115 U8L2.8
+V3P3_EC_AIC: FB6J1.1 J6J2.1 J6J2.9 J6J2.17 J6J2.25 R6J1.2
+V3P3_EC_MIX: R8G17.2 R8G26.2(B) R8G27.2(B)
+V3P3_LAN: C4A22.1 C4A25.1 C4A27.1 C4A34.1 C4B5.1 EU4B1.4 EU4B1.5 EU4B1.15 EU4B1.19 EU4B1.29 J4A2.31 R4B2.1 R4B4.1 R4B8.1 R4B10.2 R4B12.1 R4B16.1 R4B17.1 R4B18.1
+V3P3_LAN_FOX: C6A22.1 C6A23.1 C6L5.1 C6M1.1 C6M2.1 C7B13.1 C7L1.1 C7L2.1 C7L4.1 C7L5.1 C7L7.1 C7M2.1 C7M4.1 C7M6.1 C7M7.1 EU7A3.7 EU7A3.14 EU7A3.23 EU7A3.33 EU7A3.39 EU7A3.43 EU7A3.47 EU7A3.53 R6A34.2 R6A72.1 R6B2.1 R6B5.1 R6B9.1 R6B21.1 R6B22.1 R6B23.1 R7A1.1 R7A5.1 R7A10.1 R7A12.1 R7B9.1 R7B10.1 R7B12.1 R7B13.1 R7B14.1 R7B34.1 R7B39.1 R8B29.1 U6B1.8 U6B2.8
+V3P3_LAN_FOX_R: R6A34.1 U6A3.5
+V3P3_LAN_R: EU4B2.5 R4B10.1
+V3P3_PMON: C1D12.1 C1E3.1 C3H2.1 C3H3.1 C4H4.1 C4H5.1 C4H6.1 R1D16.1 R1E3.1 R1E15.1 R1E30.2(B) R1E31.1 R1E34.1 R2E5.1 R3H10.1 R3H17.2(B) R3H18.2(B) R3H21.1 R3H23.1 R3H25.1 R4H24.1 R4H25.1 R4H28.1 R4H32.1 R5J1.1 R5J2.1 U1E1.A4 U1E2.A4 U1E3.A4 U3H1.A4 U3H2.A4 U4H1.A4 U4H2.A4
+V3P3_PPV: C7J3.1 J8J1.2 J8J13.39 R7J10.1 R8J3.1 R8J5.1 R8J7.1 U8J2.8
+V3P3_SLOTE: C7B7.1 C7B8.1 C7B9.1 C7B10.1 C7B11.1 C7B12.1 C7C1.1 C7C3.1 C7C4.1 C7C6.1 C7C7.1 J7C1.2 J7C1.4 J7C1.72 J7C1.74 R7B25.2 R7B46.1 R7B49.1 R7C10.2(B) R7C11.2(B)
+V3P3_SLOTE_R: R7B16.2(B) R7B17.2(B) R7B20.2(B) R7B25.1
+V3P3_SLOTM: C8G17.1 C8G18.1 C8G19.1 C8G20.1 C8G22.1 C8H1.1 C8H4.1 C8H5.1 C8H6.1 C9G9.1 C9G10.1 J8H1.2 J8H1.4 J8H1.12 J8H1.14 J8H1.16 J8H1.18 J8H1.70 J8H1.72 J8H1.74 R8G86.2 R8H6.1 R8H51.1
+V3P3_SLOTM_LS: R8G86.1 U8G3.5
+V3P3A: C2G25.1 C5C34.1 C5D1.1 C5E3.1 C5J1.1 C6A7.1 C7E8.1 C7E10.2(B) C7F4.1 C7G6.1 C8A1.1 C8A2.1 C8C3.1 C8C5.1 C8C6.1 C8C17.1 C8C21.1 C8D8.1 C8D25.1 C8D27.1 C8D28.1 C8D29.1 C8D30.1 C8G13.1 C8N1.1 EU8G3.15(VCCB) J4J3.1 J5J1.17 J6J2.4 J6J2.5 J8J13.13 J9H3.1 J9H3.4 Q7B7.1 Q7B8.1 R2D1.2(B) R2G23.2(B) R4J5.1 R5A20.1 R5A25.1 R5C33.1 R5C50.1 R5E56.1 R5F10.1 R5G13.1 R5J4.1 R5J5.1 R5M13.1 R5M15.1 R5V1.1 R5V8.1 R6A24.1 R6A85.1 R6A87.1 R6D48.1 R6D51.1 R6D63.1 R6F2.1 R6F8.1 R6F11.1 R6F18.1 R6F21.1 R6F25.2(B) R6H37.1 R6J8.1 R6J23.1 R6T3.1 R6T11.1 R6T13.2(B) R6T14.1 R6T15.1 R6T17.1 R6T20.1 R6T22.2(B) R7B20.1 R7B36.1 R7B44.1 R7B69.2(B) R7B76.2(B) R7B77.2(B) R7B81.1 R7C6.1 R7C37.1 R7E19.1 R7E21.1 R7E42.1 R7E50.1 R7F8.1 R7G15.1 R7H47.2(B) R7P6.1 R7R2.1 R7R25.1 R7R32.1 R7R43.1 R7T2.1 R7T23.1 R7T25.1 R8A10.1 R8B20.2(B) R8C34.1 R8C38.1 R8C49.1 R8C50.1 R8C57.1 R8C60.1 R8C61.1 R8C63.1 R8C64.1 R8C81.1 R8D3.1 R8D4.1 R8D15.1 R8D67.1 R8D68.1 R8D79.1 R8D81.1 R8D88.1 R8D94.1 R8E2.1 R8E65.1 R8G5.1 R8G6.1 R8G8.2 R8G26.1 R8G52.1 R8G85.1 R8H77.1 R8J8.1 R8J10.1 R8J15.1 R8J17.1 R8N1.1 R9C15.1 R9C17.1 U2G2.1 U5C2.5 U5D1.6 U5E1.5 U6A2.1(VDD) U7G5.6 U8A1.1(VDD) U8A1.3 U8B3.1(VDD) U8B3.3 U8C2.5 U8C3.5 U8D5.6 U8D6.2 U8D6.7 U8D6.8(VCC) U8D8.5 U8D9.5 U8D10.5 U8D11.5 U8D12.5 U8N1.5
+V3P3A_1P8A_EC: C9F4.1 R9F34.1 U8F6.43
+V3P3A_1P8A_EC_MIX: R9F31.2(B) R9F33.2(B) R9F34.2
+V3P3A_1P8A_ESPI: C7W1.1 J7J1.15 R7W1.2(B) R7W2.2(B)
+V3P3A_1P8A_R_SNSR_HDR: R6A24.2(B) R6A31.2(B) R8H29.1
+V3P3A_1P8A_SNSR_HDR: C8H7.1 C8H8.1 J8H2.1 J8H2.3 R7H51.1 R7H62.1 R7H66.1 R8G48.1 R8G49.1 R8H29.2 U7H2.2 U8G2.2
+V3P3A_1P8A_SPI: C7G7.1 C7G8.1 C7G11.1 C7G13.1 CR6J1.3(C) CR7G1.1(CATHODE) CR7G2.1(CATHODE) EU7G3.8(VCC) J7G1.36 J7G2.6 R7G23.1 R7G26.2 R7H15.1 R7H19.1 R7H20.1 R7U33.1 R7U35.1 U7G4.2
+V3P3A_1P8A_SPI_R: R7G23.2(B) U7G4.3
+V3P3A_1P8A_SPI_TPM: C7G9.1 C7G10.1 J7G1.48 J7G2.18 R7G26.1 R7G35.1
+V3P3A_1P8A_SPI_TPM_R: J7G1.50 J7G2.20 R7G35.2(B)
+V3P3A_PCH_VAL: R6T10.1 R7C50.1 R7P5.1 R7R26.1 R7R31.1 R7R44.1 R7T5.1 R7T21.1 R8E38.2(B)
+V3P3A_PCH_VAL_OUT: C8E7.1 C8E8.1 L8E2.2(INB) R8E38.1 R8E42.1
+V3P3A_PCIEAUX: C5B22.1 C5B23.1 C8B23.1 C8B24.1 J5B2.B10 J7B1.B10 R8B25.1 R8B30.2
+V3P3A_PCIEAUX_LAN: C8B21.1 C8B22.1 J8B1.B10 R8B25.2(B) R8B29.2(B)
+V3P3A_SNSR_HDR: C8H2.1 C8H3.1 J8H2.2 J8H2.4 J8H2.6 R8G85.2
+V3P3A_TCH_PNL: R7C37.2(B) U8C5.A2
+V3P3A_USBC: C5A26.1 C5D8.1 C6D13.1 C6D16.1 C6D17.1 EU5A1.5(VIN_3V3) EU6D1.1 EU6D1.6(VCC_6) EU6D1.20 EU6D1.28 R5A55.1 R5D6.1 R5D11.1 R5D12.1 R5D15.1 R5D27.2 R6A56.1 R6A60.1 R6D23.1 R6D24.1 R6D35.1 R6D37.1 R6D46.1 R6D47.1 R7C41.1 R7C42.1 R7C46.1 R9G24.1
+V3P3A_V1P8A_SPI_DIODE: CR7G1.2 CR7G2.2 U7G1.3 U7U1.11
+V3P3A_VAL: C7H5.1 EU8H2.1(VDD) R1D3.2(B) R3H17.1 R6H6.1 R6H32.1 R7H69.1 R7H70.2(B) R7W2.1 R8H58.1 R8H59.1 R8H60.1
+V3P3A_VR: Q8G1.3 R7G3.2(B) R8G8.1
+V3P3DSW: C4B6.1 C6A19.1 C8C16.1 C8C22.1 C8C25.1 C8D5.1 C8D14.1 C8D35.1 C8G11.1 EU4B2.3 FB3A1.2(B) FB3A2.2(B) J8J13.8 J8J13.21 Q5C1.1 Q5C1.2 Q5C1.3(S3) Q7B4.1 Q7B4.2 Q7B4.3(S3) Q8G1.2(SRC) Q8G7.2(SRC) R5A27.1 R5C18.1 R5C30.1 R5H14.1 R6A35.1 R6D58.1 R6J16.1 R7B4.1 R7B6.1 R7B7.1 R7B16.1 R7B30.2(B) R7E61.1 R7F4.1 R7F6.1 R7F9.1 R7F49.1 R7G3.1 R7G4.2 R8C16.1 R8C25.1 R8C26.1 R8D30.1 R8D31.1 R8D32.1 R8D33.1 R8D39.1 R8D90.1 R8F18.1 R8F53.1 R8G27.1 R8H47.1 R9H15.1 U6A3.3 U8C1.5 U8C6.1(VDD) U8C6.3 U8D1.5 U8D13.5 U8D14.5 U8H5.1(VDD)
+V3P3DSW_OUT: C7G3.1 C7G4.1 C8G5.1 C8G10.1 L8G1.2(INB) R7G4.1 R8G18.1 R8G87.1
+V3P3DSW_PCH_VAL: R7F10.1 R7F12.1 R8D87.2(B)
+V3P3DSW_PCH_VAL_OUT: C8D33.1 C8D34.1 L8D1.2(INB) R8D87.1 R8E7.1
+V3P3DSW_USBRD_1: C3A23.1 C3A24.1 C3B8.1 C3B9.1 C3M1.1 C3M2.1 C3M3.1 C3M4.1 C3M5.1 C3M6.1 C3M7.1 C4M1.1 C4M2.1 C4M3.1 C4M4.1 C4M5.1 C4M6.1 C4M7.1 EU3B4.3 EU3B4.6 EU3B4.7(VDD3P3_7) EU3B4.14 EU3B4.15 EU3B4.21 EU3B4.24 EU3B4.25 EU3B4.32 EU3B4.33 EU3B4.36 EU4B5.3 EU4B5.6 EU4B5.7(VDD3P3_7) EU4B5.14 EU4B5.15 EU4B5.21 EU4B5.24 EU4B5.25 EU4B5.32 EU4B5.33 EU4B5.36 FB3A1.1 FB3A2.1 R3B12.1 R3B17.1 R3B18.1 R3B19.1 R3B20.1 R3B21.1 R3M1.1 R3M2.1 R3M7.1 R3M8.1 R4B9.1 R4B11.1 R4M3.1 R4M4.1 R4M7.1 R4M8.1
+V3P3DSW_VAL: C8H17.1 EU8H1.1(VDD) Q7H3.2(SRC) R1E30.1 R7H67.1 R7H68.1 R8F4.2(B) R8F55.1 R8H57.1 R8H61.1 R8J20.1 R8J23.1 R8J24.1
+V3P3DSW_VAL_OUT: C8F4.1 C8F5.1 L8F1.2(INB) R8F4.1 R8F11.1
+V3P3DX_CPU_SSD2: C4C3.1 C4C4.1 C5C5.1 C5C6.1 C5C7.1 C5C8.1 C5C9.1 C5C10.1 C5C11.1 C5C12.1 C5C13.1 J5B3.2 J5B3.4 J5B3.12 J5B3.14 J5B3.16 J5B3.18 J5B3.70 J5B3.72 J5B3.74 R5C17.2 R7C3.1
+V3P3DX_CPU_SSD2_LS: C5C21.1 EU5C1.5 Q5C1.5 R5C17.1
+V3P3DX_SDCARD: C9C8.1 C9C9.1 J9D1.4 R8C78.2
+V3P3DX_SDCARD_LS: R8C78.1 U8C6.6
+V3P3DX_V1P8DX_TCH_PNL: C9D6.1 C9D7.1 J9D2.6 R7C43.2 R8E11.1 R9D21.1 SW7C1.4
+V3P3DX_V1P8DX_TCH_PNL_IO: R8E31.1 R8E39.1 R8E40.1 R9D9.1 R9D10.1 R9D14.1 R9D22.1 SW7C1.5(S4B) SW7C1.6
+V3P3DX_V1P8DX_TCH_PNL_R: R7C43.1 U8C5.B2(VOUT)
+V3P3S: C1B3.1 C3A6.1 C4G18.1 C4G19.1 C4G22.1 C6B7.1 C7B1.1 C7B14.1 C8B33.1 C8B36.1 C8E17.1 C9B4.1 EU5C5.5 EU6B3.3 EU7B2.5 EU8G2.1 EU8G2.2 EU8G2.3(S3) J6J2.49 J6J2.57 R1A2.1 R1B4.1 R1B8.1 R1B9.1 R1B15.1 R1B18.1 R1B22.1 R1C12.1 R1D2.1 R1E45.1 R2A6.1 R2A20.1 R2A34.2 R2A36.1 R2A46.1 R2A50.1 R2A53.1 R2A54.1 R2B4.1 R2C20.2(B) R2C21.2(B) R2L1.2(B) R3A45.1 R4G19.2 R4G23.1 R4G24.1 R5A17.1 R5C35.1 R5C36.1 R5C58.1 R5C63.1 R5C64.1 R5D16.1 R5D17.1 R5D32.1 R5D34.1 R5D35.1 R5D38.1 R5D39.1 R5D40.1 R5E10.1 R5F5.1 R5V2.1 R5V3.1 R5V4.1 R5V5.1 R5V6.1 R5V7.1 R6B14.1 R6F9.1 R6F35.1 R6H21.1 R7B33.1 R7B55.1 R7E39.1 R7F42.1 R7F43.1 R7R41.1 R7R52.1 R7T18.1 R8B40.1 R8B42.1 R8D7.1 R8D16.1 R8F70.1 R8H32.2(B) R8H65.1 R8H66.1 R8H75.1 R8J19.1 R8R3.1 R8R6.1 R8R7.1 R8R10.1 R9C1.2(B) R9C3.1 R9C8.1 R9C11.2(B) R9E26.1 R9G20.1 R9G23.1 R9G34.1 R9G39.1 R9G40.1 R9H3.1 R9H16.2(B) R9H21.2(B) R9J6.2(B) U1B2.5 U3A4.5 U7B2.5 U8B1.3 U8B2.3 U8F3.5 U9C1.16
+V3P3S_ALS: C2A11.1 C2A12.1 C2A27.1 EU2A7.1 EU2A7.24 R2A34.1 R2A38.1 R2A39.1 R2A41.1 R2A44.1 R2A45.1 R2A52.1 R2A61.1
+V3P3S_DDI1_DP_OB_FUSE: C2A7.1 C2A8.1 C2A9.1 Q2A2.4 RT2A2.1
+V3P3S_DDIA_OB_DP: J2A1.T20 RT2A2.2(B)
+V3P3S_DP1_PWR: Q2A2.2 Q2A2.3(S2) R2A6.2
+V3P3S_DP_EMB: C1C3.1 C1C8.1 J1B2.1 J1B2.2 J1B2.3 J1B2.4 J1B2.5 Q1C1.3
+V3P3S_DP_EMB_AUXPWR: C1B7.1 C1B8.1 J1B2.29 R1B18.2(B)
+V3P3S_PCIE_SLOT2: C8B17.1 C8B18.1 C8B20.1 J7B1.A9 J7B1.A10 J7B1.B8 Q8C2.1 R8B32.2 R8C20.1
+V3P3S_PCIE_SLOT2_R: R8B32.1 U8B2.5
+V3P3S_PCIE_SLOT3: C8B15.1 C8B16.1 C8B19.1 J8B1.A9 J8B1.A10 J8B1.B8 Q8C1.1 R8B31.2 R8C19.1
+V3P3S_PCIE_SLOT3_R: R8B31.1 U8B1.5
+V3P3S_PCON: C3L5.1 C3L6.1 CR2A4.1(C) FB2L1.1 R2A35.1 R2A60.1 R2A62.1 R2A65.1 R2L1.1 R2L2.1 R3L2.1 U2B1.8 U3A5.D3 U3A5.E3
+V3P3S_PCON_AVDD: C3L3.1 C3L10.1 C3L11.1 FB2L1.2(B) U3A5.B2 U3A5.C4 U3A5.G2 U3A5.G4(VDD33_TX_G4)
+V3P3S_PEG_SLOT: C5B19.1 C5B20.1 C6B6.1 J5B2.A9 J5B2.A10 J5B2.B8 Q5B1.1 Q5D2.1 Q6C1.1 R5B38.1 R5B39.1 R5D37.1 R6B24.2
+V3P3S_PEG_SLOT_R: EU6B3.5 R6B24.1
+V3P3S_R: J4G1.1 J4G1.2 J4G1.12 J4G1.13 R4G19.1 R4G21.1
+V3P3S_V1P8S_GSP1: R9H6.1 R9H8.1 R9H9.1 R9H11.1 R9H14.1 R9H16.1 R9H17.1
+V3P3S_V1P8S_GSPI0: R9J6.1 R9J9.1 R9J12.1 R9J13.1 R9J15.1 R9J17.1 R9J19.1
+V3P3S_V1P8S_UART0: R9H21.1 R9J1.1 R9J3.1 R9J5.1 R9J8.1 R9J11.1
+V3P3S_VAL: J8J1.1 R2A8.1 R3H18.1 R4G21.2(B) R7H1.1 R8H62.1 R8H63.1
+V3P.3A_WWAN_SAR: J8H2.37 R7H47.1
+V5.0DX_SSD: C6J2.1 C6W1.1 C6W2.1 C6W3.1 J5J2.15 J5J2.16(V_5.0_9) R6J31.2 R6W4.1
+V5_AUDIO: R6A3.2 R6A4.1 R8A24.2(B) R8B14.1 R9A25.2(B)
+V5_AUDIO_I2S1: C8A4.1 J9A5.4 R8A24.1
+V5_AUDIO_R: R6A3.1 R6A9.2(B) U6A1.5
+V5_AUDIO_SDW: C8B11.1 J9B1.8(IO8) R8B14.2(B)
+V5_V12S_AUDIO_JA: C9A3.1 C9B1.1 J9A4.10 J9A4.14 R9A25.1 R9B2.1
+V5A: C1E11.1 C4C11.1 C4C13.1 C6B3.1 C6B8.1 C7G2.1 C7G5.1 C8B2.1 C8B4.1 C8B32.1 C8B34.1 C8D9.1 C8D10.1 EU1E2.1(VCC) EU6B1.1(VCC) EU6B3.1(VDD) EU8B1.1(VCC) EU8B4.1(VCC) R1B2.1 R1B3.1 R1B36.2(B) R2B39.2(B) R2C22.1 R2M1.1 R2M2.1 R2M20.1 R3M9.1 R3M10.1 R3M11.1 R3M12.1 R4C15.2(B) R4M9.1 R4M10.1 R5B72.1 R5B89.1 R6A18.1 R8G35.2 R8H33.1 R8H36.1 R8H41.1 R8H48.2(B) U4C2.1(VDD) U4C3.1(VDD) U7G1.14 U7G2.14 U8B1.1(VDD) U8B2.1(VDD) U8D2.1(VDD)
+V5A_R: Q8G4.3 R8G35.1 R8G37.2(B)
+V5A_VAL: C7H9.1 C7H10.1 J6J2.67 J7J1.6 J7J1.27 R7H71.2(B)
+V5DSW: C3G24.1 C4B3.1 C4G25.1 C4H10.1 C4H12.1 C6A28.1 C7U2.1 C7U3.1 C8D11.1 C8G14.1 EU4B2.1(VDD) Q4G2.1 Q4G2.2 Q4G2.3(S3) Q4G4.2(SRC) Q8G4.2(SRC) R3G32.1 R3G34.2 R3G42.1 R4G8.1 R4H5.1 R4H26.1 R4H34.1 R4H47.1 R5G5.1 R8C83.1 R8D34.1 R8D38.1 R8F54.1 R8G16.1 R8G28.1 R8G37.1 U6A3.1(VDD) U7U1.14 U7U2.14 U8G3.1(VDD)
+V5DSW_R: C2G26.1 C2G27.1 C3G27.1 C3G28.1 J4G1.9 J9J4.1 R2G40.1 R3G34.1 R7H63.1 R8D86.1 R8E14.1 R8E37.1 R8E49.1 R8F3.1 U2G3.1(VCC)
+V5DSW_R1: C8G8.1 C8G9.1 EU8G1.8(SVIN) EU8G1.9 EU8G1.10 R8G28.2
+V5DSW_R2: C8F21.1 C8G1.1 EU8F2.8(SVIN) EU8F2.9 EU8F2.10 R8F54.2
+V5DSW_VAL: J7H1.10 Q7H2.2(SRC) R7H63.2(B)
+V5DUAL: C4G12.1 C4H15.1 C5E17.1 C6A4.1 C6A5.1 C6J3.1 C7H8.1 EU4G2.5 F3A1.1 F6C1.1 J8H6.1 Q4G4.3 R2B3.1 R2G12.2 R2G21.1 R5A19.1 R5C14.1 R5F12.1 R5G15.1 R6A9.1 R6C17.1 R6J2.1 R6J33.1 R7C7.1 RT3A1.1 RT4A1.1 RT6B1.1 RT7C1.1 RT7J1.1 U6A1.1(VDD) U6A1.3 U6J1.3 U7H4.24
+V5DUAL_USB2_BP1: C3A7.1 C3A8.1 C3A9.1 C3A10.1 C3A11.1 J3A1.31 J3A1.35(VBUS_4) Q3B1.3(C) R3A22.1 R3B11.1 RT3A1.2(B)
+V5DUAL_USB2_FP: C7C8.1 C7C9.1 C7C10.1 J7C7.9(IO9) J7C7.10 R7C13.1 R7C21.1 RT7C1.2(B)
+V5DUAL_USB31_BP0: C3A1.1 C3A2.1 C3A3.1 C3A4.1 C3A5.1 CR3A1.3(C) F3A1.2(B) J3A1.11 J3A1.21 R3A1.1 R3A3.1
+V5DUAL_USB31_BP2: C4A1.1 C4A2.1 C4A3.1 C4A4.1 C4A5.1 CR4A7.3(C) J4A2.1 J4A2.10 R4A1.1 R4A3.1 RT4A1.2(B)
+V5DUAL_USB31_FP1: C6C7.1 C6C8.1 C6C9.1 C6C12.1 F6C1.2(B) J6C3.P10 J6C3.P20(VBUS_2) R6C17.2(B) R6C19.1 R6C20.1
+V5DUAL_USB31_FP2: C6B9.1 C6B10.1 J6B5.1(VBUS) R6B26.1 R6B27.1 RT6B1.2(B)
+V5DUAL_USBC: C5A22.1 C5L11.1 C5L26.1 C5L35.1 EU5A1.1 EU5A1.11 EU5A1.25 EU5A1.46 R5A19.2
+V5DX_AUDIO_FIL: C6A3.1 C6A18.1 C6A21.1 EU6A1.43 FB6A1.2(B) R6A1.1 R6A37.1 R6A42.1
+V5DX_SSD_LS: R6J31.1 U6J1.6
+V5DX_SSD_VDD: C6J4.1 R6J33.2(B) U6J1.1(VDD)
