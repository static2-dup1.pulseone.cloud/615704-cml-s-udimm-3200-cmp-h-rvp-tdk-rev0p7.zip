# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd

Outline 304.8 x 292.1 mm; copper layers: TOP, LAY2, LAY3, LAY4, LAY5, LAY6, LAY7, LAY8, LAY9, BOTTOM. Coordinates in mm from the lower left corner of the outline.
Outline path: 0,287.1 arc(1.46,290.63) 5,292.1 67.34,292.1 67.34,292.1 299.8,292.1 arc(303.34,290.64) 304.8,287.1 304.8,43.1 arc(303.34,39.56) 299.8,38.1 178.8,38.1 arc(178.09,37.81) 177.8,37.1 177.8,5 arc(176.34,1.46) 172.8,0 5,0 arc(1.46,1.46) 0,5 0,287.1

## Design rules (mm)
constraint set DEFAULT: min track width 0.1
net group DIFFPAIR320: nets TP_VCCCORE_PH2_CSN TP_VCCCORE_PH2_CSP
net group DIFFPAIR321: nets TP_VCCCORE_PH4_CSN TP_VCCCORE_PH4_CSP
net group DIFFPAIR322: nets TP_VCCCORE_PH3_CSN TP_VCCCORE_PH3_CSP
net group DIFFPAIR323: nets TP_VCCCORE_PH1_CSN TP_VCCCORE_PH1_CSP
net group DIFFPAIR324: nets TP_VCCCORE_PH6_CSN TP_VCCCORE_PH6_CSP
net group DIFFPAIR325: nets TP_VCCCORE_PH7_CSN TP_VCCCORE_PH7_CSP
net group DIFFPAIR326: nets TP_VCCCORE_PH8_CSN TP_VCCCORE_PH8_CSP
net group DP_DDI_1-85/375: nets DDPB_CTRLCLK DDPB_CTRLDATA
net group HDMI_1-85/375: nets HDMID_SCL HDMID_SDA
net group L_BRIGHTNESS: nets L_BKLTCTL L_BRIGHTNESS
net group LAN_XTL: nets LAN_XTL_DN LAN_XTL_DP
net group SATA1B_TX_CMC: nets SATA1B_TX_CMC_DN SATA1B_TX_CMC_DP
net group SATA_2-85/375: nets SATA1B_DIRECT_TX_DN SATA1B_DIRECT_TX_DP
net group SD3_CLK_R: nets SD3_CLK SD3_CLK_R
net group SD3_D0: nets SD3_D0 SD3_D0_R
net group SD3_D1: nets SD3_D1 SD3_D1_R
net group SD3_D2: nets SD3_D2 SD3_D2_R
net group SD3_D3: nets SD3_D3 SD3_D3_R
net group SPI_CS1_N: nets SPI_CS1_N SPI_CS1_TPM_N
net group SPI_CS2_N: nets SPI_CS2_N SPI_CS2_TPM_N
net group V1P05A_EN: nets SLP_SUS_N V1P05A_EN
net group VSS_EDP_AMOLED: nets VN_ELVSS_EDP_AMOLED VSS_EDP_AMOLED
net group +V3P3A_V1P8A_SPI_DIODE: nets +V3P3A_V1P8A_SPI_DIODE
net group +VDD_EMB_S: nets EMB_VDDEN_D_N EMB_VDDEN_N L_VDDEN
net group BSSB_1-50/125-375: nets GSPI2_MISO_BSSB_CLK GSPI2_MOSI_BSSB_DI ISH_LPSS_GSPI2_MOSI_BSSB_DI USBC_FP3_ACTVSW_DCI_CLK USBC_FP3_ACTVSW_DCI_DATA USBC_FP3_DCI_CLK USBC_FP3_DCI_DATA
net group CFG_CML_PCUDEBUG_: nets CFG_CML_PCUDEBUG_<0> CFG_CML_PCUDEBUG_<1> CFG_CML_PCUDEBUG_<2> CFG_CML_PCUDEBUG_<3> CFG_CML_PCUDEBUG_<4> CFG_CML_PCUDEBUG_<5> CFG_CML_PCUDEBUG_<6> CFG_CML_PCUDEBUG_<7> CFG_CML_PCUDEBUG_<8> CFG_CML_PCUDEBUG_<9> CFG_CML_PCUDEBUG_<10> CFG_CML_PCUDEBUG_<11> CFG_CML_PCUDEBUG_<12> CFG_CML_PCUDEBUG_<13> CFG_CML_PCUDEBUG_<14> CFG_CML_PCUDEBUG_<15>
net group CLINK_1-50/125-375: nets M.2_CLINK_CLK_WLAN M.2_CLINK_DATA_WLAN M.2_CLINK_RST_WLAN_N MLK_CLK MLK_DATA MLK_RST_N
net group CNVI B_1-50/125-375: nets CNV_BRI_DT CNV_BRI_DT_R CNV_BRI_RSP CNV_BRI_RSP_R CNV_RGI_DT CNV_RGI_DT_R CNV_RGI_RSP CNV_RGI_RSP_R
net group CPU SIDEBAND_1-50/300: nets CPU_2_PCH_TRIGGER CPU_2_PCH_TRIGGER_R H_CATERR_N H_PECI H_PM_DOWN H_PM_DOWN_R H_PM_SYNC H_PM_SYNC_R H_PROCHOT_EC_N H_PROCHOT_N H_PROCHOT_R_N H_PWRGD H_PWRGD_R H_THERMTRIP_N PCH_2_CPU_TRIGGER PCH_2_CPU_TRIGGER_R PCH_PECI PCH_THERMTRIP_N PCH_THERMTRIP_R_N PECI_EC PLTRST_CPU_N TPEV_PEG_VIEW_3 VCCST_PWRGD VCCST_PWRGD_CPU VR_SVID_ALERT_N
net group CPUAZA_1-50/125-375: nets HDACPU_SCLK HDACPU_SCLK_R HDACPU_SDI HDACPU_SDI_R HDACPU_SDO HDACPU_SDO_R
net group DD: nets +V_CPU_VREF_CA_DIMM0_CHA +V_CPU_VREF_CA_DIMM1_CHB CK_M_DDR0_A_DN CK_M_DDR0_A_DP CK_M_DDR0_B_DN CK_M_DDR0_B_DP CK_M_DDR1_A_DN CK_M_DDR1_A_DP CK_M_DDR1_B_DN CK_M_DDR1_B_DP CK_M_DDR2_A_DN CK_M_DDR2_A_DP CK_M_DDR2_B_DN CK_M_DDR2_B_DP CK_M_DDR3_A_DN CK_M_DDR3_A_DP CK_M_DDR3_B_DN CK_M_DDR3_B_DP H_SKTOCC_N M_ACT_A_N M_ACT_B_N M_ALERT_A_N M_ALERT_B_N M_BA_A_0 M_BA_A_1 M_BA_B_0 M_BA_B_1 M_BG_A_0 M_BG_A_1 M_BG_B_0 M_BG_B_1 M_DATA_A<0> M_DATA_A<1> M_DATA_A<2> M_DATA_A<3> M_DATA_A<4> M_DATA_A<5> M_DATA_A<6> M_DATA_A<7> M_DATA_A<8> M_DATA_A<9> M_DATA_A<10> M_DATA_A<11> M_DATA_A<12> M_DATA_A<13> M_DATA_A<14> M_DATA_A<15> M_DATA_A<16> M_DATA_A<17> M_DATA_A<18> M_DATA_A<19> M_DATA_A<20> M_DATA_A<21> M_DATA_A<22> M_DATA_A<23> M_DATA_A<24> M_DATA_A<25> M_DATA_A<26> M_DATA_A<27> M_DATA_A<28> M_DATA_A<29> M_DATA_A<30> M_DATA_A<31> M_DATA_A<32> M_DATA_A<33> M_DATA_A<34> M_DATA_A<35> M_DATA_A<36> M_DATA_A<37> M_DATA_A<38> M_DATA_A<39> M_DATA_A<40> M_DATA_A<41> M_DATA_A<42> M_DATA_A<43> M_DATA_A<44> M_DATA_A<45> M_DATA_A<46> M_DATA_A<47> M_DATA_A<48> M_DATA_A<49> M_DATA_A<50> M_DATA_A<51> M_DATA_A<52> M_DATA_A<53> M_DATA_A<54> M_DATA_A<55> M_DATA_A<56> M_DATA_A<57> M_DATA_A<58> M_DATA_A<59> M_DATA_A<60> M_DATA_A<61> M_DATA_A<62> M_DATA_A<63> M_DATA_A_CB<0> M_DATA_A_CB<1> M_DATA_A_CB<2> M_DATA_A_CB<3> M_DATA_A_CB<4> M_DATA_A_CB<5> M_DATA_A_CB<6> M_DATA_A_CB<7> M_DATA_B<0> M_DATA_B<1> M_DATA_B<2> M_DATA_B<3> M_DATA_B<4> M_DATA_B<5> M_DATA_B<6> M_DATA_B<7> M_DATA_B<8> M_DATA_B<9> M_DATA_B<10> M_DATA_B<11> M_DATA_B<12> M_DATA_B<13> M_DATA_B<14> M_DATA_B<15> M_DATA_B<16> M_DATA_B<17> M_DATA_B<18> M_DATA_B<19> M_DATA_B<20> M_DATA_B<21> M_DATA_B<22> M_DATA_B<23> M_DATA_B<24> M_DATA_B<25> M_DATA_B<26> M_DATA_B<27> M_DATA_B<28> M_DATA_B<29> M_DATA_B<30> M_DATA_B<31> M_DATA_B<32> M_DATA_B<33> M_DATA_B<34> M_DATA_B<35> M_DATA_B<36> M_DATA_B<37> M_DATA_B<38> M_DATA_B<39> M_DATA_B<40> M_DATA_B<41> M_DATA_B<42> M_DATA_B<43> M_DATA_B<44> M_DATA_B<45> M_DATA_B<46> M_DATA_B<47> M_DATA_B<48> M_DATA_B<49> M_DATA_B<50> M_DATA_B<51> M_DATA_B<52> M_DATA_B<53> M_DATA_B<54> M_DATA_B<55> M_DATA_B<56> M_DATA_B<57> M_DATA_B<58> M_DATA_B<59> M_DATA_B<60> M_DATA_B<61> M_DATA_B<62> M_DATA_B<63> M_DATA_B_CB<0> M_DATA_B_CB<1> M_DATA_B_CB<2> M_DATA_B_CB<3> M_DATA_B_CB<4> M_DATA_B_CB<5> M_DATA_B_CB<6> M_DATA_B_CB<7> M_DQS_A_DN<0> M_DQS_A_DN<1> M_DQS_A_DN<2> M_DQS_A_DN<3> M_DQS_A_DN<4> M_DQS_A_DN<5> M_DQS_A_DN<6> M_DQS_A_DN<7> M_DQS_A_DN<8> M_DQS_A_DP<0> M_DQS_A_DP<1> M_DQS_A_DP<2> M_DQS_A_DP<3> M_DQS_A_DP<4> M_DQS_A_DP<5> M_DQS_A_DP<6> M_DQS_A_DP<7> M_DQS_A_DP<8> M_DQS_B_DN<0> M_DQS_B_DN<1> M_DQS_B_DN<2> M_DQS_B_DN<3> M_DQS_B_DN<4> M_DQS_B_DN<5> M_DQS_B_DN<6> M_DQS_B_DN<7> M_DQS_B_DN<8> M_DQS_B_DP<0> M_DQS_B_DP<1> M_DQS_B_DP<2> M_DQS_B_DP<3> M_DQS_B_DP<4> M_DQS_B_DP<5> M_DQS_B_DP<6> M_DQS_B_DP<7> M_DQS_B_DP<8> M_MAA_A<0> M_MAA_A<1> M_MAA_A<2> M_MAA_A<3> M_MAA_A<4> M_MAA_A<5> M_MAA_A<6> M_MAA_A<7> M_MAA_A<8> M_MAA_A<9> M_MAA_A<10> M_MAA_A<11> M_MAA_A<12> M_MAA_A<13> M_MAA_A<14> M_MAA_A<15> M_MAA_A<16> M_MAA_B<0> M_MAA_B<1> M_MAA_B<2> M_MAA_B<3> M_MAA_B<4> M_MAA_B<5> M_MAA_B<6> M_MAA_B<7> M_MAA_B<8> M_MAA_B<9> M_MAA_B<10> M_MAA_B<11> M_MAA_B<12> M_MAA_B<13> M_MAA_B<14> M_MAA_B<15> M_MAA_B<16> M_ODT_A<0> M_ODT_A<1> M_ODT_A<2> M_ODT_A<3> M_ODT_B<0> M_ODT_B<1> M_ODT_B<2> M_ODT_B<3> M_PARITY_A M_PARITY_B M_SCKE_A<0> M_SCKE_A<1> M_SCKE_A<2> M_SCKE_A<3> M_SCKE_B<0> M_SCKE_B<1> M_SCKE_B<2> M_SCKE_B<3> M_SCS_A_N<0> M_SCS_A_N<1> M_SCS_A_N<2> M_SCS_A_N<3> M_SCS_B_N<0> M_SCS_B_N<1> M_SCS_B_N<2> M_SCS_B_N<3>
net group DIFFALL: nets CLK_SRC0_M.2_WLAN_DN CLK_SRC0_M.2_WLAN_DP CLK_SRC0_M.2_WLAN_R_DN CLK_SRC0_M.2_WLAN_R_DP CLK_SRC1_LAN_DN CLK_SRC1_LAN_DP CLK_SRC2_M.2_SSD_DN CLK_SRC2_M.2_SSD_DP CLK_SRC3_CPU_SSD_DN CLK_SRC3_CPU_SSD_DP CLK_SRC3_CPU_SSD_R_DN CLK_SRC3_CPU_SSD_R_DP CLK_SRC4_SLOT3_DN CLK_SRC4_SLOT3_DP CLK_SRC5_SLOT2_DN CLK_SRC5_SLOT2_DP CLK_SRC6_TR_DN CLK_SRC6_TR_DP CLK_SRC6_TR_U2_DN CLK_SRC6_TR_U2_DP CLK_SRC6_U2_DN CLK_SRC6_U2_DP CLK_SRC6_U2_R_DN CLK_SRC6_U2_R_DP CLK_SRC7_X16PORT_DN CLK_SRC7_X16PORT_DN_R CLK_SRC7_X16PORT_DP CLK_SRC7_X16PORT_DP_R CLK_SRC8_LAN_FOX_DN CLK_SRC8_LAN_FOX_DP CLK_SRC9_PEGX16_DN CLK_SRC9_PEGX16_DP CLK_SRC10_PEGX16_DN CLK_SRC10_PEGX16_DN_R CLK_SRC10_PEGX16_DP CLK_SRC10_PEGX16_DP_R CLK_SRC11_DN CLK_SRC11_DP CLK_SRC_LAN_FOX_DN CLK_SRC_LAN_FOX_DP CNV_WR_0_DN CNV_WR_0_DP CNV_WR_1_DN CNV_WR_1_DP CNV_WR_CLK_DN CNV_WR_CLK_DP CNV_WR_R_0_DN CNV_WR_R_0_DP CNV_WR_R_1_DN CNV_WR_R_1_DP CNV_WR_R_CLK_DN CNV_WR_R_CLK_DP CNV_WT_0_DN CNV_WT_0_DP CNV_WT_1_DN CNV_WT_1_DP CNV_WT_CLK_DN CNV_WT_CLK_DP CNV_WT_R_0_DN CNV_WT_R_0_DP CNV_WT_R_1_DN CNV_WT_R_1_DP CNV_WT_R_CLK_DN CNV_WT_R_CLK_DP CPU_24MHZ_R_DN CPU_24MHZ_R_DP DDI1_AUX_DN DDI1_AUX_DP DDI1_DP_AUX_C_DN DDI1_DP_AUX_C_DP DDI1_DP_CTRLCLK_AUX_DP DDI1_DP_CTRLDATA_AUX_DN DDI1_DP_TX0_C_DN DDI1_DP_TX0_C_DP DDI1_DP_TX0_L_DN DDI1_DP_TX0_L_DP DDI1_DP_TX1_C_DN DDI1_DP_TX1_C_DP DDI1_DP_TX1_L_DN DDI1_DP_TX1_L_DP DDI1_DP_TX2_C_DN DDI1_DP_TX2_C_DP DDI1_DP_TX2_L_DN DDI1_DP_TX2_L_DP DDI1_DP_TX3_C_DN DDI1_DP_TX3_C_DP DDI1_DP_TX3_L_DN DDI1_DP_TX3_L_DP DDI1_TX0_DN DDI1_TX0_DP DDI1_TX1_DN DDI1_TX1_DP DDI1_TX2_DN DDI1_TX2_DP DDI1_TX3_DN DDI1_TX3_DP DDI2_HDMI_CLK_DN DDI2_HDMI_CLK_DP DDI2_HDMI_DATA0_DN DDI2_HDMI_DATA0_DP DDI2_HDMI_DATA1_DN DDI2_HDMI_DATA1_DP DDI2_HDMI_DATA2_DN DDI2_HDMI_DATA2_DP DDI2_TX0_DN DDI2_TX0_DP DDI2_TX1_DN DDI2_TX1_DP DDI2_TX2_DN DDI2_TX2_DP DDI2_TX3_DN DDI2_TX3_DP DDI3_AUX_DN DDI3_AUX_DP DDI3_AUX_PCON_C_DN DDI3_AUX_PCON_C_DP DDI3_TR_AUX_C_DN DDI3_TR_AUX_C_DP DDI3_TR_TX0_C_DN DDI3_TR_TX0_C_DP DDI3_TR_TX0_R_DN DDI3_TR_TX0_R_DP DDI3_TR_TX1_C_DN DDI3_TR_TX1_C_DP DDI3_TR_TX1_R_DN DDI3_TR_TX1_R_DP DDI3_TR_TX2_C_DN DDI3_TR_TX2_C_DP DDI3_TR_TX2_R_DN DDI3_TR_TX2_R_DP DDI3_TR_TX3_C_DN DDI3_TR_TX3_C_DP DDI3_TR_TX3_R_DN DDI3_TR_TX3_R_DP DDI3_TX0_C_DN DDI3_TX0_C_DP DDI3_TX0_DN DDI3_TX0_DP DDI3_TX1_C_DN DDI3_TX1_C_DP DDI3_TX1_DN DDI3_TX1_DP DDI3_TX2_C_DN DDI3_TX2_C_DP DDI3_TX2_DN DDI3_TX2_DP DDI3_TX3_C_DN DDI3_TX3_C_DP DDI3_TX3_DN DDI3_TX3_DP DDSP_3_AUX_DN DDSP_3_AUX_DP DMI_IT_MR_0_DN DMI_IT_MR_0_DP DMI_IT_MR_1_DN DMI_IT_MR_1_DP DMI_IT_MR_2_DN DMI_IT_MR_2_DP DMI_IT_MR_3_DN DMI_IT_MR_3_DP DMI_MT_IR_0_DN DMI_MT_IR_0_DP DMI_MT_IR_1_DN DMI_MT_IR_1_DP DMI_MT_IR_2_DN DMI_MT_IR_2_DP DMI_MT_IR_3_DN DMI_MT_IR_3_DP EDP_C_TX0_DN EDP_C_TX0_DP EDP_C_TX1_DN EDP_C_TX1_DP EDP_C_TX2_DN EDP_C_TX2_DP EDP_C_TX3_DN EDP_C_TX3_DP EDP_D_TX0_DN EDP_D_TX0_DP EDP_D_TX1_DN EDP_D_TX1_DP EDP_D_TX2_DN EDP_D_TX2_DP EDP_D_TX3_DN EDP_D_TX3_DP EDP_TX0_DN EDP_TX0_DP EDP_TX1_DN EDP_TX1_DP EDP_TX2_DN EDP_TX2_DP EDP_TX3_DN EDP_TX3_DP EMB_AUXN EMB_AUXP EXP_A_RX_0_DN EXP_A_RX_0_DP EXP_A_RX_1_DN EXP_A_RX_1_DP EXP_A_RX_2_DN EXP_A_RX_2_DP EXP_A_RX_3_DN EXP_A_RX_3_DP EXP_A_RX_4_DN EXP_A_RX_4_DP EXP_A_RX_5_DN EXP_A_RX_5_DP EXP_A_RX_6_DN EXP_A_RX_6_DP EXP_A_RX_7_DN EXP_A_RX_7_DP EXP_A_RX_8_DN EXP_A_RX_8_DP EXP_A_RX_9_DN EXP_A_RX_9_DP EXP_A_RX_10_DN EXP_A_RX_10_DP EXP_A_RX_11_DN EXP_A_RX_11_DP EXP_A_RX_12_DN EXP_A_RX_12_DP EXP_A_RX_13_DN EXP_A_RX_13_DP EXP_A_RX_14_DN EXP_A_RX_14_DP EXP_A_RX_15_DN EXP_A_RX_15_DP EXP_A_TX_0_C_DN EXP_A_TX_0_C_DP EXP_A_TX_0_DN EXP_A_TX_0_DP EXP_A_TX_1_C_DN EXP_A_TX_1_C_DP EXP_A_TX_1_DN EXP_A_TX_1_DP EXP_A_TX_2_C_DN EXP_A_TX_2_C_DP EXP_A_TX_2_DN EXP_A_TX_2_DP EXP_A_TX_3_C_DN EXP_A_TX_3_C_DP EXP_A_TX_3_DN EXP_A_TX_3_DP EXP_A_TX_4_C_DN EXP_A_TX_4_C_DP EXP_A_TX_4_DN EXP_A_TX_4_DP EXP_A_TX_5_C_DN EXP_A_TX_5_C_DP EXP_A_TX_5_DN EXP_A_TX_5_DP EXP_A_TX_6_C_DN EXP_A_TX_6_C_DP EXP_A_TX_6_DN EXP_A_TX_6_DP EXP_A_TX_7_C_DN EXP_A_TX_7_C_DP EXP_A_TX_7_DN EXP_A_TX_7_DP EXP_A_TX_8_C_DN EXP_A_TX_8_C_DP EXP_A_TX_8_DN EXP_A_TX_8_DP EXP_A_TX_9_C_DN EXP_A_TX_9_C_DP EXP_A_TX_9_DN EXP_A_TX_9_DP EXP_A_TX_10_C_DN EXP_A_TX_10_C_DP EXP_A_TX_10_DN EXP_A_TX_10_DP EXP_A_TX_11_C_DN EXP_A_TX_11_C_DP EXP_A_TX_11_DN EXP_A_TX_11_DP EXP_A_TX_12_C_DN EXP_A_TX_12_C_DP EXP_A_TX_12_DN EXP_A_TX_12_DP EXP_A_TX_13_C_DN EXP_A_TX_13_C_DP EXP_A_TX_13_DN EXP_A_TX_13_DP EXP_A_TX_14_C_DN EXP_A_TX_14_C_DP EXP_A_TX_14_DN EXP_A_TX_14_DP EXP_A_TX_15_C_DN EXP_A_TX_15_C_DP EXP_A_TX_15_DN EXP_A_TX_15_DP HDMIC_ALS_CLK_DN HDMIC_ALS_CLK_DP HDMIC_ALS_CLK_R_DN HDMIC_ALS_CLK_R_DP HDMIC_ALS_DATA0_DN HDMIC_ALS_DATA0_DP HDMIC_ALS_DATA0_R_DN HDMIC_ALS_DATA0_R_DP HDMIC_ALS_DATA1_DN HDMIC_ALS_DATA1_DP HDMIC_ALS_DATA1_R_DN HDMIC_ALS_DATA1_R_DP HDMIC_ALS_DATA2_DN HDMIC_ALS_DATA2_DP HDMIC_ALS_DATA2_R_DN HDMIC_ALS_DATA2_R_DP HDMID_BP_CLK_DN HDMID_BP_CLK_DP HDMID_BP_DATA0_DN HDMID_BP_DATA0_DP HDMID_BP_DATA1_DN HDMID_BP_DATA1_DP HDMID_BP_DATA2_DN HDMID_BP_DATA2_DP HDMID_CLK_DN HDMID_CLK_DP HDMID_CLK_R_DN HDMID_CLK_R_DP HDMID_TX0_DN HDMID_TX0_DP HDMID_TX0_R_DN HDMID_TX0_R_DP HDMID_TX1_DN HDMID_TX1_DP HDMID_TX1_R_DN HDMID_TX1_R_DP HDMID_TX2_DN HDMID_TX2_DP HDMID_TX2_R_DN HDMID_TX2_R_DP LAN_MDI0_DN LAN_MDI0_DN_FOX LAN_MDI0_DP LAN_MDI0_DP_FOX LAN_MDI1_DN LAN_MDI1_DN_FOX LAN_MDI1_DP LAN_MDI1_DP_FOX LAN_MDI2_DN LAN_MDI2_DN_FOX LAN_MDI2_DP LAN_MDI2_DP_FOX LAN_MDI3_DN LAN_MDI3_DN_FOX LAN_MDI3_DP LAN_MDI3_DP_FOX M.2_SSD_P0_RX_DN M.2_SSD_P0_RX_DP M.2_SSD_P0_RX_R_DN M.2_SSD_P0_RX_R_DP M.2_SSD_P0_TX_C_DN M.2_SSD_P0_TX_C_DP M.2_SSD_P0_TX_CMC_DN M.2_SSD_P0_TX_CMC_DP M.2_SSD_P0_TX_DN M.2_SSD_P0_TX_DP M.2_SSD_P1_RX_DN M.2_SSD_P1_RX_DP M.2_SSD_P1_RX_R_DN M.2_SSD_P1_RX_R_DP M.2_SSD_P1_TX_C_DN M.2_SSD_P1_TX_C_DP M.2_SSD_P1_TX_CMC_DN M.2_SSD_P1_TX_CMC_DP M.2_SSD_P1_TX_DN M.2_SSD_P1_TX_DP M.2_SSD_P2_RX_DN M.2_SSD_P2_RX_DP M.2_SSD_P2_RX_R_DN M.2_SSD_P2_RX_R_DP M.2_SSD_P2_TX_C_DN M.2_SSD_P2_TX_C_DP M.2_SSD_P2_TX_CMC_DN M.2_SSD_P2_TX_CMC_DP M.2_SSD_P2_TX_DN M.2_SSD_P2_TX_DP M.2_SSD_P3_RX_DN M.2_SSD_P3_RX_DP M.2_SSD_P3_RX_R_DN M.2_SSD_P3_RX_R_DP M.2_SSD_P3_TX_C_DN M.2_SSD_P3_TX_C_DP M.2_SSD_P3_TX_CMC_DN M.2_SSD_P3_TX_CMC_DP M.2_SSD_P3_TX_DN M.2_SSD_P3_TX_DP PCH_CPU_BCLK_DN PCH_CPU_BCLK_DP PCH_CPU_BCLK_R_DN PCH_CPU_BCLK_R_DP PCH_CPU_NSSC_CLK_DN PCH_CPU_NSSC_CLK_DP PCH_CPU_PCIBCLK_DN PCH_CPU_PCIBCLK_DP PCH_CPU_PCIBCLK_R_DN PCH_CPU_PCIBCLK_R_DP PCIE3_LAN_FOX_RX_C_DN PCIE3_LAN_FOX_RX_C_DP PCIE3_LAN_FOX_RX_DN PCIE3_LAN_FOX_RX_DP PCIE3_LAN_FOX_TX_C_DN PCIE3_LAN_FOX_TX_C_DP PCIE3_LAN_FOX_TX_DN PCIE3_LAN_FOX_TX_DP PCIE4_M.2_WLAN_RX_DN PCIE4_M.2_WLAN_RX_DP PCIE4_M.2_WLAN_RX_R_DN PCIE4_M.2_WLAN_RX_R_DP PCIE4_M.2_WLAN_TX_C_DN PCIE4_M.2_WLAN_TX_C_DP PCIE4_M.2_WLAN_TX_DN PCIE4_M.2_WLAN_TX_DP PCIE5_TR_RX_C_DN PCIE5_TR_RX_C_DP PCIE5_TR_RX_DN PCIE5_TR_RX_DP PCIE5_TR_TX_C_DN PCIE5_TR_TX_C_DP PCIE5_TR_TX_DN PCIE5_TR_TX_DP PCIE5_TR_U2_RX_DN PCIE5_TR_U2_RX_DP PCIE5_TR_U2_TX_DN PCIE5_TR_U2_TX_DP PCIE5_U2_R_RX_DN PCIE5_U2_R_RX_DP PCIE5_U2_R_TX_DN PCIE5_U2_R_TX_DP PCIE5_U2_RX_DN PCIE5_U2_RX_DP PCIE5_U2_TX_DN PCIE5_U2_TX_DP PCIE6_TR_RX_C_DN PCIE6_TR_RX_C_DP PCIE6_TR_RX_DN PCIE6_TR_RX_DP PCIE6_TR_TX_C_DN PCIE6_TR_TX_C_DP PCIE6_TR_TX_DN PCIE6_TR_TX_DP PCIE6_TR_U2_RX_DN PCIE6_TR_U2_RX_DP PCIE6_TR_U2_TX_DN PCIE6_TR_U2_TX_DP PCIE6_U2_R_RX_DN PCIE6_U2_R_RX_DP PCIE6_U2_R_TX_DN PCIE6_U2_R_TX_DP PCIE6_U2_RX_DN PCIE6_U2_RX_DP PCIE6_U2_TX_DN PCIE6_U2_TX_DP PCIE7_TR_RX_C_DN PCIE7_TR_RX_C_DP PCIE7_TR_RX_DN PCIE7_TR_RX_DP PCIE7_TR_TX_C_DN PCIE7_TR_TX_C_DP PCIE7_TR_TX_DN PCIE7_TR_TX_DP PCIE7_TR_U2_RX_DN PCIE7_TR_U2_RX_DP PCIE7_TR_U2_TX_DN PCIE7_TR_U2_TX_DP PCIE7_U2_R_RX_DN PCIE7_U2_R_RX_DP PCIE7_U2_R_TX_DN PCIE7_U2_R_TX_DP PCIE7_U2_RX_DN PCIE7_U2_RX_DP PCIE7_U2_TX_DN PCIE7_U2_TX_DP PCIE8_TR_RX_C_DN PCIE8_TR_RX_C_DP PCIE8_TR_RX_DN PCIE8_TR_RX_DP PCIE8_TR_TX_C_DN PCIE8_TR_TX_C_DP PCIE8_TR_TX_DN PCIE8_TR_TX_DP PCIE8_TR_U2_RX_DN PCIE8_TR_U2_RX_DP PCIE8_TR_U2_TX_DN PCIE8_TR_U2_TX_DP PCIE8_U2_R_RX_DN PCIE8_U2_R_RX_DP PCIE8_U2_R_TX_DN PCIE8_U2_R_TX_DP PCIE8_U2_RX_DN PCIE8_U2_RX_DP PCIE8_U2_TX_DN PCIE8_U2_TX_DP PCIE9_SLOT3_RX_DN PCIE9_SLOT3_RX_DP PCIE9_SLOT3_RX_R_DN PCIE9_SLOT3_RX_R_DP PCIE9_SLOT3_TX_C_DN PCIE9_SLOT3_TX_C_DP PCIE9_SLOT3_TX_DN PCIE9_SLOT3_TX_DP PCIE10_SLOT3_RX_DN PCIE10_SLOT3_RX_DP PCIE10_SLOT3_RX_R_DN PCIE10_SLOT3_RX_R_DP PCIE10_SLOT3_TX_C_DN PCIE10_SLOT3_TX_C_DP PCIE10_SLOT3_TX_DN PCIE10_SLOT3_TX_DP PCIE11_SLOT3_RX_DN PCIE11_SLOT3_RX_DP PCIE11_SLOT3_RX_R_DN PCIE11_SLOT3_RX_R_DP PCIE11_SLOT3_TX_C_DN PCIE11_SLOT3_TX_C_DP PCIE11_SLOT3_TX_DN PCIE11_SLOT3_TX_DP PCIE12_SLOT3_RX_DN PCIE12_SLOT3_RX_DP PCIE12_SLOT3_RX_R_DN PCIE12_SLOT3_RX_R_DP PCIE12_SLOT3_TX_C_DN PCIE12_SLOT3_TX_C_DP PCIE12_SLOT3_TX_DN PCIE12_SLOT3_TX_DP PCIE13_LAN_RX_C_DN PCIE13_LAN_RX_C_DP PCIE13_LAN_RX_DN PCIE13_LAN_RX_DP PCIE13_LAN_TX_C_DN PCIE13_LAN_TX_C_DP PCIE13_LAN_TX_DN PCIE13_LAN_TX_DP PCIE14_SATA1B_RX_DN PCIE14_SATA1B_RX_DP PCIE14_SATA1B_TX_DN PCIE14_SATA1B_TX_DP PCIE15_SATA2_RX_DN PCIE15_SATA2_RX_DP PCIE15_SATA2_TX_DN PCIE15_SATA2_TX_DP PCIE16_SATA3_RX_DN PCIE16_SATA3_RX_DP PCIE16_SATA3_TX_DN PCIE16_SATA3_TX_DP PCIE21_SLOT2_RX_DN PCIE21_SLOT2_RX_DP PCIE21_SLOT2_RX_R_DN PCIE21_SLOT2_RX_R_DP PCIE21_SLOT2_TX_C_DN PCIE21_SLOT2_TX_C_DP PCIE21_SLOT2_TX_DN PCIE21_SLOT2_TX_DP PCIE22_SLOT2_RX_DN PCIE22_SLOT2_RX_DP PCIE22_SLOT2_RX_R_DN PCIE22_SLOT2_RX_R_DP PCIE22_SLOT2_TX_C_DN PCIE22_SLOT2_TX_C_DP PCIE22_SLOT2_TX_DN PCIE22_SLOT2_TX_DP PCIE23_SLOT2_RX_DN PCIE23_SLOT2_RX_DP PCIE23_SLOT2_RX_R_DN PCIE23_SLOT2_RX_R_DP PCIE23_SLOT2_TX_C_DN PCIE23_SLOT2_TX_C_DP PCIE23_SLOT2_TX_DN PCIE23_SLOT2_TX_DP PCIE24_SLOT2_RX_DN PCIE24_SLOT2_RX_DP PCIE24_SLOT2_RX_R_DN PCIE24_SLOT2_RX_R_DP PCIE24_SLOT2_TX_C_DN PCIE24_SLOT2_TX_C_DP PCIE24_SLOT2_TX_DN PCIE24_SLOT2_TX_DP PINSET_TSENC PINSET_TSENG SATA1B_DIRECT_RX_DN SATA1B_DIRECT_RX_DP SATA1B_DIRECT_TX_CMC_DN SATA1B_DIRECT_TX_CMC_DP SATA1B_RX_DN SATA1B_RX_DP SATA1B_RX_R_DN SATA1B_RX_R_DP SATA1B_TX_DN SATA1B_TX_DP SATA1B_TX_R_DN SATA1B_TX_R_DP SATA2_RX_DN SATA2_RX_DP SATA2_TX_CMC_DN SATA2_TX_CMC_DP SATA2_TX_DN SATA2_TX_DP SATA3_RX_DN SATA3_RX_DP SATA3_TX_CMC_DN SATA3_TX_CMC_DP SATA3_TX_DN SATA3_TX_DP TBTA_RX1_ESD_N TBTA_RX1_ESD_P TBTA_RX2_ESD_N TBTA_RX2_ESD_P TBTA_TX1_C_N TBTA_TX1_C_P TBTA_TX1_ESD_N TBTA_TX1_ESD_P TBTA_TX2_C_N TBTA_TX2_C_P TBTA_TX2_ESD_N TBTA_TX2_ESD_P TP_CLK_ITPXDP_DN TP_CLK_ITPXDP_DP TP_CLKOUT_SRC12_DN TP_CLKOUT_SRC12_DP TP_CLKOUT_SRC13_DN TP_CLKOUT_SRC13_DP TP_CLKOUT_SRC15_DN TP_CLKOUT_SRC15_DP TP_DDI2_AUX_DN TP_DDI2_AUX_DP TP_DPSRC_AUX_N TP_DPSRC_AUX_P TP_DPSRC_ML0_N TP_DPSRC_ML0_P TP_DPSRC_ML1_N TP_DPSRC_ML1_P TP_DPSRC_ML2_N TP_DPSRC_ML2_P TP_DPSRC_ML3_N TP_DPSRC_ML3_P TP_PA_USB2_D_N TP_PA_USB2_D_P TP_PB_USB2_D_N TP_PB_USB2_D_P TP_V1P8A_CSN TP_V1P8A_CSP TP_V3P3_SLOTM_CSN TP_V3P3_SLOTM_CSP TP_V3P3_SLOTM_EAC_CSN TP_V3P3_SLOTM_EAC_CSP TP_V3P3A_CSN TP_V3P3A_CSP TP_V3P3DSW_CSN TP_V3P3DSW_CSP TP_V3P3DX_CPU_SSD2_CSN TP_V3P3DX_CPU_SSD2_CSP TP_V3P3DX_CPU_SSD2_EAC_CSN TP_V3P3DX_CPU_SSD2_EAC_CSP TP_V3P3S_ALS_CSN TP_V3P3S_ALS_CSP TP_V3P3S_CSN TP_V3P3S_CSP TP_V3P3S_DP1_PWR_CSN TP_V3P3S_DP1_PWR_CSP TP_V3P3S_EAC_CSN TP_V3P3S_EAC_CSP TP_V5A_CSN TP_V5A_CSP TP_V5DSW_CSN TP_V5DSW_CSP TP_V5DSW_EAC_CSN TP_V5DSW_EAC_CSP TP_V5S_CSN TP_V5S_CSP TP_V5S_EAC_CSN TP_V5S_EAC_CSP TP_V12S_CSN TP_V12S_CSP TP_V12S_EAC_CSN TP_V12S_EAC_CSP TP_VCCCORE_PH1_EAC_CSN TP_VCCCORE_PH1_EAC_CSP TP_VCCCORE_PH2_EAC_CSN TP_VCCCORE_PH2_EAC_CSP TP_VCCCORE_PH3_EAC_CSN TP_VCCCORE_PH3_EAC_CSP TP_VCCCORE_PH4_EAC_CSN TP_VCCCORE_PH4_EAC_CSP TP_VCCCORE_PH5_CSN TP_VCCCORE_PH5_CSP TP_VCCCORE_PH5_EAC_CSN TP_VCCCORE_PH5_EAC_CSP TP_VCCCORE_PH6_EAC_CSN TP_VCCCORE_PH6_EAC_CSP TP_VCCCORE_PH7_EAC_CSN TP_VCCCORE_PH7_EAC_CSP TP_VCCCORE_PH8_EAC_CSN TP_VCCCORE_PH8_EAC_CSP TP_VCCCORE_VIN_CSN TP_VCCCORE_VIN_CSP TP_VCCCORE_VIN_EAC_CSN TP_VCCCORE_VIN_EAC_CSP TP_VCCDDQ_EAC_CSN TP_VCCDDQ_EAC_CSP TP_VCCGT_PH1_CSN TP_VCCGT_PH1_CSP TP_VCCGT_PH1_EAC_CSN TP_VCCGT_PH1_EAC_CSP TP_VCCGT_PH2_CSN TP_VCCGT_PH2_CSP TP_VCCGT_PH2_EAC_CSN TP_VCCGT_PH2_EAC_CSP TP_VCCGT_VIN_CSN TP_VCCGT_VIN_CSP TP_VCCGT_VIN_EAC_CSN TP_VCCGT_VIN_EAC_CSP TP_VCCIO_0_EAC_NEG TP_VCCIO_0_EAC_POS TP_VCCIO_0_NEG TP_VCCIO_0_POS TP_VCCIO_1_2_EAC_NEG TP_VCCIO_1_2_EAC_POS TP_VCCIO_1_2_NEG TP_VCCIO_1_2_POS TP_VCCSA_CSN TP_VCCSA_CSP TP_VCCSA_EAC_CSN TP_VCCSA_EAC_CSP TP_VCCSA_VIN_CSN TP_VCCSA_VIN_CSP TP_VDDQ_CSN TP_VDDQ_CSP TP_VDDQ_EAC_CSN TP_VDDQ_EAC_CSP TP_VPP_CSN TP_VPP_CSP TP_VPP_EAC_CSN TP_VPP_EAC_CSP TPEV_CML_PCUSTB_0_DN TPEV_CML_PCUSTB_0_DP TPEV_CML_PCUSTB_1_DN TPEV_CML_PCUSTB_1_DP USB2_P1_DN USB2_P1_DP USB2_P1_L_DN USB2_P1_L_DP USB2_P2_DN USB2_P2_DP USB2_P2_L_DN USB2_P2_L_DP USB2_P3_DN USB2_P3_DP USB2_P3_L_DN USB2_P3_L_DP USB2_P4_DN USB2_P4_DP USB2_P4_L_DN USB2_P4_L_DP USB2_P5_DN USB2_P5_DP USB2_P5_L_DN USB2_P5_L_DP USB2_P6_DN USB2_P6_DP USB2_P6_L_DN USB2_P6_L_DP USB2_P7_DN USB2_P7_DP USB2_P8_DN USB2_P8_DP USB2_P8_L_DN USB2_P8_L_DP USB2_P9_CMC_ESD_DN USB2_P9_CMC_ESD_DP USB2_P9_DN USB2_P9_DP USB2_P10_CMC_ESD_DN USB2_P10_CMC_ESD_DP USB2_P10_DN USB2_P10_DP USB2_P11_DN USB2_P11_DP USB2_P11_ESD_DN USB2_P11_ESD_DP USB2_P11_R_DN USB2_P11_R_DP USB2_P11_TTK3_DN USB2_P11_TTK3_DP USB2_P12_DN USB2_P12_DP USB2_P12_ESD_DN USB2_P12_ESD_DP USB2_P13_CMC_ESD_DN USB2_P13_CMC_ESD_DP USB2_P13_DN USB2_P13_DP USB2_P14_DN USB2_P14_DP USB2_P14_M.2_BT_L_DN USB2_P14_M.2_BT_L_DP USB2_TTK_DN USB2_TTK_DP USB2_USBC_BP_CMC_ESD_DN USB2_USBC_BP_CMC_ESD_DP USB31_P1_RX_DN USB31_P1_RX_DP USB31_P1_RX_ESD_DN USB31_P1_RX_ESD_DP USB31_P1_TX_C_DN USB31_P1_TX_C_DP USB31_P1_TX_DN USB31_P1_TX_DP USB31_P1_TX_ESD_DN USB31_P1_TX_ESD_DP USB31_P2_RX_C_DN USB31_P2_RX_C_DP USB31_P2_RX_DN USB31_P2_RX_DP USB31_P2_RX_ESD_DN USB31_P2_RX_ESD_DP USB31_P2_RX_RD_DN USB31_P2_RX_RD_DP USB31_P2_TX_C_DN USB31_P2_TX_C_DP USB31_P2_TX_CMC_DN USB31_P2_TX_CMC_DP USB31_P2_TX_DN USB31_P2_TX_DP USB31_P2_TX_ESD_DN USB31_P2_TX_ESD_DP USB31_P2_TX_RD_DN USB31_P2_TX_RD_DP USB31_P3_RX_C_DN USB31_P3_RX_C_DP USB31_P3_RX_DN USB31_P3_RX_DP USB31_P3_RX_ESD_DN USB31_P3_RX_ESD_DP USB31_P3_RX_RD_DN USB31_P3_RX_RD_DP USB31_P3_TX_C_DN USB31_P3_TX_C_DP USB31_P3_TX_CMC_DN USB31_P3_TX_CMC_DP USB31_P3_TX_DN USB31_P3_TX_DP USB31_P3_TX_ESD_DN USB31_P3_TX_ESD_DP USB31_P3_TX_RD_DN USB31_P3_TX_RD_DP USB31_P4_RX_C_DN USB31_P4_RX_C_DP USB31_P4_RX_DN USB31_P4_RX_DP USB31_P4_RX_ESD_DN USB31_P4_RX_ESD_DP USB31_P4_RX_RD_DN USB31_P4_RX_RD_DP USB31_P4_TX_C_DN USB31_P4_TX_C_DP USB31_P4_TX_CMC_DN USB31_P4_TX_CMC_DP USB31_P4_TX_DN USB31_P4_TX_DP USB31_P4_TX_ESD_DN USB31_P4_TX_ESD_DP USB31_P4_TX_RD_DN USB31_P4_TX_RD_DP USB31_P5_RX_DN USB31_P5_RX_DP USB31_P5_RX_R_DN USB31_P5_RX_R_DP USB31_P5_TX_C_CMC_ESD_DN USB31_P5_TX_C_CMC_ESD_DP USB31_P5_TX_C_DN USB31_P5_TX_C_DP USB31_P5_TX_DN USB31_P5_TX_DP USB31_P6_RX_DN USB31_P6_RX_DP USB31_P6_RX_FP3_DN USB31_P6_RX_FP3_DP USB31_P6_TX_DN USB31_P6_TX_DP USB31_P6_TX_FP3_DN USB31_P6_TX_FP3_DP USB31_P7_RX_C_DN USB31_P7_RX_C_DP USB31_P7_RX_DN USB31_P7_RX_DP USB31_P7_RX_ESD_DN USB31_P7_RX_ESD_DP USB31_P7_RX_RD_DN USB31_P7_RX_RD_DP USB31_P7_TX_C_DN USB31_P7_TX_C_DP USB31_P7_TX_CMC_DN USB31_P7_TX_CMC_DP USB31_P7_TX_DN USB31_P7_TX_DP USB31_P7_TX_ESD_DN USB31_P7_TX_ESD_DP USB31_P7_TX_RD_DN USB31_P7_TX_RD_DP USB31_P8_RX_DN USB31_P8_RX_DP USB31_P8_RX_R_DN USB31_P8_RX_R_DP USB31_P8_TX_C_CMC_ESD_DN USB31_P8_TX_C_CMC_ESD_DP USB31_P8_TX_C_DN USB31_P8_TX_C_DP USB31_P8_TX_DN USB31_P8_TX_DP USBC_FP3_RX1_DN USBC_FP3_RX1_DP USBC_FP3_RX1_R_DN USBC_FP3_RX1_R_DP USBC_FP3_RX2_DN USBC_FP3_RX2_DP USBC_FP3_RX2_R_DN USBC_FP3_RX2_R_DP USBC_FP3_TX1_C_CMC_ESD_DN USBC_FP3_TX1_C_CMC_ESD_DP USBC_FP3_TX1_C_DN USBC_FP3_TX1_C_DP USBC_FP3_TX1_DN USBC_FP3_TX1_DP USBC_FP3_TX2_C_CMC_ESD_DN USBC_FP3_TX2_C_CMC_ESD_DP USBC_FP3_TX2_C_DN USBC_FP3_TX2_C_DP USBC_FP3_TX2_DN USBC_FP3_TX2_DP V1P05A_SENSE_EAC_NEG V1P05A_SENSE_EAC_POS V1P05A_SENSE_NEG V1P05A_SENSE_POS V5.0DX_SSD_SENSE_EAC_NEG V5.0DX_SSD_SENSE_EAC_POS V5.0DX_SSD_SENSE_NEG V5.0DX_SSD_SENSE_POS VCCCORE_SENSE_N VCCCORE_SENSE_P VCCGT_NTC1N VCCGT_NTC1P VCCGT_SENSE VCCGT_TSEN VCCMPHY_SENSE VCCPDSW_3P3A_SENSE_EAC_NEG VCCPDSW_3P3A_SENSE_EAC_POS VCCPDSW_3P3A_SENSE_NEG VCCPDSW_3P3A_SENSE_POS VCCPRIM_1P8_SENSE_EAC_NEG VCCPRIM_1P8_SENSE_EAC_POS VCCPRIM_1P8_SENSE_NEG VCCPRIM_1P8_SENSE_POS VCORE_NTC1N VCORE_NTC1P VCORE_TSEN VSSGT_SENSE VSSMPHY_SENSE
net group EC_SHD_IO0: nets EC_SHD_IO0 EC_SHD_IO0_AIC EC_SHD_IO0_R EC_SPI_MOSI SPI_MOSI SPI_MOSI_EC SPI_MOSI_FLASH SPI_MOSI_SW SPI_MOSI_TPM
net group EC_SHD_IO1: nets EC_SHD_IO1 EC_SHD_IO1_AIC EC_SHD_IO1_R EC_SPI_MISO SPI_MISO SPI_MISO_EC SPI_MISO_FLASH SPI_MISO_SW SPI_MISO_TPM
net group EC_SHD_IO2: nets EC_SHD_IO2 EC_SHD_IO2_R EC_SPI_WP_N SPI_DQ2_TPM SPI_IO2 SPI_IO2_EC SPI_IO2_SW SPI_WP0_FLASH_N
net group EC_SHD_IO3: nets EC_SHD_IO3 EC_SHD_IO3_R EC_SPI_HOLD_N SPI_DQ3_TPM SPI_HOLD0_FLASH_N SPI_IO3 SPI_IO3_EC SPI_IO3_SW
net group EC_SPI_CS_N: nets EC_SHD_CS_AIC_N EC_SHD_CS_N EC_SHD_CS_N_R EC_SPI_CS_N
net group EC_SPI_SCLK: nets EC_SHD_SCLK EC_SHD_SCLK_AIC EC_SHD_SCLK_R EC_SPI_SCLK SPI_CLK SPI_CLK_EC SPI_CLK_FLASH SPI_CLK_SW SPI_CLK_TPM
net group ESPI_1-50/125-375: nets RCIN_ESPI_ALRT1_HDR_N RCIN_ESPI_ALRT1_N RCIN_N_EC SUS_STAT_ESPI_RST_EC_AIC_N SUS_STAT_ESPI_RST_EC_N SUS_STAT_ESPI_RST_N
net group GSPI_2-50/125-375: nets ISH_SPI_CLK_SNSR_HDR ISH_SPI_MISO_SNSR_HDR ISH_SPI_MOSI_SNSR_HDR LPSS_GSPI0_CLK LPSS_GSPI0_CLK_R LPSS_GSPI0_CS0_N LPSS_GSPI0_CS0_R_N LPSS_GSPI0_CS1_N LPSS_GSPI0_CS1_R_N LPSS_GSPI0_MISO LPSS_GSPI0_MISO_R LPSS_GSPI0_MOSI LPSS_GSPI0_MOSI_R LPSS_GSPI1_CLK LPSS_GSPI1_CLK_R LPSS_GSPI1_CS0_N LPSS_GSPI1_CS0_R_N LPSS_GSPI1_CS1_N LPSS_GSPI1_CS1_R_N LPSS_GSPI1_MISO LPSS_GSPI1_MISO_R LPSS_GSPI1_MOSI LPSS_GSPI1_MOSI_R
net group HDA_2_50-125-375: nets HDA_CODEC_BCLK HDA_CODEC_BCLK_R HDA_CODEC_SDI HDA_CODEC_SDI_R HDA_CODEC_SDO HDA_CODEC_SYNC
net group HDMI DDI_1-85/375: nets DDI2_HDMI_ALS_CTRLCLK DDI2_HDMI_ALS_CTRLDATA DDPC_CTRLCLK DDPC_CTRLDATA HDMIC_ALS_SCL HDMIC_ALS_SDA
net group I2S_2_50-125-375: nets HDA_BCLK_I2S0_SCLK HDA_BCLK_I2S0_SCLK_HDR HDA_SDI0_I2S0_RXD_HDR HDA_SDI0_I2S0_RXD_HDR_R HDA_SDI_0_I2S0_RXD HDA_SDI_1_I2S1_RXD_HDR HDA_SDO_I2S0_TXD HDA_SDO_I2S0_TXD_HDR HDA_SYNC_I2S0_SFRM HDA_SYNC_I2S0_SFRM_HDR I2S1_SCLK I2S1_SCLK_POST1_I2S_BCLK I2S1_SFRM I2S1_SFRM_POST1_I2S_LRCLK I2S1_TXD I2S2_RXD I2S2_RXD_HDR I2S2_SCLK I2S2_SCLK_HDR I2S2_SFRM I2S2_SFRM_HDR I2S2_TXD I2S2_TXD_HDR M.2_BT_PCMCLK M.2_BT_PCMFRM_CRF_RST_N M.2_BT_PCMIN M.2_BT_PCMOUT_CLKREQ0 SSP1_TXD_SDW2_DATA_POST1_OUT
net group KBC_SCANOUT: nets KBC_SCANOUT<1> KBC_SCANOUT<2> KBC_SCANOUT<3> KBC_SCANOUT<4> KBC_SCANOUT<5> KBC_SCANOUT<6> KBC_SCANOUT<7> KBC_SCANOUT<9> KBC_SCANOUT<10> KBC_SCANOUT<12> KBC_SCANOUT<13>
net group LAD_ESPI_IO_0: nets LAD_ESPI_IO_0 LAD_ESPI_IO_0_EC LAD_ESPI_IO_0_EC_AIC LAD_ESPI_IO_0_HDR LAD_ESPI_IO_0_R
net group LAD_ESPI_IO_1: nets LAD_ESPI_IO_1 LAD_ESPI_IO_1_EC LAD_ESPI_IO_1_EC_AIC LAD_ESPI_IO_1_HDR LAD_ESPI_IO_1_R
net group LAD_ESPI_IO_2: nets LAD_ESPI_IO_2 LAD_ESPI_IO_2_EC LAD_ESPI_IO_2_EC_AIC LAD_ESPI_IO_2_HDR LAD_ESPI_IO_2_R
net group LAD_ESPI_IO_3: nets LAD_ESPI_IO_3 LAD_ESPI_IO_3_EC LAD_ESPI_IO_3_EC_AIC LAD_ESPI_IO_3_HDR LAD_ESPI_IO_3_R
net group LFRAME_ESPI_CS0_EC_AIC_N: nets LFRAME_ESPI_CS0_EC_AIC_N LFRAME_ESPI_CS0_EC_N LFRAME_ESPI_CS0_HDR_N LFRAME_ESPI_CS0_N LFRAME_ESPI_CS0_R_N
net group LPC_CLK1_R: nets LPC_CLK1 LPC_CLK1_R LPC_ESPI_CLK_HDR
net group LPC_ESPI_CLK: nets LPC_ESPI_CLK LPC_ESPI_CLK_EC LPC_ESPI_CLK_EC_AIC LPC_ESPI_CLK_R
net group PIRQ_N: nets PIRQ_ESPI_ALRT0_N PIRQ_N SERIRQ_ESPI_ALERT0_EC
net group RTC_1-50/200: nets PCH_RTCX1 PCH_RTCX1_XTAL PCH_RTCX2 PCH_RTCXO_XTAL
net group SD3_2-50/250-375: nets SD3_CD_R_N SD3_CDB SD3_CMD SD3_CMD_R SD3_WP
net group SERIRQ_ESPI_CS1_HDR_N: nets SERIRQ_ESPI_CS1_HDR_N SERIRQ_ESPI_CS1_MECC_N SERIRQ_ESPI_CS1_N
net group SMB_SML_2-50/125-375: nets ISH_EEPROM_CLK ISH_EEPROM_DATA ISH_I2C0_SCL ISH_I2C0_SCL_SNSR_HDR ISH_I2C0_SDA ISH_I2C0_SDA_SNSR_HDR ISH_I2C1_SCL ISH_I2C1_SCL_SNSR_HDR ISH_I2C1_SDA ISH_I2C1_SDA_SNSR_HDR ISH_I2C2_LPSS_I2C3_SCL ISH_I2C2_LPSS_I2C3_SDA ISH_I2C2_SCL_SNSR_HDR ISH_I2C2_SDA_SNSR_HDR LPSS_I2C0_SCL LPSS_I2C0_SDA LPSS_I2C1_SCL LPSS_I2C1_SDA
net group SOUND_2-50/125-375: nets DMIC0_SDW4_CLK_HDR DMIC0_SDW4_DATA_HDR DMIC1_SDW3_CLK_HDR DMIC1_SDW3_DATA_HDR DMIC_CLK_0 DMIC_CLK_1 DMIC_DATA_0 DMIC_DATA_1 HDA_RST_N_SNDW1_CLK HDA_RST_N_SW1_CK_I2S_MCLK_HDR HDA_SDI_1_I2S1_RXD HDA_SDI_1_I2S1_RXD_SW1_DATA I2S1_SFRM_SNDW2_CLK I2S1_SFRM_SNDW2_CLK_R I2S1_TXD_SNDW2_DATA I2S1_TXD_SNDW2_DATA_R SNDW1_CLK_HDR SNDW1_DATA_HDR SNDW2_CLK SNDW2_DATA SOC_DMIC0_SDW3_DATA SOC_DMIC0_SDW4_CLK SOC_DMIC0_SDW4_DATA SOC_DMIC1_SDW3_CLK
net group SPI 1_1-50/125-375: nets SPI1_TCHPNL_CLK SPI1_TCHPNL_CS_N SPI1_TCHPNL_IO2 SPI1_TCHPNL_IO2_R SPI1_TCHPNL_IO3 SPI1_TCHPNL_IO3_R SPI1_TCHPNL_MISO SPI1_TCHPNL_MOSI TCH_PNL_SPI1_CLK_I2C_MODE_SEL TCH_PNL_SPI1_CS_N TCH_PNL_SPI1_MISO_I2C1_SDA TCH_PNL_SPI1_MOSI_I2C1_SCL
net group SPI_CS0_FLASH_N: nets SPI_CS0_EC_N SPI_CS0_FLASH_N SPI_CS0_N SPI_CS0_SW_N SPI_CS0_TPM_N
net group SUSCLK_2-50/375: nets CPU_RTCCLK CPU_SUSCLK EC_SUS_CLK M.2_BTWIFI_SUS_CLK PCH_SUSCLK SSD_SUS_CLK
net group SVID_1-50/375: nets CPU_VIDALERT_N CPU_VIDSCK CPU_VIDSOUT H_CPU_SVIDALRT_R_N H_CPU_SVIDCLK_R H_CPU_SVIDDAT_R VR_SVID_ALERT_N_R VR_SVID_CLK VR_SVID_CLK_R VR_SVID_DATA VR_SVID_DATA_R
net group UART_2-50/125-375: nets CNV_MFUART2_RXD CNV_MFUART2_RXD_R CNV_MFUART2_TXD CNV_MFUART2_TXD_R ISH_UART0_CTS_N LPSS_ISH_UART1_CTS_N LPSS_ISH_UART1_RTS_N LPSS_ISH_UART1_RXD LPSS_ISH_UART1_TXD LPSS_UART0_CTS_N LPSS_UART0_CTS_R_N LPSS_UART0_RTS_N LPSS_UART0_RTS_R_N LPSS_UART0_RXD LPSS_UART0_RXD_R LPSS_UART0_TXD LPSS_UART0_TXD_R LPSS_UART2_CTS_N LPSS_UART2_CTS_R_N LPSS_UART2_RTS_N LPSS_UART2_RTS_R_N LPSS_UART2_RXD LPSS_UART2_RXD_R LPSS_UART2_TXD LPSS_UART2_TXD_R
net group VCCSA_EN: nets VCCSA_EN VR_ENABLE VR_ENABLE_C10
net group XTAL_1-50/200: nets XTAL_PCH_24M_IN XTAL_PCH_24M_IN_R XTAL_PCH_24M_OUT XTAL_PCH_24M_OUT_R

## Placement (name value [footprint] x y rotation side)
BH9C1  -  [BH_C68619001MA]  22.6 225.29 0 top
C1A1  470pF  [SMC0603IA]  292.73 266.83 0 top
C1A2  470pF  [SMC0603IA]  292.73 265.43 0 top
C1A3  4.7UF  [SMC0603IA]  289.43 260.09 0 top
C1B1  10uF  [SMC0603IA]  286.89 257.81 90 top
C1B2  10uF  [SMC0603IA]  292.22 255.01 270 top
C1B3  0.1uF  [SMC0402IA]  288.16 250.82 90 top
C1B4  0.1uF  [SMC0402IA]  294.89 249.3 90 top
C1B5  0.1uF  [SMC0402IA]  295.14 246.38 90 top
C1B6  82pF  [SMC0402IA]  281.81 243.33 90 top
C1B7  22uF  [SMC0603ID]  293.49 241.55 90 top
C1B8  22uF  [SMC0603ID]  295.02 241.55 90 top
C1B9  82pF  [SMC0402IB]  281.43 241.43 0 top
C1B10  100pF  [SMC0402IA]  280.54 241.3 180 top
C1B11  0.1uF  [SMC0402IA]  292.6 240.16 0 top
C1B12  0.1uF  [SMC0402IA]  292.6 239.01 0 top
C1B13  0.1uF  [SMC0402IA]  291.97 238.12 0 top
C1B14  0.1uF  [SMC0402IA]  291.97 237.23 0 top
C1B15  0.1uF  [SMC0402IA]  291.97 236.35 0 top
C1B16  0.22uF  [SMC0402IA]  287.4 235.96 0 top
C1B17  0.1uF  [SMC0402IA]  291.97 235.46 0 top
C1B18  0.1uF  [SMC0402IA]  291.97 234.57 0 top
C1B19  0.1uF  [SMC0402IA]  291.97 233.68 0 top
C1B20  0.1uF  [SMC0402IA]  291.97 232.79 0 top
C1B21  0.1uF  [SMC0402IA]  291.97 231.9 0 top
C1B22  0.1uF  [SMC0402IA]  286.13 227.2 0 top
C1C1  56pF  [SMC0402IA]  282.7 226.31 0 top
C1C2  0.1uF  [SMC0402IA]  284.48 226.31 0 top
C1C3  470uF  [CPRC68_250PMA]  292.35 225.8 180 top
C1C4  0.1uF  [SMC0402IA]  286.13 225.42 0 top
C1C5  0.1uF  [SMC0402IA]  284.6 224.66 270 top
C1C6  120PF  [SMC0402IA]  282.09 223.8 0 top
C1C7  82pF  [SMC0402IB]  283.71 223.65 270 top
C1C8  22uF  [SMC0603ID]  289.94 223.14 270 top
C1C9  0.1uF  [SMC0402IA]  299.59 221.36 90 top
C1C10  0.047uF  [SMC0402IA]  296.54 219.71 180 top
C1C11  0.1uF  [SMC0402IA]  296.92 213.99 0 top
C1C12  0.1uF  [SMC0402IA]  296.92 211.96 0 top
C1C13  0.1uF  [SMC0402IA]  285.11 211.71 180 top
C1C14  0.1uF  [SMC0402IA]  297.81 210.95 180 top
C1C15  0.1uF  [SMC0402IA]  285.11 209.68 180 top
C1D1  10uF  [SMC0603IA]  282.7 188.59 180 top
C1D2  10uF  [SMC0603IA]  286 187.32 0 top
C1D3  0.1uF  [SMC0603IA]  286 184.78 0 top
C1D4  1uF  [SMC0402IA]  285.49 182.62 270 top
C1D5  1uF  [SMC0402IA]  282.7 180.59 180 top
C1D6  470uF  [CPRC100_500PMA]  288.54 178.18 90 top
C1D7  10uF  [SMC0603IA]  282.57 176.53 180 top
C1D8  10uF  [SMC0603IA]  282.6 175.26 180 top
C1D9  0.1uF  [SMC0603IA]  286.02 171.32 0 top
C1D10  1uF  [SMC0402IA]  286.02 169.92 270 top
C1D11  1uF  [SMC0402IA]  282.72 167.13 180 top
C1D12  0.1uF  [SMC0402IA]  291.84 163.83 90 top
C1D13  0.1uF  [SMC0402IA]  287.02 162.3 0 top
C1D14  30V  [SOD123IB]  60.19 80.39 0 top
C1E1  0.1uF  [SMC0402IA]  293.24 161.54 0 top
C1E2  0.1uF  [SMC0402IA]  293.24 159.26 0 top
C1E3  0.1uF  [SMC0402IA]  284.6 157.61 90 top
C1E4  0.1uF  [SMC0402IA]  286 155.32 0 top
C1E5  0.01uF  [SMC0603IA]  295.65 155.19 90 top
C1E6  0.1uF  [SMC0402IA]  286 153.03 0 top
C1E7  0.1uF  [SMC0603IA]  295.65 148.84 270 top
C1E8  0.1uF  [SMC0402IA]  280.28 146.43 0 top
C1E9  0.1uF  [SMC0402IA]  286.51 145.67 0 top
C1E10  0.1uF  [SMC0402IA]  286.51 143.38 0 top
C1E11  1uF  [SMC0402IA]  293.62 137.54 180 top
C1E13  0.01uF  [SMC0402IA]  283.43 133.48 90 top
C1E14  2.2UF  [SMC0402IA]  284.32 133.48 90 top
C1F1  0.022uF  [SMC0402IA]  292.86 117.85 180 top
C1F2  0.01uF  [SMC0402IA]  281.94 116.58 270 top
C1F3  2.2UF  [SMC0402IA]  283.08 116.58 270 top
C1F4  0.022uF  [SMC0402IA]  290.95 115.95 90 top
C1F7  0.022uF  [SMC0402IA]  291.97 108.58 0 top
C1F8  0.01uF  [SMC0402IA]  281.94 106.3 0 top
C1F9  2.2UF  [SMC0402IA]  284.48 106.3 180 top
C1F12  0.022uF  [SMC0402IA]  291.97 97.41 180 top
C1G1  2.2UF  [SMC0402IA]  281.68 97.03 270 top
C1G2  0.01uF  [SMC0402IA]  282.82 97.03 270 top
C1P1  10uF  [SMC0603IA]  282.7 188.59 180 bottom
C1P2  680pF  [SMC0402IA]  280.28 187.45 0 bottom
C1P3  10uF  [SMC0603IA]  282.57 175.13 180 bottom
C2A1  0.1uF  [SMC0402IA]  252.09 286.64 0 top
C2A2  0.1uF  [SMC0402IA]  274.57 285.75 90 top
C2A3  22uF  [SMC0805IA]  251.58 285.37 0 top
C2A4  22uF  [SMC0805IA]  275.84 284.73 90 top
C2A5  22uF  [SMC0805IA]  277.62 284.73 90 top
C2A6  22uF  [SMC0805IA]  251.58 283.59 0 top
C2A7  22uF  [SMC0805IA]  277.36 278.89 180 top
C2A8  22uF  [SMC0805IA]  279.14 278.89 0 top
C2A9  0.1uF  [SMC0402IA]  279.14 277.37 0 top
C2A10  100pF  [SMC0603IA]  246.5 277.11 270 top
C2A11  0.1uF  [SMC0402IA]  250.95 270.25 90 top
C2A12  0.1uF  [SMC0402IA]  251.84 270.25 90 top
C2A13  0.1uF  [SMC0402IA]  260.09 269.49 90 top
C2A14  0.1uF  [SMC0402IA]  260.98 269.49 90 top
C2A15  0.1uF  [SMC0402IA]  262 269.49 90 top
C2A16  0.1uF  [SMC0402IA]  262.89 269.49 90 top
C2A17  0.1uF  [SMC0402IA]  263.9 269.49 90 top
C2A18  0.1uF  [SMC0402IA]  264.79 269.49 90 top
C2A19  0.1uF  [SMC0402IA]  265.68 269.49 90 top
C2A20  0.1uF  [SMC0402IA]  266.57 269.49 90 top
C2A21  0.1uF  [SMC0402IA]  275.18 268.6 180 top
C2A22  100pF  [SMC0402IA]  273.3 268.48 90 top
C2A23  100pF  [SMC0402IA]  273.3 267.46 270 top
C2A24  0.1uF  [SMC0402IA]  275.18 267.46 180 top
C2A25  22uF  [SMC0603ID]  267.97 263.65 0 top
C2A26  1uF  [SMC0402IA]  251.58 263.14 180 top
C2A27  0.01uF  [SMC0402IA]  258.95 261.36 270 top
C2A28  4700pF  [SMC0402MA]  275.2 260.86 0 top
C2A29  0.1uF  [SMC0402IA]  253.11 260.48 90 top
C2A30  0.1uF  [SMC0402IA]  254 260.48 90 top
C2A31  0.1uF  [SMC0402IA]  256.41 260.48 90 top
C2A32  0.1uF  [SMC0402IA]  257.3 260.48 90 top
C2A33  10uF  [SMC0603IA]  274.57 259.84 0 top
C2B1  0.1uF  [SMC0402IA]  244.47 259.21 90 top
C2B2  0.1uF  [SMC0402IA]  255.27 258.7 90 top
C2B3  0.1uF  [SMC0402IA]  256.15 258.7 90 top
C2B4  0.1uF  [SMC0402IA]  258.69 258.06 90 top
C2B5  0.1uF  [SMC0402IA]  259.58 258.06 90 top
C2B6  470uF  [CPRC100_500PMA]  273.05 251.71 90 top
C2B7  0.1uF  [SMC0603IA]  243.96 246.89 90 top
C2B8  1uF  [SMC0402IA]  245.36 246.89 0 top
C2B9  0.1uF  [SMC0603IA]  253.87 246.89 90 top
C2B10  0.1uF  [SMC0603IA]  266.95 246.89 90 top
C2B11  1uF  [SMC0402IA]  254.88 246.63 0 top
C2B12  10uF  [SMC0603IA]  262.38 243.97 270 top
C2B13  1uF  [SMC0402IA]  248.15 243.58 270 top
C2B14  1uF  [SMC0402IA]  258.06 243.58 270 top
C2B15  10uF  [SMC0603IA]  263.65 243.58 270 top
C2B16  1uF  [SMC0402IA]  271.39 243.58 270 top
C2B17  10uF  [SMC0603IA]  249.14 243.46 270 top
C2B18  10uF  [SMC0603IA]  250.31 243.46 270 top
C2B19  680pF  [SMC0402IA]  259.84 242.44 0 top
C2B20  100pF  [SMC0402IA]  279.27 238.58 0 top
C2B21  1uF  [SMC0402MA]  275.2 236.22 90 top
C2B22  0.47uF  [SMC0402IA]  273.55 229.49 180 top
C2B23  4.7uF  [SMC0402IA]  279.14 227.2 180 top
C2C1  47pF  [SMC0402IA]  277.62 225.3 90 top
C2C2  470uF  [CPRC34_250PMA]  246.5 222.63 90 top
C2C3  470uF  [CPRC34_250PMA]  263.82 196.34 180 top
C2D1  470uF  [CPRC34_250PMA]  269.87 194.56 90 top
C2D2  47uF  [SMC0805IA]  261.11 188.85 90 top
C2D3  470uF  [CPRC34_250PMA]  265.55 188.59 0 top
C2D4  47uF  [SMC0805IA]  261.11 181.99 90 top
C2D5  470uF  [CPRC34_250PMA]  265.55 180.21 0 top
C2D6  47uF  [SMC0805IA]  261.11 177.42 270 top
C2D7  470uF  [CPRC34_250PMA]  264.92 172.21 0 top
C2E1  0.1uF  [SMC0402IA]  279.78 156.08 0 top
C2F1  1uF  [SMC0402IA]  273.81 116.46 0 top
C2F2  10uF  [SMC0402MC]  258.06 116.33 180 top
C2F3  10uF  [SMC0402MC]  261.11 116.33 0 top
C2F4  10uF  [SMC0402MC]  265.55 116.33 0 top
C2F5  22uF  [SMC0603ID]  268.73 116.33 0 top
C2F6  22uF  [SMC0805IA]  249.68 116.08 0 top
C2G1  0.1uF  [SMC0402IA]  248.28 96.77 0 top
C2G2  680pF  [SMC0402IA]  272.16 95.88 0 top
C2G3  100uF  [SMC1206IA]  249.68 92.58 90 top
C2G4  100uF  [SMC1206IA]  251.71 92.58 90 top
C2G5  100uF  [SMC1206IA]  253.74 92.58 90 top
C2G6  100uF  [SMC1206IA]  255.77 92.58 90 top
C2G7  100uF  [SMC1206IA]  257.81 92.58 90 top
C2G8  22uF  [SMC0805IA]  245.74 89.15 270 top
C2G9  1uF  [SMC0603IA]  255.27 87.76 0 top
C2G10  0.1uF  [SMC0402IA]  274.44 87.37 0 top
C2G11  1uF  [SMC0603IA]  274.32 86.1 0 top
C2G12  10uF  [SMC0603IA]  262.76 85.85 180 top
C2G13  10uF  [SMC0603IA]  262.76 84.45 180 top
C2G14  22uF  [SMC0805IA]  274.19 84.45 0 top
C2G15  0.1uF  [SMC0402IA]  265.04 84.33 90 top
C2G16  10uF  [SMC0603IB]  258.06 83.69 90 top
C2G17  10uF  [SMC0603IB]  259.46 83.69 90 top
C2G18  22uF  [SMC0805IA]  270.38 82.29 270 top
C2G19  22uF  [SMC0805IA]  272.28 82.29 270 top
C2G20  0.033uF  [SMC0402IA]  259.58 80.64 180 top
C2G21  2.2UF  [SMC0402IA]  266.31 80.26 0 top
C2G22  0.1uF  [SMC0402IA]  260.73 79.75 180 top
C2G23  2200pF  [SMC0402IA]  260.98 77.72 270 top
C2G24  0.01uF  [SMC0402IA]  259.08 77.34 180 top
C2G25  0.1uF  [SMC0402IA]  248.66 75.18 270 top
C2G26  1uF  [SMC0402IA]  268.6 73.28 270 top
C2G27  1uF  [SMC0402IA]  269.49 73.28 270 top
C2L1  0.1uF  [SMC0402IA]  256.92 268.98 270 bottom
C2L2  0.1uF  [SMC0402IA]  255.9 268.98 270 bottom
C2L3  0.01uF  [SMC0402IA]  254.88 268.98 270 bottom
C2L4  0.01uF  [SMC0402IA]  252.98 266.83 0 bottom
C2L5  0.1uF  [SMC0402IA]  259.08 266.57 180 bottom
C2L6  0.1uF  [SMC0402IA]  252.98 265.94 0 bottom
C2L7  0.01uF  [SMC0402IA]  259.08 265.68 180 bottom
C2L8  0.1uF  [SMC0402IA]  259.08 264.79 180 bottom
C2L9  0.1uF  [SMC0402IA]  258.31 262.89 90 bottom
C2L10  0.01uF  [SMC0402IA]  257.42 262.89 90 bottom
C2L11  4.7uF  [SMC0402IA]  256.54 262.89 90 bottom
C2L12  0.1uF  [SMC0402IA]  255.65 262.89 90 bottom
C2M1  4.7uF  [SMC0402IA]  258.69 247.01 0 bottom
C2M2  10uF  [SMC0603IA]  251.07 243.58 270 bottom
C2M3  10uF  [SMC0603IA]  264.28 244.13 270 bottom
C2M4  1uF  [SMC0402IA]  256.28 243.33 270 bottom
C2M5  0.1uF  [SMC0402IA]  258.92 241.83 180 bottom
C2M6  0.1uF  [SMC0402IA]  259.71 241.81 0 bottom
C2M7  0.47uF  [SMC0402IA]  261.62 241.43 270 bottom
C2M8  0.1uF  [SMC0402IA]  259.71 240.03 270 bottom
C2M9  0.1uF  [SMC0402IA]  258.82 240.03 270 bottom
C2M10  680pF  [SMC0402IA]  247.77 239.9 180 bottom
C2M11  680pF  [SMC0402IA]  249.8 239.77 0 bottom
C2P1  680pF  [SMC0402IA]  279.27 173.86 0 bottom
C3A1  0.1uF  [SMC0402IA]  223.9 285.88 90 top
C3A2  0.1uF  [SMC0402IA]  224.79 285.88 90 top
C3A3  470pF  [SMC0402IA]  225.67 285.88 90 top
C3A4  4.7UF  [SMC0603IA]  226.69 285.24 90 top
C3A5  470uF  [CPRC68_250PMA]  226.94 281.94 0 top
C3A6  0.1uF  [SMC0402IA]  233.8 278.76 90 top
C3A7  0.1uF  [SMC0402IA]  223.52 276.35 90 top
C3A8  0.1uF  [SMC0402IA]  224.4 276.35 90 top
C3A9  470uF  [CPRC68_250PMA]  226.94 274.06 0 top
C3A10  470pF  [SMC0402IA]  231.26 272.92 270 top
C3A11  4.7UF  [SMC0603IA]  233.17 272.92 270 top
C3A12  0.20pF  [SMC1005MB]  237.1 272.54 0 top
C3A13  0.20pF  [SMC1005MB]  239.01 272.54 0 top
C3A14  0.20pF  [SMC1005MB]  240.91 272.54 0 top
C3A15  0.20pF  [SMC1005MB]  242.82 272.54 0 top
C3A16  2.2UF  [SMC0402IA]  235.45 270.76 180 top
C3A17  22pF  [SMC0402IA]  234.56 268.1 0 top
C3A18  22pF  [SMC0402IA]  234.56 266.57 0 top
C3A19  0.22uF  [SMC1005MB]  233.17 263.02 180 top
C3A20  0.1uF  [SMC0402IA]  233.17 263.02 0 top
C3A21  0.1uF  [SMC0402IA]  233.17 261.87 0 top
C3A22  0.22uF  [SMC1005MB]  233.17 261.87 180 top
C3A23  22uF  [SMC0805IA]  212.09 259.84 180 top
C3A24  22uF  [SMC0805IA]  213.61 259.84 0 top
C3A25  0.33uF  [SMC1005MB]  207.49 259.71 90 top
C3A26  0.33uF  [SMC1005MB]  208.38 259.71 90 top
C3A27  0.1uF  [SMC0402IA]  217.39 259.71 90 top
C3A28  0.1uF  [SMC0402IA]  218.28 259.71 90 top
C3A29  0.33uF  [SMC1005MB]  219.43 259.71 90 top
C3A30  0.33uF  [SMC1005MB]  220.31 259.71 90 top
C3A31  0.1uF  [SMC0402IA]  221.46 259.71 90 top
C3A32  0.1uF  [SMC0402IA]  222.35 259.71 90 top
C3A33  0.33uF  [SMC1005MB]  223.36 259.71 90 top
C3A34  0.33uF  [SMC1005MB]  224.25 259.71 90 top
C3B1  0.1uF  [SMC0402IA]  237.23 259.21 90 top
C3B2  0.1uF  [SMC0402IA]  238.37 259.21 90 top
C3B3  0.1uF  [SMC0402IA]  239.26 259.21 90 top
C3B4  0.1uF  [SMC0402IA]  240.41 259.21 90 top
C3B5  0.1uF  [SMC0402IA]  241.3 259.21 90 top
C3B6  0.1uF  [SMC0402IA]  242.44 259.21 90 top
C3B7  0.1uF  [SMC0402IA]  243.33 259.21 90 top
C3B8  0.1uF  [SMC0402IA]  209.93 257.55 0 top
C3B9  0.1uF  [SMC0402IA]  225.93 257.55 0 top
C3B10  0.1uF  [SMC0402IA]  207.89 253.11 270 top
C3B11  0.1uF  [SMC0402IA]  208.78 253.11 270 top
C3B12  0.1uF  [SMC0402IA]  219.2 253.11 270 top
C3B13  0.1uF  [SMC0402IA]  220.09 253.11 270 top
C3B14  0.1uF  [SMC0402IA]  223.9 253.11 270 top
C3B15  0.1uF  [SMC0402IA]  224.79 253.11 270 top
C3B16  0.1uF  [SMC0402IA]  216.66 252.98 0 top
C3B17  0.1uF  [SMC0402IA]  221.58 252.22 90 top
C3B18  0.1uF  [SMC0402IA]  222.47 252.22 90 top
C3B19  0.1uF  [SMC0402IA]  216.66 252.09 0 top
C3B20  0.1uF  [SMC0603IA]  207.26 246.89 90 top
C3B21  0.1uF  [SMC0603IA]  220.59 246.89 90 top
C3B22  1uF  [SMC0402IA]  221.99 246.89 0 top
C3B23  0.1uF  [SMC0603IA]  230.63 246.89 90 top
C3B24  1uF  [SMC0402IA]  208.28 246.63 0 top
C3B25  10uF  [SMC0603IA]  239.14 243.84 270 top
C3B26  10uF  [SMC0603IA]  240.41 243.84 270 top
C3B27  10uF  [SMC0603IA]  225.8 243.71 270 top
C3B28  10uF  [SMC0603IA]  227.07 243.71 270 top
C3B29  1uF  [SMC0402IA]  211.45 243.58 270 top
C3B30  10uF  [SMC0603IA]  215.77 243.58 270 top
C3B31  10uF  [SMC0603IA]  217.04 243.58 270 top
C3B32  1uF  [SMC0402IA]  224.79 243.58 270 top
C3B33  1uF  [SMC0402IA]  234.82 243.58 270 top
C3C1  470uF  [CPRC34_250PMA]  211.96 222.63 90 top
C3C2  470uF  [CPRC34_250PMA]  220.59 222.63 90 top
C3C3  470uF  [CPRC34_250PMA]  229.36 222.63 90 top
C3C4  470uF  [CPRC34_250PMA]  237.87 222.63 90 top
C3C5  470uF  [CPRC34_250PMA]  207.64 216.03 90 top
C3C6  470uF  [CPRC34_250PMA]  216.28 216.03 90 top
C3C7  470uF  [CPRC34_250PMA]  224.91 216.03 90 top
C3C8  470uF  [CPRC34_250PMA]  233.55 216.03 90 top
C3C9  470uF  [CPRC34_250PMA]  242.18 216.03 90 top
C3C10  47uF  [SMC0805IA]  217.93 207.64 0 top
C3C11  47uF  [SMC0805IA]  221.36 207.64 0 top
C3C12  47uF  [SMC0805IA]  224.79 207.64 0 top
C3C13  47uF  [SMC0805IA]  228.21 207.64 0 top
C3C14  47uF  [SMC0805IA]  231.64 207.64 0 top
C3D1  47uF  [SMC0805IA]  217.77 184.97 180 top
C3D2  47uF  [SMC0805IA]  220.95 184.97 180 top
C3D3  47uF  [SMC0805IA]  224.12 184.97 180 top
C3D4  47uF  [SMC0805IA]  227.3 184.95 180 top
C3D5  47uF  [SMC0805IA]  228.69 184.95 0 top
C3D6  22uF  [SMC0603ID]  213.31 183.61 90 top
C3D7  22uF  [SMC0603ID]  214.55 183.61 90 top
C3D8  47uF  [SMC0805IA]  217.77 182.89 180 top
C3D9  47uF  [SMC0805IA]  220.95 182.89 180 top
C3D10  47uF  [SMC0805IA]  224.12 182.89 180 top
C3D11  47uF  [SMC0805IA]  227.3 182.87 180 top
C3D12  47uF  [SMC0805IA]  228.69 182.87 0 top
C3D13  22uF  [SMC0603ID]  214.64 182.42 180 top
C3D14  22uF  [SMC0603ID]  214.63 180.85 180 top
C3D15  47uF  [SMC0805IA]  228.69 180.79 0 top
C3D16  47uF  [SMC0805IA]  217.77 180.26 180 top
C3D17  47uF  [SMC0805IA]  220.95 180.26 180 top
C3D18  47uF  [SMC0805IA]  224.12 180.26 180 top
C3D19  47uF  [SMC0805IA]  227.3 180.24 180 top
C3D20  22uF  [SMC0603ID]  214.63 179.65 180 top
C3D21  47uF  [SMC0805IA]  228.69 178.7 0 top
C3D22  22uF  [SMC0603ID]  214.63 177.98 180 top
C3D23  47uF  [SMC0805IA]  227.3 177.76 180 top
C3D24  47uF  [SMC0805IA]  217.77 177.63 180 top
C3D25  47uF  [SMC0805IA]  220.95 177.63 180 top
C3D26  47uF  [SMC0805IA]  224.12 177.63 180 top
C3D27  22uF  [SMC0603ID]  214.63 176.78 180 top
C3D28  47uF  [SMC0805IA]  228.69 176.62 0 top
C3D29  47uF  [SMC0805IA]  227.3 175.68 180 top
C3D30  47uF  [SMC0805IA]  217.77 175.55 180 top
C3D31  47uF  [SMC0805IA]  220.95 175.55 180 top
C3D32  47uF  [SMC0805IA]  224.12 175.55 180 top
C3D33  22uF  [SMC0603ID]  214.63 175.51 180 top
C3E1  10uF  [SMC0402MC]  231.64 147.45 270 top
C3E2  10uF  [SMC0402MC]  224.53 146.43 45 top
C3E3  10uF  [SMC0402MC]  238.5 145.79 90 top
C3E4  10uF  [SMC0402MC]  235.2 145.16 90 top
C3E5  470uF  [CPRC34_250PMA]  219.76 139.66 180 top
C3E6  470uF  [CPRC34_250PMA]  235.05 139.35 180 top
C3E7  1uF  [SMC0402IA]  221.62 134.5 270 top
C3E8  1uF  [SMC0402IA]  234.69 134.49 270 top
C3E9  1uF  [SMC0402IA]  226.62 134.48 270 top
C3E10  4.7UF  [SMC0603IA]  218.28 133.88 90 top
C3E11  12PF  [SMC0402IA]  230.88 116.2 180 top
C3E12  2.2pF  [SMC0402IA]  203.07 133.6 90 top
C3E13  0.1uF  [SMC0402IA]  235.58 133.6 90 top
C3E14  22uF  [SMC0603ID]  240.28 133.6 90 top
C3E15  0.1uF  [SMC0402IA]  217.16 133.58 90 top
C3F1  1uF  [SMC0402IA]  209.04 116.46 0 top
C3F2  0.1uF  [SMC0402IA]  218.56 116.46 0 top
C3F3  0.1uF  [SMC0402IA]  235.1 116.36 0 top
C3F4  1uF  [SMC0402IA]  212.72 116.33 270 top
C3F5  2.2pF  [SMC0402IA]  238.12 116.33 180 top
C3F6  10uF  [SMC0402MC]  240.79 116.33 180 top
C3F7  22uF  [SMC0603ID]  243.58 116.33 0 top
C3F8  2.2pF  [SMC0402IA]  232.15 116.2 0 top
C3F9  2.2pF  [SMC0402IA]  239.01 133.86 90 top
C3F10  22uF  [SMC0805IA]  220.74 115.98 0 top
C3F11  22uF  [SMC0805IA]  226.33 115.98 0 top
C3F12  4.7UF  [SMC0603IA]  216.33 115.95 180 top
C3F13  1uF  [SMC0402IA]  223.9 115.95 0 top
C3F14  1uF  [SMC0402IA]  218.56 115.57 0 top
C3F15  10uF  [SMC0402MC]  209.04 115.44 0 top
C3F16  4.7uF  [SMC0402IA]  215.58 106.08 180 top
C3F17  0.1uF  [SMC0402IA]  233.14 106.34 0 top
C3F18  0.1uF  [SMC0402IA]  218.25 106.33 0 top
C3F19  10uF  [SMC0402MC]  220.16 106.33 0 top
C3F20  1uF  [SMC0402IA]  231.21 106.33 0 top
C3F21  2.2pF  [SMC0402IA]  197.73 96.65 0 top
C3F22  12PF  [SMC0402IA]  229.23 96.65 0 top
C3F23  1uF  [SMC0402IA]  223.9 106.31 0 top
C3F24  1uF  [SMC0402IA]  227.45 106.31 0 top
C3G1  4.7UF  [SMC0603IA]  217.04 96.82 180 top
C3G2  10uF  [SMC0402MC]  208.66 96.65 180 top
C3G3  10uF  [SMC0402MC]  211.45 96.65 180 top
C3G4  0.1uF  [SMC0402IA]  218.69 96.65 0 top
C3G5  1uF  [SMC0402IA]  221.61 96.65 180 top
C3G6  1uF  [SMC0402IA]  222.75 96.65 0 top
C3G7  1uF  [SMC0402IA]  225.67 96.65 180 top
C3G8  1uF  [SMC0402IA]  227.71 96.65 180 top
C3G9  2.2pF  [SMC0402IA]  231.01 96.65 0 top
C3G10  0.1uF  [SMC0402IA]  233.29 96.65 0 top
C3G11  0.1uF  [SMC0402IA]  216.4 95.38 180 top
C3G12  22uF  [SMC0805IA]  210.82 94.99 0 top
C3G13  22uF  [SMC0603ID]  222.75 94.74 0 top
C3G14  1000uF  [CPRC68_250PMA]  214.79 91.17 90 top
C3G15  560uF  [CPRC55_200MA]  217.29 89.17 180 top
C3G16  22uF  [SMC0805IA]  243.58 89.15 270 top
C3G17  0.1uF  [SMC0402IA]  224.28 88.26 270 top
C3G24  22uF  [CPRC55_200PMA]  208.02 74.93 90 top
C3G25  100uF  [CPRC63_250PMA]  233.55 74.93 90 top
C3G26  100uF  [CPRC63_250PMA]  241.55 74.93 90 top
C3G27  0.1uF  [SMC0402IA]  215.01 73.4 90 top
C3G28  0.1uF  [SMC0402IA]  216.15 73.4 90 top
C3G29  0.1uF  [SMC0402IA]  242.44 70.48 0 top
C3H1  0.1uF  [SMC0402IA]  227.96 57.15 90 top
C3H2  0.1uF  [SMC0402IA]  231.39 57.15 90 top
C3H3  0.1uF  [SMC0402IA]  219.83 56.64 90 top
C3H4  0.1uF  [SMC0402IA]  215.01 55.12 0 top
C3H5  0.1uF  [SMC0402IA]  221.23 54.35 0 top
C3H6  0.1uF  [SMC0402IA]  231.9 54.23 0 top
C3H8  0.1uF  [SMC0402IA]  221.23 52.07 0 top
C3H9  0.1uF  [SMC0402IA]  231.14 51.31 270 top
C3L1  0.01uF  [SMC0402IA]  240.41 270.76 90 bottom
C3L2  0.1uF  [SMC0402IA]  238.76 270.76 90 bottom
C3L3  0.1uF  [SMC0402IA]  241.93 270.13 90 bottom
C3L4  0.1uF  [SMC0402IA]  239.62 269.24 0 bottom
C3L5  0.1uF  [SMC0402IA]  242.95 267.59 90 bottom
C3L6  0.1uF  [SMC0402IA]  242.06 267.59 90 bottom
C3L7  0.1uF  [SMC0402IA]  238.88 266.83 180 bottom
C3L8  0.01uF  [SMC0402IA]  238.88 265.94 180 bottom
C3L9  10uF  [SMC0603IA]  236.09 265.68 90 bottom
C3L10  0.01uF  [SMC0402IA]  242.82 265.17 270 bottom
C3L11  0.1uF  [SMC0402IA]  241.93 265.17 270 bottom
C3L12  0.1uF  [SMC0402IA]  240.28 264.41 0 bottom
C3L13  0.1uF  [SMC0402IA]  237.61 264.41 180 bottom
C3L14  0.1uF  [SMC0402IA]  240.28 263.52 0 bottom
C3M1  0.1uF  [SMC0402IA]  223.01 258.06 0 bottom
C3M2  0.1uF  [SMC0402IA]  218.56 258.06 180 bottom
C3M3  0.1uF  [SMC0402IA]  215.64 258.06 0 bottom
C3M4  0.1uF  [SMC0402IA]  223.01 254.76 0 bottom
C3M5  0.1uF  [SMC0402IA]  218.56 254.76 180 bottom
C3M6  0.1uF  [SMC0402IA]  216.78 254.76 180 bottom
C3M7  0.1uF  [SMC0402IA]  223.01 253.24 0 bottom
C3M8  4.7uF  [SMC0402IA]  235.45 247.01 0 bottom
C3M9  4.7uF  [SMC0402IA]  212.09 247.01 0 bottom
C3M10  10uF  [SMC0603IA]  229.36 246.89 90 bottom
C3M11  10uF  [SMC0603IA]  241.3 244.23 270 bottom
C3M12  10uF  [SMC0603IA]  240.13 244.23 270 bottom
C3M13  10uF  [SMC0603IA]  217.8 244.38 270 bottom
C3M14  10uF  [SMC0603IA]  216.63 244.38 270 bottom
C3M15  10uF  [SMC0603IA]  227.83 243.58 270 bottom
C3M16  10uF  [SMC0603IA]  226.56 243.58 270 bottom
C3M17  1uF  [SMC0402IA]  233.04 243.33 270 bottom
C3M18  1uF  [SMC0402IA]  209.67 243.33 270 bottom
C3M19  0.1uF  [SMC0402IA]  235.68 241.83 180 bottom
C3M20  0.1uF  [SMC0402IA]  236.47 241.81 0 bottom
C3M21  0.1uF  [SMC0402IA]  212.31 241.7 180 bottom
C3M22  0.1uF  [SMC0402IA]  213.1 241.68 0 bottom
C3M23  0.47uF  [SMC0402IA]  214.75 241.55 270 bottom
C3M24  0.47uF  [SMC0402IA]  238.25 241.43 270 bottom
C3M25  0.1uF  [SMC0402IA]  236.47 240.03 270 bottom
C3M26  0.1uF  [SMC0402IA]  235.58 240.03 270 bottom
C3M27  680pF  [SMC0402IA]  226.06 240.03 0 bottom
C3M28  680pF  [SMC0402IA]  224.66 240.03 180 bottom
C3M29  0.1uF  [SMC0402IA]  213.1 239.9 270 bottom
C3M30  0.1uF  [SMC0402IA]  212.19 239.88 270 bottom
C3P1  22uF  [SMC0603ID]  213.87 186.69 180 bottom
C3P2  330uF  [TK0_SMC7343_7500X4500_ALEL_MA]  227.77 186.05 180 bottom
C3P3  330uF  [TK0_SMC7343_7500X4500_ALEL_MA]  219.17 185.64 180 bottom
C3P4  47uF  [SMC0805IA]  211.22 184.78 0 bottom
C3P5  47uF  [SMC0805IA]  234.12 183.91 90 bottom
C3P6  47uF  [SMC0805IA]  211.22 183.08 0 bottom
C3P7  47uF  [SMC0805IA]  232.49 182.87 180 bottom
C3P8  47uF  [SMC0805IA]  211.25 181.1 0 bottom
C3P9  47uF  [SMC0805IA]  232.49 180.79 180 bottom
C3P10  330uF  [TK0_SMC7343_7500X4500_ALEL_MA]  219.17 180.17 180 bottom
C3P11  330uF  [TK0_SMC7343_7500X4500_ALEL_MA]  227.33 179.22 270 bottom
C3P12  47uF  [SMC0805IA]  211.25 179.2 0 bottom
C3P13  47uF  [SMC0805IA]  232.49 178.7 180 bottom
C3P14  47uF  [SMC0805IA]  211.27 177.42 0 bottom
C3P15  47uF  [SMC0805IA]  232.47 176.62 180 bottom
C3P16  47uF  [SMC0805IA]  234.37 175.64 270 bottom
C3P17  47uF  [SMC0805IA]  211.27 175.64 0 bottom
C3P18  330uF  [TK0_SMC7343_7500X4500_ALEL_MA]  220.52 174.75 0 bottom
C3P19  47uF  [SMC0805IA]  232.41 174.54 180 bottom
C3P20  22uF  [SMC0603ID]  215.01 172.97 90 bottom
