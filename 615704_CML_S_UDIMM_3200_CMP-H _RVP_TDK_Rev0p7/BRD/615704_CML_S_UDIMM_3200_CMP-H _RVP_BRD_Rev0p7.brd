# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R7B21  10K  [SMR0402IA]  90.67 249.58 90 top
R7B22  0  [SMR0402IA]  89.28 249.55 90 top
R7B23  0  [SMR0402IA]  96.39 250.19 180 top
R7B24  0  [SMR0402IA]  95.42 249.41 270 top
R7B25  0.01  [SMR4_0603ID_RVP]  75.69 248.03 0 top
R7B26  0  [SMR0402IA]  91.56 247.9 180 top
R7B27  0  [SMR0402IA]  70.35 247.65 180 top
R7B28  0  [SMR0402IA]  72.13 247.65 180 top
R7B29  0  [SMR0402IA]  74.04 247.65 180 top
R7B30  4.7K  [SMR0402IA]  91.05 247.01 180 top
R7B31  1K  [SMR0402IA]  89.02 246.89 180 top
R7B32  0  [SMR0402IA]  82.67 246.76 180 top
R7B33  10K  [SMR0402IA]  82.67 246 180 top
R7B34  10K  [SMR0402IA]  90.04 244.22 0 top
R7B35  0  [SMR0402IA]  66.92 245.24 0 top
R7B36  100K  [SMR0402IA]  88.13 244.98 0 top
R7B37  0  [SMR0402IA]  66.92 244.09 0 top
R7B38  1K  [SMR0402IA]  89.02 243.33 180 top
R7B39  10K  [SMR0402IA]  91.05 242.44 90 top
R7B40  0  [SMR0402IA]  66.92 242.95 0 top
R7B41  0  [SMR0402IA]  79.24 242.19 0 top
R7B42  0  [SMR0402IA]  81.66 242.19 0 top
R7B43  0  [SMR0402IA]  66.92 241.81 0 top
R7B44  100K  [SMR0402IA]  88.13 241.43 0 top
R7B45  0  [SMR0402IA]  79.24 241.04 0 top
R7B46  10K  [SMR0402IA]  82.55 241.04 180 top
R7B47  0  [SMR0402IA]  66.92 240.66 0 top
R7B48  0  [SMR0402IA]  79.24 239.9 0 top
R7B49  10K  [SMR0402IA]  82.55 239.9 180 top
R7B50  0  [SMR0402IA]  84.2 239.9 0 top
R7B51  0  [SMR0402IA]  66.92 239.52 0 top
R7B52  0  [SMR0402IA]  79.24 238.76 0 top
R7B53  100K  [SMR0402IA]  84.2 238.76 0 top
R7B54  0  [SMR0402IA]  66.92 238.5 0 top
R7B55  10K  [SMR0402IA]  96.52 236.47 270 top
R7B56  0  [SMR0402IA]  85.09 237.74 180 top
R7B57  0  [SMR0402IA]  79.24 237.62 0 top
R7B58  0  [SMR0402IA]  81.66 237.62 0 top
R7B59  0  [SMR0402IA]  66.92 237.36 0 top
R7B60  0  [SMR0402IA]  95.63 236.47 270 top
R7B61  0  [SMR0402IA]  85.09 236.6 180 top
R7B62  22  [SMR0402IA]  79.24 236.22 0 top
R7B63  0  [SMR0402IA]  94.74 234.69 270 top
R7B64  100K  [SMR0402IA]  95.63 234.69 270 top
R7B65  0  [SMR0402IA]  66.92 235.2 0 top
R7B66  0  [SMR0402IA]  80.13 235.08 180 top
R7B67  10K  [SMR0402IA]  86.74 234.44 0 top
R7B68  0  [SMR0402IA]  89.66 234.44 180 top
R7B69  200K  [SMR0402IA]  67.81 234.06 180 top
R7B70  0  [SMR0402IA]  80.13 233.93 180 top
R7B71  0  [SMR0402IA]  66.92 232.92 0 top
R7B72  0  [SMR0402IA]  66.92 231.77 0 top
R7B73  1K  [SMR0402IA]  88.01 231.65 0 top
R7B74  0  [SMR0402IA]  66.92 230.63 0 top
R7B75  22  [SMR0402IA]  79.24 230.63 0 top
R7B76  1K  [SMR0402IA]  88.01 229.87 0 top
R7B77  10K  [SMR0402IA]  79.24 229.61 0 top
R7B78  0  [SMR0402IA]  66.92 229.49 0 top
R7B79  75K  [SMR0402IA]  79.24 228.6 0 top
R7B80  0  [SMR0402IA]  66.92 228.34 0 top
R7B81  1K  [SMR0402IA]  88.9 227.84 180 top
R7B82  75K  [SMR0402IA]  79.24 227.58 0 top
R7B83  0  [SMR0402IA]  66.92 227.2 0 top
R7B84  10K  [SMR0402IA]  101.72 248.15 180 top
R7C1  1K  [SMR0402IA]  88.01 226.82 0 top
R7C2  1M  [SMR0402IA]  92.45 226.82 0 top
R7C3  10K  [SMR0402IA]  95.75 226.82 180 top
R7C4  0  [SMR0402IA]  95.75 225.8 180 top
R7C5  0  [SMR0402IA]  95.75 224.53 180 top
R7C6  1K  [SMR0402IA]  86.99 223.9 270 top
R7C7  1K  [SMR0402IA]  83.05 223.26 90 top
R7C8  0  [SMR0603IA]  66.42 222.88 90 top
R7C9  0  [SMR0603IA]  67.56 222.88 90 top
R7C10  100  [SMR0402IA]  77.59 221.23 90 top
R7C11  100  [SMR0402IA]  78.35 221.23 90 top
R7C13  10K  [SMR0402IA]  77.85 216.91 180 top
R7C15  15K  [SMR0402IA]  77.85 215.77 180 top
R7C21  10K  [SMR0402IA]  78.1 210.06 180 top
R7C26  1K  [SMR0402IA]  65.02 203.58 270 top
R7C30  1K  [SMR0402IA]  65.02 200.53 90 top
R7C32  0  [SMR0603IA]  86.1 199.77 90 top
R7C33  0  [SMR0603IA]  87.24 199.77 90 top
R7C34  0  [SMR0603IA]  88.64 199.77 90 top
R7C35  0  [SMR0603IA]  89.78 199.77 90 top
R7C37  0  [SMR0603IA]  63.88 198.12 180 top
R7C39  0  [SMR0402IA]  86.36 197.23 90 top
R7C40  0  [SMR0402IA]  87.12 197.23 90 top
R7C41  200K  [SMR0402IA]  89.66 196.85 270 top
R7C42  10K  [SMR0402IA]  90.67 196.85 0 top
R7C43  0.01  [SMR4_0603ID_RVP]  62.48 196.59 0 top
R7C45  10K  [SMR0402IA]  88.9 195.96 90 top
R7C46  10K  [SMR0402IA]  90.67 195.96 0 top
R7C47  0  [SMR0402IA]  86.36 195.71 270 top
R7C48  0  [SMR0402IA]  87.12 195.71 270 top
R7C49  0  [SMR0603IA]  63.88 195.07 180 top
R7C50  0  [SMR0603IA]  77.47 195.58 270 top
R7C51  0  [SMR0603IA]  78.74 195.58 270 top
R7D5  75K  [SMR0402IA]  61.21 189.36 0 top
R7D6  10K  [SMR0402IA]  89.91 187.32 270 top
R7D7  10K  [SMR0402IA]  90.93 187.32 270 top
R7D8  0  [SMR0402IA]  89.15 186.43 90 top
R7D9  0  [SMR0402IA]  91.69 186.43 90 top
R7D12  100  [SMR0402IA]  89.15 181.48 90 top
R7D14  0  [SMR0402IA]  84.58 180.34 270 top
R7D15  0  [SMR0402IA]  84.58 180.34 90 top
R7D16  10K  [SMR0402IA]  85.59 180.34 270 top
R7D18  51  [SMR0402IA]  89.15 179.96 270 top
R7D19  22  [SMR0402IA]  76.2 179.83 270 top
R7D20  20K  [SMR0402IA]  77.21 179.83 270 top
R7D21  20K  [SMR0402IA]  78.1 179.83 270 top
R7D22  51  [SMR0402IA]  92.07 179.32 270 top
R7D24  13  [SMR0402IC]  97.02 179.07 270 top
R7D25  1K  [SMR0402IA]  90.29 178.43 90 top
R7D26  100  [SMR0402IA]  94.1 178.43 270 top
R7D27  51  [SMR0402IA]  95.12 178.43 270 top
R7D29  0  [SMR0402IA]  84.58 178.05 0 top
R7D30  0  [SMR0402IA]  84.58 178.05 180 top
R7D31  22  [SMR0402IA]  78.1 177.54 270 top
R7D32  4.7K  [SMR0402IA]  79.88 177.54 270 top
R7D33  51  [SMR0402IA]  93.09 177.54 90 top
R7D35  20K  [SMR0402IA]  78.99 176.66 90 top
R7D36  0  [SMR0402IA]  84.58 176.66 0 top
R7D37  0  [SMR0402IA]  84.58 176.66 180 top
R7D39  1K  [SMR0402IA]  97.02 175.77 90 top
R7D40  100K  [SMR0402IA]  77.21 174.62 0 top
R7D41  4.7K  [SMR0402IA]  78.1 174.62 0 top
R7D46  0  [SMR0402IA]  92.96 167.64 270 top
R7D47  30  [SMR0402IA]  97.53 167.64 270 top
R7D48  30  [SMR0402IA]  94.86 166.75 90 top
R7D49  30  [SMR0402IA]  95.75 166.75 90 top
R7D50  0  [SMR0402IA]  75.18 163.7 180 top
R7D51  150  [SMR0402IA]  88.26 163.45 90 top
R7E1  0  [SMR0402IA]  75.21 160.28 0 top
R7E2  0  [SMR0402IA]  75.21 160.28 180 top
R7E3  33  [SMR0402IA]  71.62 159.26 180 top
R7E4  1K  [SMR0402IA]  74.29 159.26 0 top
R7E5  33  [SMR0402IA]  72.51 158.37 0 top
R7E6  33  [SMR0402IA]  75.18 158.37 180 top
R7E7  33  [SMR0402IA]  75.18 158.37 0 top
R7E8  100K  [SMR0402IA]  77.85 158.11 90 top
R7E9  33  [SMR0402IA]  78.74 158.11 90 top
R7E10  33  [SMR0402IA]  78.74 158.11 0 top
R7E11  33K  [SMR0402IA]  82.16 157.35 0 top
R7E12  33  [SMR0402IA]  83.05 156.59 180 top
R7E13  33  [SMR0402IA]  83.59 154.94 180 top
R7E14  33  [SMR0402IA]  81.53 154.81 180 top
R7E15  100K  [SMR0402IA]  71.62 153.8 0 top
R7E16  33  [SMR0402IA]  76.96 153.41 180 top
R7E17  0  [SMR0402IA]  84.58 153.41 180 top
R7E18  33  [SMR0402IA]  84.58 152.65 180 top
R7E19  4.7K  [SMR0402IA]  80.77 147.83 0 top
R7E20  1K  [SMR0402IA]  84.07 147.83 180 top
R7E21  4.7K  [SMR0402IA]  80.77 146.81 0 top
R7E22  20K  [SMR0402IA]  84.07 146.81 180 top
R7E23  0  [SMR0402IA]  72.13 145.92 0 top
R7E24  0  [SMR0402IA]  72.13 144.52 0 top
R7E25  33  [SMR0402IA]  79.09 142.67 180 top
R7E26  0  [SMR0402IA]  69.85 142.62 0 top
R7E27  0  [SMR0402IA]  74.8 142.49 180 top
R7E28  0  [SMR0402IA]  68.45 142.24 270 top
R7E29  0  [SMR0402IA]  75.81 141.6 180 top
R7E30  0  [SMR0402IA]  75.81 141.6 0 top
R7E31  100K  [SMR0402IA]  67.08 141.48 90 top
R7E32  33  [SMR0402IA]  73.02 140.97 270 top
R7E33  4.7K  [SMR0402IA]  70.86 140.71 0 top
R7E34  0  [SMR0402IA]  77.72 140.46 180 top
R7E35  10K  [SMR0402IA]  75.56 140.33 180 top
R7E36  0  [SMR0402IA]  73.78 140.08 90 top
R7E37  1K  [SMR0402IA]  71.75 139.95 180 top
R7E38  0  [SMR0402IA]  78.74 139.57 45 top
R7E39  4.7K  [SMR0402IA]  69.97 139.06 0 top
R7E40  10K  [SMR0402IA]  74.67 138.94 0 top
R7E42  4.7K  [SMR0402IA]  70.99 137.16 0 top
R7E43  20K  [SMR0402IA]  71.88 137.16 0 top
R7E44  0  [SMR0402IA]  75.18 137.16 0 top
R7E45  0  [SMR0402IA]  75.18 137.16 180 top
R7E46  0  [SMR0402IA]  68.07 136.65 0 top
R7E47  0  [SMR0402IA]  69.46 135 180 top
R7E48  0  [SMR0402IA]  71.5 135 0 top
R7E49  0  [SMR0402IA]  73.15 134.87 0 top
R7E50  10K  [SMR0402IA]  69.46 134.24 180 top
R7E51  100K  [SMR0402IA]  80.13 133.98 180 top
R7E52  0  [SMR0402IA]  76.7 133.73 180 top
R7E53  0  [SMR0402IA]  68.58 133.35 180 top
R7E54  0  [SMR0402IA]  76.7 132.97 180 top
R7E55  75K  [SMR0402IA]  71.75 132.84 0 top
R7E56  0  [SMR0402IA]  68.58 132.59 180 top
R7E57  10K  [SMR0402IA]  71.5 131.32 0 top
R7E58  0  [SMR0402IA]  80.26 131.19 180 top
R7E59  0  [SMR0603IA]  82.16 131.06 0 top
R7E60  0  [SMR0402IA]  68.58 130.94 180 top
R7E61  100K  [SMR0402IA]  71.37 130.05 0 top
R7F1  0.022  [SMR4_0603ID_RVP]  77.97 128.78 0 top
R7F2  20K  [SMR0402IA]  71.4 128.66 0 top
R7F3  100K  [SMR0402IA]  73.27 128.65 90 top
R7F4  10K  [SMR0402IA]  69.59 127.13 0 top
R7F5  0.022  [SMR4_0603ID_RVP]  79.37 126.74 180 top
R7F6  0  [SMR0603IA]  72.51 124.84 0 top
R7F7  0  [SMR0402IA]  78.61 124.46 0 top
R7F8  0  [SMR0603IA]  72.51 123.7 0 top
R7F9  100K  [SMR0402IA]  69.08 123.44 270 top
R7F10  0  [SMR0603IA]  72.51 122.55 0 top
R7F11  10M  [SMR0603IA]  77.34 121.66 0 top
R7F12  0  [SMR0603IA]  72.51 121.41 0 top
R7F13  100K  [SMR0402IA]  73.78 120.39 180 top
R7F14  0  [SMR0402IA]  77.34 119.63 90 top
R7F15  0  [SMR0402IA]  78.74 119.63 90 top
R7F16  0  [SMR0402IA]  75.18 119.12 90 top
R7F17  33  [SMR0402IA]  70.1 118.87 270 top
R7F18  33  [SMR0402IA]  70.86 118.87 270 top
R7F19  33  [SMR0402IA]  71.62 118.87 270 top
R7F20  33  [SMR0402IA]  72.51 118.87 270 top
R7F21  33  [SMR0402IA]  73.27 118.87 270 top
R7F22  1K  [SMR0402IA]  74.04 118.87 270 top
R7F23  30.1K  [SMR0402IA]  81.66 118.24 270 top
R7F24  100K  [SMR0402IA]  88.77 118.24 270 top
R7F25  0  [SMR0402IA]  90.93 118.24 270 top
R7F26  0  [SMR0402IA]  93.34 118.24 270 top
R7F27  0  [SMR0402IA]  94.23 118.24 270 top
R7F28  0  [SMR0402IA]  95.25 118.24 270 top
R7F29  0  [SMR0402IA]  96.9 118.24 270 top
R7F30  470  [SMR0402IA]  75.18 117.73 270 top
R7F31  100K  [SMR0402IA]  83.05 117.35 90 top
R7F32  4.7K  [SMR0402IA]  84.2 117.35 90 top
R7F33  100K  [SMR0402IA]  85.34 117.35 90 top
R7F34  1K  [SMR0402IA]  86.36 117.35 90 top
R7F35  0  [SMR0402IA]  89.78 117.35 90 top
R7F36  0  [SMR0402IA]  91.82 117.35 90 top
R7F37  100K  [SMR0402IA]  93.34 116.46 270 top
R7F38  4.7K  [SMR0402IA]  83.05 115.82 270 top
R7F39  4.7K  [SMR0402IA]  85.34 115.82 270 top
R7F40  10K  [SMR0402IA]  90.93 115.57 90 top
R7F41  10K  [SMR0402IA]  94.23 115.57 90 top
R7F42  10K  [SMR0402IA]  95.25 115.57 90 top
R7F43  10K  [SMR0402IA]  90.8 113.92 270 top
R7F44  0  [SMR0402IA]  83.43 112.77 180 top
R7F45  0  [SMR0402IA]  70.1 112.65 180 top
R7F46  0  [SMR0402IA]  72 112.65 180 top
R7F47  10K  [SMR0402IA]  90.04 112.39 270 top
R7F48  0  [SMR0402IA]  83.43 111.89 180 top
R7F49  1K  [SMR0402IA]  83.43 111 180 top
R7F50  0  [SMR0402IA]  90.04 109.09 90 top
R7F51  0  [SMR0402IA]  94.74 107.57 270 top
R7G1  1K  [SMR0402IA]  83.56 93.09 180 top
R7G2  10K  [SMR0402IA]  83.56 92.2 180 top
R7G3  0  [SMR1206IA]  62.99 91.69 180 top
R7G4  10mOHM  [SMR4_0805IB_RVP]  61.21 89.41 0 top
R7G7  100K  [SMR0402IA]  82.67 87.63 0 top
R7G8  33  [SMR0402IA]  83.56 86.74 180 top
R7G9  33  [SMR0402IA]  83.56 85.98 270 top
R7G10  0  [SMR0402IA]  71.88 85.47 0 top
R7G11  33  [SMR0402IA]  82.67 84.33 0 top
R7G12  0  [SMR0402IA]  73.53 84.07 180 top
R7G13  33  [SMR0402IA]  83.56 83.56 180 top
R7G14  100K  [SMR0402IA]  71.62 82.55 0 top
R7G15  100K  [SMR0402IA]  67.05 80.9 180 top
R7G16  33  [SMR0402IA]  72.51 80.77 180 top
R7G17  33  [SMR0402IA]  72.51 80.01 180 top
R7G18  100K  [SMR0402IA]  61.08 78.87 270 top
R7G19  33  [SMR0402IA]  72.51 78.87 180 top
R7G20  33  [SMR0402IA]  82.16 78.61 0 top
R7G21  33  [SMR0402IA]  83.05 77.85 180 top
R7G22  0  [SMR0402IA]  67.31 77.47 180 top
R7G23  10K  [SMR0402IA]  89.66 77.21 180 top
R7G24  33  [SMR0402IA]  72.26 77.09 90 top
R7G25  0  [SMR0402IA]  67.31 76.71 180 top
R7G26  0.01  [SMR4_0603ID_RVP]  91.18 76.07 90 top
R7G27  0  [SMR0402IA]  62.01 74.29 90 top
R7G28  0  [SMR0402IA]  63.28 74.29 90 top
R7G29  0  [SMR0402IA]  64.55 74.29 90 top
R7G30  0  [SMR0402IA]  73.44 74.29 90 top
R7G31  0  [SMR0402IA]  77.25 74.29 90 top
R7G32  0  [SMR0402IA]  78.52 74.29 90 top
R7G33  0  [SMR0402IA]  81.66 74.17 90 top
R7G34  0  [SMR0402IA]  90.17 74.17 90 top
R7G35  0  [SMR0603IA]  91.31 74.04 0 top
R7G36  10K  [SMR0402IA]  88.77 73.91 180 top
R7H1  10K  [SMR0402IA]  68.87 64.9 270 top
R7H2  1K  [SMR0402IA]  89.91 64.9 270 top
R7H3  0  [SMR0402IA]  92.49 64.9 270 top
R7H4  0  [SMR0402IA]  62.61 64.01 90 top
R7H5  0  [SMR0402IA]  63.37 64.01 90 top
R7H6  0  [SMR0402IA]  64.55 64.01 90 top
R7H7  0  [SMR0402IA]  69.89 64.01 90 top
R7H8  0  [SMR0402IA]  70.9 64.01 90 top
R7H9  0  [SMR0402IA]  73.44 64.01 90 top
R7H10  0  [SMR0402IA]  74.71 64.01 90 top
R7H11  0  [SMR0402IA]  75.98 64.01 90 top
R7H12  0  [SMR0402IA]  77.25 64.01 90 top
R7H13  0  [SMR0402IA]  78.52 64.01 90 top
R7H14  0  [SMR0402IA]  82.33 64.01 90 top
R7H15  2.2K  [SMR0402IA]  87.41 64.01 90 top
R7H16  0  [SMR0402IA]  88.68 64.01 90 top
R7H17  0  [SMR0402IA]  91.22 64.01 90 top
R7H18  0  [SMR0402IA]  92.49 63.12 90 top
R7H19  20K  [SMR0402IA]  88.68 61.59 90 top
R7H20  1K  [SMR0402IA]  89.91 61.59 90 top
R7H21  1K  [SMR0402IA]  73.91 60.7 0 top
R7H22  1K  [SMR0402IA]  78.1 60.7 180 top
R7H23  1K  [SMR0402IA]  80.01 60.7 180 top
R7H24  1K  [SMR0402IA]  74.8 59.82 180 top
R7H25  0  [SMR0402IA]  86.36 59.31 180 top
R7H26  0  [SMR0402IA]  86.36 59.31 0 top
R7H27  49.9K  [SMR0402IA]  89.4 59.31 0 top
R7H28  1K  [SMR0402IA]  81.66 59.18 0 top
R7H29  0  [SMR0402IA]  73.91 58.93 0 top
R7H30  1K  [SMR0402IA]  82.55 58.29 180 top
R7H31  0  [SMR0402IA]  73.91 58.04 0 top
R7H32  0  [SMR0402IA]  86.36 58.04 180 top
R7H33  0  [SMR0402IA]  86.36 58.04 0 top
R7H34  49.9K  [SMR0402IA]  89.4 58.04 0 top
R7H35  0  [SMR0402IA]  73.91 57.15 0 top
R7H36  0  [SMR0402IA]  86.36 56.77 180 top
R7H37  0  [SMR0402IA]  86.36 56.77 0 top
R7H38  49.9K  [SMR0402IA]  89.4 56.77 0 top
R7H39  1K  [SMR0402IA]  81.66 56.51 0 top
R7H40  0  [SMR0402IA]  73.91 56.26 0 top
R7H41  1K  [SMR0402IA]  82.55 55.62 180 top
R7H42  0  [SMR0402IA]  86.36 55.5 0 top
R7H43  0  [SMR0402IA]  86.36 55.5 180 top
R7H44  49.9K  [SMR0402IA]  89.4 55.5 0 top
R7H45  1K  [SMR0402IA]  78.48 54.35 0 top
R7H46  1K  [SMR0402IA]  80.26 54.35 0 top
R7H47  0  [SMR0402IA]  62.48 52.83 270 top
R7H48  0  [SMR0402IA]  67.05 52.07 90 top
R7H49  0  [SMR0402IA]  68.07 52.07 90 top
R7H50  0  [SMR0402IA]  69.08 52.07 90 top
R7H51  0  [SMR0402IA]  66.04 50.04 270 top
R7H52  0  [SMR0402IA]  68.07 50.04 270 top
R7H53  0  [SMR0402IA]  69.08 50.04 270 top
R7H54  10K  [SMR0402IA]  70.1 50.04 270 top
R7H55  200K  [SMR0402IA]  71.12 50.04 270 top
R7H56  1K  [SMR0402IA]  71.88 50.04 270 top
R7H57  100  [SMR0402IA]  67.05 49.15 90 top
R7H58  0  [SMR0402IA]  72.77 49.15 90 top
R7H59  0  [SMR0402IA]  73.66 49.15 90 top
R7H60  1K  [SMR0402IA]  73.78 46.23 90 top
R7H61  0  [SMR0402IA]  97.15 45.46 90 top
R7H62  1K  [SMR0402IA]  75.05 43.81 180 top
R7H63  0  [SMR0603IA]  78.23 42.92 270 top
R7H64  0  [SMR0402IA]  82.29 42.67 180 top
R7H65  0  [SMR0402IA]  87.75 42.67 180 top
R7H66  1K  [SMR0402IA]  75.05 42.29 180 top
R7H67  330  [SMR0402IA]  96.01 40.64 180 top
R7H68  10K  [SMR0402IA]  97.53 40.13 0 top
R7H69  220  [SMR0402IA]  62.73 39.62 90 top
R7H70  0  [SMR0603IA]  86.1 37.59 0 top
R7H71  0  [SMR0603IA]  79.12 37.08 0 top
R7H72  0  [SMR1206IA]  66.67 34.42 180 top
R7J1  100  [SMR0402IA]  67.31 30.22 270 top
R7J2  2.2K  [SMR0402IA]  68.45 29.34 90 top
R7J3  2.2K  [SMR0402IA]  69.72 29.34 90 top
R7J4  2.2K  [SMR0402IA]  70.99 29.34 90 top
R7J5  2.2K  [SMR0402IA]  72.26 29.34 90 top
R7J6  0  [SMR0402IA]  68.45 27.81 270 top
R7J7  0  [SMR0402IA]  69.72 27.81 270 top
R7J8  0  [SMR0402IA]  70.99 27.81 270 top
R7J9  0  [SMR0402IA]  72.26 27.81 270 top
R7J10  10K  [SMR0402IA]  64.64 26.41 180 top
R7J11  100  [SMR0402IA]  63.75 25.27 0 top
R7J12  0  [SMR0402IA]  63.75 24 0 top
R7J13  0  [SMR0402IA]  65.53 24 180 top
R7J14  0  [SMR0402IA]  63.75 22.73 0 top
R7J15  0  [SMR0402IA]  65.53 22.73 180 top
R7L1  10K  [SMR0402IA]  61.59 266.7 180 bottom
R7M1  0  [SMR0402IA]  95.88 256.67 90 bottom
R7M2  0  [SMR0402IA]  93.34 254 90 bottom
R7P1  0  [SMR0402IA]  85.59 176.15 270 bottom
R7P2  0  [SMR0402IA]  88.39 175.26 90 bottom
R7P3  4.7K  [SMR0402IA]  78.1 174.62 0 bottom
R7P4  4.7K  [SMR0402IA]  77.21 174.62 0 bottom
R7P5  0  [SMR0603IA]  77.59 168.15 270 bottom
R7P6  0.022  [SMR4_0603ID_RVP]  76.32 168.15 270 bottom
R7P7  0  [SMR0402IA]  96.9 166.62 90 bottom
R7P8  0  [SMR0603IA]  72.13 165.99 270 bottom
R7P9  100K  [SMR0402IA]  96.9 165.48 270 bottom
R7P10  0.005  [SMR4_0805IC_RVP]  75.94 164.59 180 bottom
R7P11  0  [SMR0603IA]  77.47 164.46 0 bottom
R7P12  0  [SMR0603IA]  77.47 163.19 0 bottom
R7R1  0  [SMR0603IA]  72.13 161.8 90 bottom
R7R2  0  [SMR0603IA]  76.58 161.29 270 bottom
R7R3  0  [SMR0603IA]  75.43 161.29 270 bottom
R7R4  200  [SMR0402IA]  89.78 160.65 180 bottom
R7R5  0.022  [SMR4_0603ID_RVP]  77.85 159.89 90 bottom
R7R6  200  [SMR0402IA]  89.78 158.88 90 bottom
R7R7  200  [SMR0402IA]  88.9 158.88 90 bottom
R7R8  100K  [SMR0402IA]  73.27 158.62 180 bottom
R7R9  33  [SMR0402IA]  82.55 155.32 135 bottom
R7R10  33  [SMR0402IA]  79.88 154.94 180 bottom
R7R11  0  [SMR0402IA]  82.29 154.3 135 bottom
R7R12  33  [SMR0402IA]  76.78 154.3 180 bottom
R7R13  0  [SMR0402IA]  76.78 154.3 0 bottom
R7R14  150K  [SMR0402IA]  86.23 154.18 180 bottom
R7R15  33  [SMR0402IA]  84.58 154.18 180 bottom
R7R16  33  [SMR0402IA]  88.39 153.8 180 bottom
R7R17  33  [SMR0402IA]  76.83 153.24 180 bottom
R7R18  0  [SMR0402IA]  76.83 153.24 0 bottom
R7R19  0  [SMR0402IA]  88.26 153.03 180 bottom
R7R20  49.9K  [SMR0402IA]  86.23 152.91 180 bottom
R7R21  0  [SMR0402IA]  84.58 152.91 180 bottom
R7R22  33  [SMR0402IA]  79.75 151.89 180 bottom
R7R23  33  [SMR0402IA]  79.75 151.89 90 bottom
R7R24  49.9K  [SMR0402IA]  78.86 151.13 0 bottom
R7R25  0  [SMR0603IA]  76.2 149.6 270 bottom
R7R26  0  [SMR0603IA]  75.05 149.6 270 bottom
R7R27  0  [SMR0603IA]  73.91 149.6 270 bottom
R7R28  0  [SMR0603IA]  72.39 149.6 270 bottom
R7R29  0  [SMR0603IA]  70.1 149.6 270 bottom
R7R30  0  [SMR0603IA]  67.56 149.6 270 bottom
R7R31  0  [SMR0603IA]  66.42 149.6 270 bottom
R7R32  0  [SMR0603IA]  64.89 149.6 270 bottom
R7R33  0  [SMR0402IA]  79.75 149.22 180 bottom
R7R34  0  [SMR0402IA]  79.75 149.22 90 bottom
R7R35  49.9K  [SMR0402IA]  78.86 148.46 0 bottom
R7R36  0.01  [SMR4_0603ID_RVP]  77.47 148.21 90 bottom
R7R37  0.01  [SMR4_0603ID_RVP]  68.83 148.21 90 bottom
R7R38  33  [SMR0402IA]  77.72 145.79 180 bottom
R7R39  0  [SMR0402IA]  75.94 145.41 180 bottom
R7R40  33  [SMR0402IA]  79.62 143.71 90 bottom
R7R41  4.7K  [SMR0402IA]  78.61 143.51 270 bottom
R7R42  4.7K  [SMR0402IA]  79.62 142.87 270 bottom
R7R43  0  [SMR0603IA]  76.07 142.87 270 bottom
R7R44  0  [SMR0603IA]  74.93 142.87 270 bottom
R7R45  0  [SMR0603IA]  73.78 142.87 270 bottom
R7R46  0  [SMR0603IA]  72.26 142.87 270 bottom
R7R47  20K  [SMR0402IA]  79.62 141.98 270 bottom
R7R48  0.01  [SMR4_0603ID_RVP]  77.47 141.48 90 bottom
R7R49  0  [SMR0402IA]  74.93 140.46 180 bottom
R7R50  100K  [SMR0402IA]  66.92 138.94 180 bottom
R7R51  20K  [SMR0402IA]  66.92 138.17 180 bottom
R7R52  4.7K  [SMR0402IA]  66.04 137.41 0 bottom
R7R53  10K  [SMR0402IA]  70.99 137.16 0 bottom
R7R54  0  [SMR0402IA]  87.37 135.89 180 bottom
R7R55  0  [SMR0402IA]  84.96 135.25 225 bottom
R7R56  0  [SMR0402IA]  68.58 135.13 180 bottom
R7R57  0  [SMR0402IA]  88.51 134.75 180 bottom
R7R58  0  [SMR0402IA]  86.48 134.75 270 bottom
R7R59  0  [SMR0402IA]  76.2 132.46 180 bottom
R7R60  1M  [SMR0402IA]  88.26 131.7 0 bottom
R7R61  0  [SMR0402IA]  79.62 131.44 270 bottom
R7R62  30.1K  [SMR0402IA]  88.26 130.81 0 bottom
R7R63  0  [SMR0402IA]  74.16 135.38 180 bottom
R7T1  0  [SMR0603IA]  90.29 123.32 270 bottom
R7T2  0  [SMR0603IA]  93.09 121.92 270 bottom
R7T3  0  [SMR0402IA]  94.1 120.78 90 bottom
R7T4  0.022  [SMR4_0603ID_RVP]  91.69 120.52 90 bottom
R7T5  0  [SMR0603IA]  90.29 120.52 90 bottom
R7T6  10K  [SMR0402IA]  67.69 120.14 0 bottom
R7T7  10K  [SMR0402IA]  67.69 119.38 0 bottom
R7T8  0  [SMR0402IA]  94.23 118.24 270 bottom
R7T9  0  [SMR0402IA]  93.21 118.24 270 bottom
R7T10  100K  [SMR0402IA]  87.88 118.24 270 bottom
R7T11  0  [SMR0402IA]  95.25 118.24 270 bottom
R7T12  0  [SMR0402IA]  97.15 118.24 270 bottom
R7T13  10K  [SMR0402IA]  89.78 117.35 90 bottom
R7T14  1K  [SMR0402IA]  86.36 117.35 90 bottom
R7T15  1K  [SMR0402IA]  85.34 117.35 90 bottom
R7T16  0  [SMR0402IA]  92.2 117.35 90 bottom
R7T17  4.7K  [SMR0402IA]  85.34 115.82 270 bottom
R7T18  10K  [SMR0402IA]  95.25 115.57 90 bottom
R7T19  10K  [SMR0402IA]  94.23 115.57 90 bottom
R7T20  0  [SMR0603IA]  94.74 113.79 180 bottom
R7T21  0  [SMR0603IA]  94.74 112.52 180 bottom
R7T22  0.01  [SMR4_0603ID_RVP]  93.34 111.25 0 bottom
R7T23  0  [SMR0603IA]  94.74 109.85 180 bottom
R7T24  0  [SMR0603IA]  94.74 108.71 180 bottom
R7T25  20K  [SMR0402IA]  97.15 106.42 90 bottom
R7T26  20K  [SMR0402IA]  96.77 104.9 270 bottom
R7T27  220  [SMR0402IA]  96.77 101.6 90 bottom
R7U1  0  [SMR0402IA]  88.26 95.5 0 bottom
R7U2  0  [SMR0402IA]  87.24 95.25 180 bottom
R7U3  0  [SMR0402IA]  85.47 95.25 0 bottom
R7U4  10  [SMR0402IA]  93.06 95.15 270 bottom
R7U5  10  [SMR0402IA]  91.44 95.15 270 bottom
R7U6  0  [SMR0402IA]  84.58 94.87 180 bottom
R7U7  0  [SMR0402IA]  88.26 94.74 0 bottom
R7U8  0  [SMR0402IA]  88.64 93.85 270 bottom
R7U9  10  [SMR0402IA]  95.5 93.72 270 bottom
R7U10  0  [SMR0402IA]  86.61 93.6 0 bottom
R7U11  0  [SMR0402IA]  86.61 93.6 180 bottom
R7U12  75K  [SMR0402IA]  82.67 93.6 0 bottom
R7U13  10  [SMR0402IA]  90.42 93.22 270 bottom
R7U14  0  [SMR0402IA]  86.61 92.84 180 bottom
R7U15  33  [SMR0402IA]  93.09 92.71 0 bottom
R7U16  33  [SMR0402IA]  91.44 92.71 0 bottom
R7U17  0  [SMR0402IA]  89.53 92.07 270 bottom
R7U18  0  [SMR0402IA]  85.72 92.07 0 bottom
R7U19  10K  [SMR0402IA]  84.32 91.69 90 bottom
R7U20  33  [SMR0402IA]  95.5 91.18 0 bottom
R7U21  33  [SMR0402IA]  88.64 91.18 90 bottom
R7U22  33  [SMR0402IA]  88.64 91.18 270 bottom
R7U23  33  [SMR0402IA]  93.98 91.06 270 bottom
R7U24  33  [SMR0402IA]  93.98 91.06 90 bottom
R7U25  33  [SMR0402IA]  92.32 91.06 270 bottom
R7U26  33  [SMR0402IA]  92.32 91.06 90 bottom
R7U27  33  [SMR0402IA]  89.53 90.3 90 bottom
R7U28  33  [SMR0402IA]  96.39 89.53 90 bottom
R7U29  33  [SMR0402IA]  96.39 89.53 270 bottom
R7U30  0  [SMR0402IA]  70.86 88.14 0 bottom
R7U31  10K  [SMR0402IA]  72.64 87.25 90 bottom
R7U32  0  [SMR0402IA]  71.75 87.25 90 bottom
R7U33  1K  [SMR0402IA]  71.62 80.26 0 bottom
R7U34  1K  [SMR0402IA]  72.51 79.37 180 bottom
R7U35  1K  [SMR0402IA]  71.62 78.36 0 bottom
R7V1  0  [SMR0402IA]  73.15 50.54 90 bottom
R7V2  0  [SMR0402IA]  72.26 50.54 90 bottom
R7W1  0.005  [SMR0805IC]  94.74 28.7 270 bottom
R7W2  0.005  [SMR0805IC]  92.71 28.7 270 bottom
R7W3  0  [SMR0402IA]  85.21 27.56 270 bottom
R7W4  0  [SMR0402IA]  84.45 27.56 270 bottom
R8A1  820  [SMR0402IA]  50.03 286.64 270 top
R8A2  1.2K  [SMR0402IA]  51.3 286.64 270 top
R8A3  2.7K  [SMR0402IA]  52.57 286.64 270 top
R8A4  10K  [SMR0402IA]  53.84 286.64 270 top
R8A5  22k  [SMR0402IA]  57.02 286.64 270 top
R8A6  1.2K  [SMR0402IA]  58.29 286.64 270 top
R8A7  2.7K  [SMR0402IA]  59.56 286.64 270 top
R8A8  10K  [SMR0402IA]  60.83 286.64 270 top
R8A9  0  [SMR0402IA]  32.25 285.24 270 top
R8A10  0  [SMR0603IA]  30.22 282.57 270 top
R8A11  0.01  [SMR4_0603ID_RVP]  30.09 279.65 0 top
R8A12  0  [SMR0402IA]  50.03 275.84 270 top
R8A13  0  [SMR0402IA]  57.02 275.84 270 top
R8A14  10K  [SMR0402IA]  35.81 274.95 90 top
R8A15  2.7K  [SMR0402IA]  37.08 274.95 90 top
R8A16  1.2K  [SMR0402IA]  38.35 274.95 90 top
R8A17  820  [SMR0402IA]  39.62 274.95 90 top
R8A18  10K  [SMR0402IA]  42.92 274.95 90 top
R8A19  2.7K  [SMR0402IA]  44.19 274.95 90 top
R8A20  1.2K  [SMR0402IA]  45.46 274.95 90 top
R8A21  22k  [SMR0402IA]  46.73 274.95 90 top
R8A22  1.5K  [SMR0402IA]  28.82 273.18 180 top
R8A23  1.5K  [SMR0402IA]  28.82 272.16 180 top
R8A24  0  [SMR0603IA]  25.27 269.62 0 top
R8A25  0  [SMR0603IA]  25.27 268.48 0 top
R8A26  0  [SMR0603IA]  28.06 268.48 180 top
R8A27  0  [SMR0402IA]  25.9 266.57 180 top
R8A28  10K  [SMR0402IA]  28.57 266.57 180 top
R8A29  0  [SMR0402IA]  26.03 263.52 180 top
R8A30  0  [SMR0402IA]  26.03 262.25 180 top
R8A31  100K  [SMR0402IA]  26.03 260.98 180 top
R8A32  100K  [SMR0402IA]  26.03 259.97 180 top
R8B1  100K  [SMR0402IA]  31.62 259.59 180 top
R8B2  100K  [SMR0402IA]  32.76 259.59 0 top
R8B3  0  [SMR0402IA]  25.14 257.68 0 top
R8B4  0  [SMR0402IA]  26.92 257.68 180 top
R8B5  0.002  [SMR4_2512IG_RVP]  39.37 256.28 270 top
R8B6  33  [SMR0402IA]  25.14 255.78 90 top
R8B7  0  [SMR0402IA]  29.71 255.01 0 top
R8B8  0  [SMR0603IA]  27.94 253.74 0 top
R8B9  0  [SMR0603IA]  30.73 253.74 180 top
R8B10  0.002  [SMR4_2512IG_RVP]  54.22 253.62 0 top
R8B11  22  [SMR0402IA]  26.28 252.73 180 top
R8B12  33  [SMR0402IA]  24.89 248.54 270 top
R8B13  22  [SMR0402IA]  24.89 246.76 90 top
R8B14  0  [SMR0603IA]  26.16 244.09 180 top
R8B15  0  [SMR0402IA]  33.78 243.46 0 top
R8B16  0  [SMR0402IA]  24.76 242.7 0 top
R8B17  0  [SMR0402IA]  26.54 242.7 180 top
R8B18  0  [SMR0402IA]  34.67 242.57 180 top
R8B19  0  [SMR0402IA]  34.79 238.89 180 top
R8B20  200K  [SMR0402IA]  45.72 238.89 90 top
R8B21  0  [SMR0402IA]  45.72 236.85 90 top
R8B22  0  [SMR0402IA]  45.72 235.84 0 top
R8B23  0  [SMR0603IA]  26.03 235.2 180 top
R8B24  0  [SMR0402IA]  45.72 234.69 0 top
R8B25  0  [SMR0603IA]  32.63 234.44 180 top
R8B26  0  [SMR0603IA]  26.03 233.68 180 top
R8B27  0  [SMR0402IA]  54.22 233.68 0 top
R8B28  0  [SMR0402IA]  46.6 233.42 180 top
R8B29  0  [SMR0603IA]  32.63 233.04 180 top
R8B30  0.01  [SMR4_0603ID_RVP]  34.54 233.04 90 top
R8B31  10mOHM  [SMR4_0805IB_RVP]  29.18 232.28 90 top
R8B32  10mOHM  [SMR4_0805IB_RVP]  51.68 232.41 90 top
R8B33  0  [SMR0603IA]  33.4 230 90 top
R8B34  0  [SMR0603IA]  34.67 230 90 top
R8B35  0  [SMR0402IA]  45.72 230 0 top
R8B36  0  [SMR0402IA]  55.11 230 180 top
R8B37  0  [SMR0402IA]  45.72 228.85 0 top
R8B38  0  [SMR0402IA]  55.11 228.85 180 top
R8B39  10K  [SMR0402IA]  29.21 228.22 270 top
R8B40  10K  [SMR0402IA]  50.41 227.96 180 top
R8B41  0  [SMR0402IA]  28.32 227.33 90 top
R8B42  200K  [SMR0402IA]  30.09 227.33 90 top
R8C1  10K  [SMR0402IA]  49.53 227.07 0 top
R8C2  0  [SMR0402IA]  50.41 226.19 180 top
R8C3  0  [SMR0402IA]  45.72 225.42 0 top
R8C4  0  [SMR0402IA]  55.11 225.42 180 top
R8C5  0  [SMR0402IA]  31.87 224.79 90 top
R8C6  0  [SMR0402IA]  45.72 224.28 0 top
R8C7  0  [SMR0402IA]  55.11 224.28 180 top
R8C8  10K  [SMR0402IA]  29.46 223.39 0 top
R8C9  0  [SMR0402IA]  31.36 222.38 270 top
R8C10  0  [SMR0402IA]  34.67 222.38 180 top
R8C11  10K  [SMR0402IA]  27.81 221.99 0 top
R8C12  0  [SMR0402IA]  29.59 221.99 0 top
R8C13  45.3K  [SMR0402IA]  25.78 221.49 180 top
R8C14  0  [SMR0402IA]  45.72 220.85 0 top
R8C15  0  [SMR0402IA]  55.11 220.85 180 top
R8C16  0  [SMR0402IA]  24.89 220.34 0 top
R8C17  0  [SMR0402IA]  45.72 219.71 0 top
R8C18  0  [SMR0402IA]  55.11 219.71 180 top
R8C19  100K  [SMR0402IA]  28.82 217.3 0 top
R8C20  100K  [SMR0402IA]  32.25 217.3 0 top
R8C21  0  [SMR0402IA]  45.72 216.28 0 top
R8C22  0  [SMR0402IA]  55.11 216.28 180 top
R8C23  0  [SMR0402IA]  45.72 215.14 0 top
R8C24  0  [SMR0402IA]  55.11 215.14 180 top
R8C25  4.7K  [SMR0402IA]  31.62 215.01 270 top
R8C26  0  [SMR0402IA]  32.76 215.01 270 top
R8C27  0  [SMR0402IA]  26.28 213.99 180 top
R8C28  0  [SMR0402IA]  46.6 213.99 180 top
R8C29  0  [SMR0402IA]  54.22 213.99 0 top
R8C30  0  [SMR0402IA]  45.72 212.98 0 top
R8C31  0  [SMR0402IA]  26.28 212.85 180 top
R8C32  0  [SMR0402IA]  45.72 211.96 0 top
R8C33  0  [SMR0402IA]  25.4 211.71 0 top
R8C34  4.7K  [SMR0402IA]  26.28 210.69 180 top
R8C35  10K  [SMR0402IA]  26.28 209.17 180 top
R8C36  10K  [SMR0402IA]  26.28 208.41 180 top
R8C37  0  [SMR0402IA]  35.94 208.28 0 top
R8C38  22k  [SMR0402IA]  40 208.28 180 top
R8C39  0  [SMR0402IA]  43.43 208.28 0 top
R8C40  0  [SMR0402IA]  45.46 208.28 0 top
R8C41  0  [SMR0402IA]  31.11 207.52 180 top
R8C42  10K  [SMR0402IA]  35.94 207.14 0 top
R8C43  0  [SMR0402IA]  27.68 206.75 270 top
R8C44  0  [SMR0402IA]  30.09 206.63 180 top
R8C45  20K  [SMR0402IA]  31.11 206.63 270 top
R8C46  0  [SMR0402IA]  35.94 205.99 0 top
R8C47  100  [SMR0402IA]  44.57 204.85 90 top
R8C48  100K  [SMR0402IA]  27.68 204.72 270 top
R8C49  0  [SMR0402IA]  31.24 204.09 180 top
R8C50  10K  [SMR0402IA]  32.51 204.09 0 top
R8C51  0  [SMR0402IA]  28.82 203.83 90 top
R8C52  1K  [SMR0402IA]  47.49 203.2 180 top
R8C53  4.7K  [SMR0402IA]  49.4 203.2 0 top
R8C54  100K  [SMR0402IA]  51.3 203.2 0 top
R8C55  20K  [SMR0402IA]  31.24 202.94 180 top
R8C56  0  [SMR0402IA]  44.57 201.93 180 top
R8C57  10K  [SMR0402IA]  50.29 201.93 180 top
R8C58  0  [SMR0402IA]  51.3 201.93 0 top
R8C59  10K  [SMR0402IA]  27.68 201.8 0 top
R8C60  10K  [SMR0402IA]  51.3 201.04 0 top
R8C61  10K  [SMR0402IA]  50.31 200.79 180 top
R8C62  10K  [SMR0402IA]  30.35 200.66 0 top
R8C63  10K  [SMR0402IA]  43.68 200.15 90 top
R8C64  47K  [SMR0402IA]  44.57 200.15 90 top
R8C65  10K  [SMR0402IA]  37.33 199.64 0 top
R8C66  0  [SMR0402IA]  39.37 199.64 0 top
R8C67  10K  [SMR0402IA]  42.29 199.64 180 top
R8C68  0  [SMR0402IA]  31.24 199.52 180 top
R8C69  0  [SMR0402IA]  53.72 199.39 270 top
R8C70  75K  [SMR0402IA]  54.48 198.5 90 top
R8C71  75K  [SMR0402IA]  55.49 198.5 90 top
R8C72  0  [SMR0402IA]  49.27 198.37 0 top
R8C73  0  [SMR0402IA]  47.37 198.25 180 top
R8C74  0  [SMR0402IA]  58.16 198.25 0 top
R8C75  4.7K  [SMR0402IA]  37.84 197.74 180 top
R8C76  100K  [SMR0402IA]  46.48 197.23 0 top
R8C77  10K  [SMR0402IA]  58.16 197.23 0 top
R8C78  0.01  [SMR4_0603ID_RVP]  25.65 196.59 180 top
R8C79  10K  [SMR0402IA]  35.05 196.59 0 top
R8C80  0  [SMR0402IA]  36.95 196.59 0 top
R8C81  10K  [SMR0402IA]  58.16 196.21 0 top
R8C82  4.7K  [SMR0402IA]  38.98 195.32 270 top
R8C83  10K  [SMR0402IA]  46.48 195.32 270 top
R8C84  0  [SMR0402IA]  58.16 195.2 0 top
R8D1  0  [SMR0402IA]  37.84 194.44 90 top
R8D2  4.7K  [SMR0402IA]  41.27 194.44 90 top
R8D3  10K  [SMR0402IA]  42.79 194.44 90 top
R8D4  100K  [SMR0402IA]  43.94 194.44 90 top
R8D5  0  [SMR0402IA]  45.33 194.44 90 top
R8D6  3.3K  [SMR0402IA]  47.62 194.44 90 top
R8D7  100K  [SMR0402IA]  27.55 194.18 0 top
R8D8  249  [SMR0402IA]  50.16 192.78 0 top
R8D9  0  [SMR0402IA]  26.92 191.77 90 top
R8D10  200K  [SMR0402IA]  32 189.36 270 top
R8D11  0  [SMR0402IA]  35.43 189.36 270 top
R8D12  0  [SMR0402IA]  36.57 189.36 270 top
R8D13  3.32K  [SMR0402IA]  38.86 189.36 270 top
R8D14  10K  [SMR0402IA]  57.65 189.36 0 top
R8D15  3.92K  [SMR0402IA]  29.71 188.47 90 top
R8D16  10K  [SMR0402IA]  30.86 188.47 90 top
R8D17  8.2K  [SMR0402IA]  40 188.47 90 top
R8D18  10K  [SMR0402IA]  41.14 188.47 90 top
R8D19  4.7K  [SMR0402IA]  42.29 188.47 90 top
R8D20  4.7K  [SMR0402IA]  43.43 188.47 90 top
R8D21  0  [SMR0402IA]  52.83 188.21 0 top
R8D22  0  [SMR0402IA]  28.57 186.94 270 top
R8D23  1K  [SMR0402IA]  36.19 186.05 0 top
R8D24  1M  [SMR0402IA]  38.6 185.8 270 top
R8D25  2.43K  [SMR0402IA]  43.3 185.8 0 top
R8D26  0  [SMR0402IA]  46.48 185.8 0 top
R8D27  1M  [SMR0402IA]  31.87 184.91 180 top
R8D28  10K  [SMR0402IA]  33.4 184.91 0 top
R8D29  10K  [SMR0402IA]  39.62 184.91 90 top
R8D30  10K  [SMR0402IA]  40.89 184.66 270 top
R8D31  0  [SMR0402IA]  44.19 184.66 180 top
R8D32  47K  [SMR0402IA]  47.37 184.66 180 top
R8D33  22k  [SMR0402IA]  49.02 184.66 0 top
R8D34  10K  [SMR0402IA]  31.87 183.77 180 top
R8D35  0  [SMR0402IA]  34.29 183.77 180 top
R8D36  4.7K  [SMR0402IA]  37.08 183.77 180 top
R8D37  0  [SMR0402IA]  38.73 183.77 0 top
R8D38  1K  [SMR0402IA]  44.19 183.51 180 top
R8D39  4.7K  [SMR0402IA]  47.37 183.51 180 top
R8D42  0  [SMR0402IA]  46.48 182.24 0 top
R8D43  0  [SMR0402IA]  49.91 182.24 180 top
R8D45  4.7K  [SMR0402IA]  30.86 181.23 270 top
R8D46  100K  [SMR0402IA]  47.37 181.1 180 top
R8D47  0  [SMR0402IA]  26.79 178.18 180 top
R8D49  49.9K  [SMR0402IA]  25.9 177.29 0 top
R8D50  0  [SMR0402IA]  30.48 177.29 270 top
R8D53  0  [SMR0402IA]  26.79 176.4 180 top
R8D54  0  [SMR0402IA]  29.71 176.4 180 top
R8D57  0  [SMR0402IA]  44.95 175.89 90 top
R8D59  0  [SMR0402IA]  26.79 175.51 180 top
R8D60  1K  [SMR0402IA]  39.75 174.88 270 top
R8D61  0  [SMR0402IA]  42.67 174.88 270 top
R8D63  49.9K  [SMR0402IA]  25.9 174.62 0 top
R8D64  47K  [SMR0402IA]  31.87 174.24 0 top
R8D65  0  [SMR0402IA]  34.67 174.24 180 top
R8D66  10K  [SMR0402IA]  41.91 173.99 90 top
R8D67  10K  [SMR0402IA]  48.26 174.5 180 top
R8D68  0  [SMR0402IA]  37.97 173.35 270 top
R8D69  0  [SMR0402IA]  32.51 169.8 270 top
R8D70  0  [SMR0402IA]  36.57 172.46 90 top
R8D71  0  [SMR0402IA]  31.87 172.34 270 top
R8D72  0  [SMR0402IA]  25.9 172.21 0 top
R8D74  0  [SMR0402IA]  47.37 171.32 180 top
R8D76  0  [SMR0402IA]  41.65 170.18 0 top
R8D77  0  [SMR0402IA]  29.71 169.8 90 top
R8D78  0  [SMR0402IA]  36.57 169.8 270 top
R8D79  0  [SMR0402IA]  31.49 168.91 90 top
R8D80  0  [SMR0402IA]  33.9 168.91 90 top
R8D81  0  [SMR0402IA]  34.67 168.91 90 top
R8D84  0  [SMR0402IA]  42.41 166.11 90 top
R8D85  100K  [SMR0402IA]  33.9 165.23 180 top
R8D86  0.01  [SMR0603IA]  44.78 164.84 270 top
R8D87  0.01  [SMR0603IA]  51.76 164.71 0 top
R8D88  31.6K  [SMR0402IA]  33.02 164.08 0 top
R8D89  10K  [SMR0402IA]  42.41 164.08 90 top
R8D90  100K  [SMR0402IA]  33.02 162.94 0 top
R8D91  0  [SMR0402IA]  27.43 162.3 270 top
R8D92  0  [SMR0402IA]  28.32 162.3 270 top
R8D93  0  [SMR0402IA]  43.3 170.18 0 top
R8D94  100K  [SMR0402IA]  47.37 172.85 180 top
R8D95  0  [SMR0402IA]  47.37 173.61 180 top
R8D96  0  [SMR0402IA]  48.26 175.39 180 top
R8D97  0  [SMR0402IA]  48.64 167.77 0 top
R8D98  0  [SMR0402IA]  48.64 168.53 0 top
R8D99  0  [SMR0402IA]  49.53 166.88 180 top
R8E1  0  [SMR0402IA]  39.37 161.67 90 top
R8E2  22.1K  [SMR0402IA]  40.38 161.67 90 top
R8E3  1K  [SMR0402IA]  41.4 161.67 90 top
R8E4  0  [SMR0402IA]  42.41 161.67 90 top
R8E5  0  [SMR0402IA]  45.46 159.76 0 top
R8E6  51K  [SMR0402IA]  49.53 159.13 270 top
R8E7  232K  [SMR0402IA]  51.3 159 180 top
R8E8  0  [SMR0402IA]  48.76 158.24 180 top
R8E11  1K  [SMR0402IA]  41.14 157.35 90 top
R8E13  1.2K  [SMR0402IA]  32 156.46 0 top
R8E14  0.01  [SMR0603IA]  44.72 155.69 270 top
R8E15  0.01  [SMR0603IA]  51.71 155.57 0 top
R8E16  1.2K  [SMR0402IA]  41.14 153.67 90 top
R8E17  0  [SMR0402IA]  29.84 152.91 180 top
R8E18  10K  [SMR0402IA]  28.95 151.76 0 top
R8E19  10K  [SMR0402IA]  32.38 151.76 180 top
R8E20  10K  [SMR0402IA]  28.95 150.62 0 top
R8E21  10K  [SMR0402IA]  32.38 150.62 180 top
R8E22  51K  [SMR0402IA]  50.67 149.86 270 top
R8E23  102K  [SMR0402IA]  52.45 149.86 180 top
R8E24  10K  [SMR0402IA]  28.95 149.48 0 top
R8E25  10K  [SMR0402IA]  32.38 149.48 180 top
R8E26  0  [SMR0402IA]  49.78 149.1 180 top
R8E28  0  [SMR0402IA]  46.99 149.09 90 top
R8E31  1K  [SMR0402IA]  41.14 148.72 90 top
R8E32  10K  [SMR0402IA]  28.95 148.33 0 top
R8E33  10K  [SMR0402IA]  32.38 148.33 180 top
R8E36  10K  [SMR0402IA]  29.84 147.19 180 top
R8E37  0.01  [SMR0603IA]  44.75 146.55 270 top
R8E38  0.01  [SMR0603IA]  51.73 146.42 0 top
R8E39  1K  [SMR0402IA]  32.51 145.16 90 top
R8E40  1K  [SMR0402IA]  41.14 145.16 90 top
R8E41  51K  [SMR0402IA]  49.65 140.71 270 top
R8E42  232K  [SMR0402IA]  51.43 140.71 180 top
R8E43  0  [SMR0402IA]  48.76 140.21 180 top
R8E44  0  [SMR0402IA]  47.01 139.95 90 top
R8E45  10K  [SMR0402IA]  26.54 139.83 270 top
R8E49  0.01  [SMR0603IA]  44.72 137.25 270 top
R8E50  0.01  [SMR0603IA]  51.71 137.13 0 top
R8E51  0  [SMR0402IA]  42.03 136.02 180 top
R8E52  100K  [SMR0402IA]  27.55 135.13 0 top
R8E53  100K  [SMR0402IA]  31.11 135.13 0 top
R8E54  0  [SMR0402IA]  42.03 135.13 180 top
R8E55  0  [SMR0402IA]  42.03 134.24 180 top
R8E56  75  [SMR0402IA]  34.54 134.11 270 top
R8E57  0  [SMR0402IA]  42.03 133.35 180 top
R8E58  0  [SMR0402IA]  27.55 133.22 90 top
R8E59  0  [SMR0402IA]  28.44 133.22 90 top
R8E60  0  [SMR0402IA]  31.11 133.22 90 top
R8E61  0  [SMR0402IA]  32 133.22 90 top
R8E62  0  [SMR0402IA]  42.03 131.57 180 top
R8E63  51K  [SMR0402IA]  50.29 131.44 270 top
R8E64  39K  [SMR0402IA]  52.07 131.44 180 top
R8E65  10K  [SMR0402IA]  42.03 130.68 180 top
R8E66  0  [SMR0402IA]  49.4 130.68 180 top
R8E68  0  [SMR0402IA]  46.99 130.65 90 top
R8F1  0  [SMR0402IA]  42.03 129.79 180 top
R8F2  0  [SMR0402IA]  42.03 128.9 180 top
R8F3  0.01  [SMR0603IA]  44.7 128.36 270 top
R8F4  0.01  [SMR0603IA]  51.68 128.24 0 top
R8F5  0  [SMR0402IA]  42.03 128.01 180 top
R8F6  100K  [SMR0402IA]  29.71 127.13 270 top
R8F7  0  [SMR0402IA]  43.05 127.13 270 top
R8F8  0  [SMR0402IA]  42.03 126.24 180 top
R8F9  0  [SMR0402IA]  25.14 124.2 90 top
R8F10  51K  [SMR0402IA]  47.87 122.68 270 top
R8F11  232K  [SMR0402IA]  48.76 121.79 90 top
R8F12  10K  [SMR0402IA]  45.97 121.79 90 top
R8F13  100K  [SMR0402IA]  24.63 121.54 180 top
R8F14  100K  [SMR0402IA]  27.68 121.54 180 top
R8F15  100K  [SMR0402IA]  26.79 120.52 0 top
R8F16  0  [SMR0402IA]  27.68 119.51 180 top
R8F17  0  [SMR0402IA]  27.68 118.49 180 top
R8F18  0  [SMR0402IA]  27.68 117.47 180 top
R8F19  0  [SMR0402IA]  27.68 116.46 180 top
R8F20  0  [SMR0402IA]  24.89 113.16 270 top
R8F21  0  [SMR0402IA]  24.89 111.38 90 top
R8F22  0  [SMR0402IA]  26.03 110.74 270 top
R8F23  10K  [SMR0402IA]  24.89 109.85 270 top
R8F24  10K  [SMR0402IA]  27.17 109.85 270 top
R8F25  100K  [SMR0402IA]  29.33 109.85 270 top
R8F26  0  [SMR0402IA]  32.76 109.85 270 top
R8F27  10K  [SMR0402IA]  35.56 109.85 0 top
R8F28  10K  [SMR0402IA]  37.46 109.83 0 top
R8F30  0  [SMR0402IA]  26.03 108.96 90 top
R8F31  100K  [SMR0402IA]  31.75 108.96 90 top
R8F32  10K  [SMR0402IA]  33.65 108.96 90 top
R8F34  10K  [SMR0402IA]  35.56 107.95 0 top
R8F35  10K  [SMR0402IA]  36.44 107.06 180 top
R8F36  10K  [SMR0402IA]  36.44 106.17 180 top
R8F37  1K  [SMR0402IA]  51.81 105.54 0 top
R8F38  0.01  [SMR4_0603ID_RVP]  59.94 105.54 90 top
R8F39  0  [SMR0402IA]  35.56 105.03 0 top
R8F40  0  [SMR0402IA]  39.24 105.03 180 top
R8F41  102K  [SMR0402IA]  46.22 104.52 0 top
R8F42  0  [SMR0402IA]  35.56 104.14 0 top
R8F43  0  [SMR0402IA]  37.33 104.14 180 top
R8F44  15K  [SMR0402IA]  51.81 103.63 0 top
R8F45  0  [SMR0402IA]  37.33 102.87 180 top
R8F46  51K  [SMR0402IA]  47.11 102.74 180 top
R8F48  0  [SMR0402IA]  47.11 101.85 270 top
R8F49  0  [SMR0603IA]  42.79 101.47 270 top
R8F50  0.01  [SMR4_0603ID_RVP]  41.14 101.34 180 top
R8F51  0  [SMR0402IA]  39.37 99.95 0 top
R8F52  10K  [SMR0402IA]  40.25 98.93 180 top
R8F53  0  [SMR0603IA]  42.79 98.68 90 top
R8F54  0.01  [SMR4_0603ID_RVP]  46.22 98.3 0 top
R8F55  330  [SMR0402IA]  49.65 119.51 270 top
R8F56  22k  [SMR0402IA]  43.43 119.51 270 top
R8F70  100K  [SMR0402IA]  35.68 127.38 180 top
R8F71  0  [SMR0402IA]  35.94 129.79 90 top
R8G1  0  [SMR0402IA]  36.57 96.9 180 top
R8G2  0  [SMR0402IA]  38.48 96.65 0 top
R8G3  0  [SMR0402IA]  36.57 95.76 180 top
R8G4  0  [SMR0402IA]  38.48 95.5 0 top
R8G5  22.6K  [SMR0402IA]  41.91 95.5 180 top
R8G6  22.6K  [SMR0402IA]  38.48 94.36 0 top
R8G7  47KOHM  [STR0402MA]  177.54 95.88 0 top
R8G8  0.01  [SMR4_0603ID_RVP]  60.19 94.36 0 top
R8G9  0  [SMR0402IA]  54.22 93.98 0 top
R8G10  4.7K  [SMR0402IA]  36.57 92.58 180 top
R8G11  10K  [SMR0402IA]  43.56 92.2 0 top
R8G13  0  [SMR0402IA]  52.95 91.69 270 top
R8G14  4.7K  [SMR0402IA]  36.57 91.44 180 top
R8G15  51K  [SMR0402IA]  52.07 90.8 90 top
R8G16  10K  [SMR0402IA]  54.99 90.8 90 top
R8G17  0.01  [SMR4_0603ID_RVP]  36.95 89.66 180 top
R8G18  232K  [SMR0402IA]  49.65 89.28 0 top
R8G19  10K  [SMR0402IA]  27.3 88.01 270 top
R8G20  10K  [SMR0402IA]  24.76 87.12 90 top
R8G21  10K  [SMR0402IA]  28.57 87.12 90 top
R8G22  4.7K  [SMR0402IA]  29.46 87.12 90 top
R8G23  4.7K  [SMR0402IA]  30.35 87.12 90 top
R8G24  33  [SMR0402IA]  31.24 87.12 90 top
R8G25  0  [SMR0603IA]  33.27 86.74 90 top
R8G26  0  [SMR0603IA]  35.68 86.61 90 top
R8G27  0  [SMR0603IA]  36.95 86.61 90 top
R8G28  0.01  [SMR4_0603ID_RVP]  49.27 85.85 0 top
R8G29  10K  [SMR0402IA]  26.41 85.6 0 top
R8G30  10K  [SMR0402IA]  28.57 85.6 0 top
R8G33  0  [SMR0402IA]  32.25 84.96 180 top
R8G35  0.01  [SMR4_0603ID_RVP]  53.72 84.33 0 top
R8G36  0  [SMR0402IA]  32.25 83.95 180 top
R8G37  0  [SMR1206IA]  49.14 83.69 0 top
R8G38  1K  [SMR0402IA]  28.32 83.56 0 top
R8G40  100K  [SMR0402IA]  31.36 82.93 0 top
R8G41  0  [SMR0402IA]  39.75 81.66 270 top
R8G42  0  [SMR0402IA]  57.02 81.66 270 top
R8G43  0  [SMR0402IA]  38.1 81.41 180 top
R8G44  0  [SMR0402IA]  45.21 81.41 0 top
R8G45  10K  [SMR0402IA]  38.1 80.26 180 top
R8G46  2.2K  [SMR0402IA]  26.03 78.87 180 top
R8G47  2.2K  [SMR0402IA]  28.57 78.87 0 top
R8G48  1K  [SMR0402IA]  51.3 78.74 180 top
R8G49  1K  [SMR0402IA]  52.7 78.74 0 top
R8G50  0  [SMR0402IA]  51.3 77.85 180 top
R8G51  0  [SMR0402IA]  52.7 77.85 0 top
R8G52  8.2K  [SMR0402IA]  33.14 77.6 270 top
R8G53  1K  [SMR0402IA]  50.41 77.09 0 top
R8G54  1K  [SMR0402IA]  53.59 77.09 180 top
R8G55  0  [SMR0402IA]  34.41 76.71 90 top
R8G56  10K  [SMR0402IA]  25.01 76.45 180 top
R8G57  0  [SMR0402IA]  32 75.44 270 top
R8G58  0  [SMR0402IA]  33.14 75.44 270 top
R8G59  0  [SMR0402IA]  34.41 75.44 270 top
R8G60  1K  [SMR0402IA]  36.7 75.44 270 top
R8G61  1K  [SMR0402IA]  36.7 74.55 270 top
R8G62  0  [SMR0402IA]  32 73.66 90 top
R8G63  0  [SMR0402IA]  33.14 73.66 90 top
R8G64  0  [SMR0402IA]  34.41 73.66 90 top
R8G65  0  [SMR0402IA]  35.56 73.66 90 top
R8G66  200K  [SMR0402IA]  48.76 73.66 0 top
R8G67  10K  [SMR0402IA]  48.76 72.77 0 top
R8G68  10K  [SMR0402IA]  28.95 70.86 270 top
R8G69  0.002  [SMR4_2512IG_RVP]  40.89 70.86 0 top
R8G70  0  [SMR0402IA]  48.89 70.74 270 top
R8G71  0  [SMR0402IA]  24.89 69.98 90 top
R8G72  0  [SMR0402IA]  43.18 66.8 270 top
R8G73  0  [SMR0402IA]  29.71 66.55 270 top
R8G76  0  [SMR0402IA]  35.94 66.55 270 top
R8G77  0  [SMR0402IA]  36.83 66.55 270 top
R8G78  10K  [SMR0402IA]  44.19 65.91 90 top
R8G79  0  [SMR0402IA]  28.82 65.66 90 top
R8G80  0  [SMR0402IA]  30.6 65.66 90 top
R8G81  10K  [SMR0402IA]  31.49 65.66 90 top
R8G82  0  [SMR0402IA]  32.38 65.66 90 top
R8G83  0  [SMR0402IA]  35.05 65.66 90 top
R8G84  0  [SMR0402IA]  37.71 65.66 90 top
R8G85  0.005  [SMR4_0805IC_RVP]  52.83 65.66 270 top
R8G86  0.01  [SMR4_0603ID_RVP]  48.26 65.02 270 top
R8G87  249  [SMR0603IA]  61.59 82.17 0 top
R8H1  0  [SMR0402IA]  56.38 64.77 270 top
R8H2  0  [SMR0402IA]  57.4 64.77 270 top
R8H3  0  [SMR0402IA]  58.29 64.77 270 top
R8H4  0  [SMR0402IA]  60.11 64.77 270 top
R8H5  0  [SMR0402IA]  61 64.77 270 top
R8H6  100  [SMR0402IA]  46.1 58.8 0 top
R8H7  0  [SMR0402IA]  46.99 56.01 180 top
R8H8  10K  [SMR0402IA]  25.52 53.85 90 top
R8H9  0  [SMR0201IA]  29.54 54.56 270 top
R8H10  0  [SMR0201IA]  33.09 54.56 270 top
R8H11  0  [SMR0201IA]  36.52 54.56 270 top
R8H12  0  [SMR0201IA]  39.95 54.56 270 top
R8H13  0  [SMR0201IA]  30.17 54.02 90 top
R8H14  0  [SMR0402IA]  31.24 53.85 90 top
R8H15  0  [SMR0402IA]  32 53.85 90 top
R8H16  0  [SMR0201IA]  33.73 54.02 90 top
R8H17  0  [SMR0402IA]  34.67 53.85 90 top
R8H18  0  [SMR0402IA]  35.43 53.85 90 top
R8H19  0  [SMR0201IA]  37.16 54.02 90 top
R8H20  0  [SMR0402IA]  38.22 53.85 90 top
R8H21  0  [SMR0402IA]  38.98 53.85 90 top
R8H22  0  [SMR0201IA]  40.58 54.02 90 top
R8H23  0  [SMR0402IA]  41.65 53.85 90 top
R8H24  0  [SMR0402IA]  42.41 53.85 90 top
R8H25  0  [SMR0402IA]  55.88 51.94 90 top
R8H26  0  [SMR0402IA]  56.64 51.94 90 top
R8H27  0  [SMR0402IA]  58.67 51.94 90 top
R8H28  0  [SMR0402IA]  59.69 51.94 90 top
R8H29  0.01  [SMR4_0603ID_RVP]  54.22 51.43 180 top
R8H30  0  [SMR0402IA]  58.67 50.8 180 top
R8H31  0  [SMR0402IA]  59.69 50.8 0 top
R8H32  330  [SMR0402IA]  45.46 50.29 180 top
R8H33  8.2K  [SMR0402IA]  29.33 49.4 180 top
R8H34  1K  [SMR0402IA]  29.33 48.26 180 top
R8H36  330  [SMR0402IA]  29.33 47.12 180 top
R8H37  49.9  [SMR0402IA]  58.16 46.86 90 top
R8H38  0  [SMR0402IA]  37.21 46.61 180 top
R8H39  0  [SMR0402IA]  49.65 46.35 180 top
R8H40  100K  [SMR0402IA]  42.03 45.97 0 top
R8H41  8.2K  [SMR0402IA]  29.33 45.85 180 top
R8H42  0  [SMR0402IA]  38.98 45.21 180 top
R8H43  10K  [SMR0402IA]  34.29 45.08 180 top
R8H44  1K  [SMR0402IA]  29.33 44.7 180 top
R8H45  100K  [SMR0402IA]  42.03 44.7 0 top
R8H46  0  [SMR0402IA]  38.98 44.32 180 top
R8H47  10K  [SMR0402IA]  33.4 44.07 0 top
R8H48  330  [SMR0402IA]  28.44 43.56 0 top
R8H49  100K  [SMR0402IA]  42.03 43.43 0 top
R8H50  0  [SMR0402IA]  35.05 43.18 270 top
R8H51  10K  [SMR0402IA]  36.95 43.18 180 top
R8H52  0  [SMR0402IA]  36.95 42.29 180 top
R8H53  100K  [SMR0402IA]  42.03 42.04 0 top
R8H54  1K  [SMR0402IA]  24.76 40.64 0 top
R8H55  100K  [SMR0402IA]  42.03 40.64 0 top
R8H56  1M  [SMR0402IA]  47.75 40.64 180 top
R8H57  220  [SMR0402IA]  51.05 39.62 90 top
R8H58  220  [SMR0402IA]  52.19 39.62 90 top
R8H59  220  [SMR0402IA]  53.21 39.62 90 top
R8H60  220  [SMR0402IA]  54.86 39.62 90 top
R8H61  220  [SMR0402IA]  56.51 39.62 90 top
R8H62  150  [SMR0402IA]  58.92 39.62 90 top
R8H63  220  [SMR0402IA]  60.7 39.62 90 top
R8H64  10K  [SMR0402IA]  25.65 38.1 180 top
R8H65  10K  [SMR0402IA]  43.68 36.96 270 top
R8H66  10K  [SMR0402IA]  44.83 36.96 270 top
R8H67  0  [SMR0402IA]  40.25 36.07 90 top
R8H68  0  [SMR0402IA]  41.4 36.07 90 top
R8H69  0  [SMR0402IA]  42.54 36.07 90 top
R8H70  0  [SMR0402IA]  45.97 36.07 90 top
R8H71  0  [SMR1206IA]  51.56 35.94 0 top
R8H72  0  [SMR0402IA]  25.52 35.05 270 top
R8H73  0  [SMR0402IA]  28.19 35.05 270 top
R8H74  0  [SMR0402IA]  28.95 35.05 270 top
R8H75  1K  [SMR0402IA]  36.83 34.54 180 top
R8H76  10K  [SMR0402IA]  35.94 33.27 0 top
R8H77  10K  [SMR0402IA]  25.52 51.05 90 top
R8J1  0  [SMR0603IA]  52.83 29.46 0 top
R8J2  10K  [SMR0402IA]  52.07 26.54 180 top
R8J3  10K  [SMR0402IA]  53.59 26.54 0 top
R8J4  10K  [SMR0402IA]  52.07 25.27 180 top
R8J5  10K  [SMR0402IA]  53.59 25.27 0 top
R8J6  10K  [SMR0402IA]  52.07 24 180 top
R8J7  10K  [SMR0402IA]  53.59 24 0 top
R8J8  499  [SMR0402IA]  41.14 23.62 180 top
R8J9  1K  [SMR0402IA]  32.63 23.49 180 top
R8J10  499  [SMR0402IA]  34.92 23.49 0 top
R8J11  0  [SMR0402IA]  32.63 22.48 180 top
R8J12  0  [SMR0402IA]  35.81 22.48 180 top
R8J13  0  [SMR0402IA]  38.35 22.48 180 top
R8J14  0  [SMR0402IA]  40.25 22.48 0 top
R8J15  499  [SMR0402IA]  59.56 21.21 0 top
R8J16  0  [SMR0402IA]  60.45 20.06 180 top
R8J17  499  [SMR0402IA]  59.56 16.25 0 top
R8J18  0  [SMR0402IA]  60.45 14.98 180 top
R8J19  1K  [SMR0402IA]  31.62 12.57 0 top
R8J20  1K  [SMR0402IA]  35.43 12.57 0 top
R8J21  0  [SMR0402IA]  39.87 12.57 0 top
R8J22  4.7K  [SMR0402IA]  44.19 12.57 0 top
R8J23  10K  [SMR0402IA]  48.26 12.57 0 top
R8J24  1K  [SMR0402IA]  52.32 12.57 0 top
R8L1  0.01  [SMR0603IA]  34.29 268.48 0 bottom
R8L2  10K  [SMR0402IA]  50.67 268.1 180 bottom
R8L3  0.01  [SMR0603IB]  34.29 267.08 0 bottom
R8L4  10K  [SMR0402IA]  50.67 266.95 180 bottom
R8L5  100  [SMR0402IA]  60.7 265.81 0 bottom
R8L6  10K  [SMR0402IA]  50.67 265.81 180 bottom
R8L7  10K  [SMR0402IA]  50.67 264.67 180 bottom
R8N1  0  [SMR0402IA]  29.97 210.56 270 bottom
R8N2  0  [SMR0402IA]  31.24 206.63 270 bottom
R8R1  0  [SMR0402IA]  44.19 151.89 0 bottom
R8R2  0  [SMR0402IA]  43.3 151.89 180 bottom
R8R3  49.9K  [SMR0402IA]  45.08 151 180 bottom
R8R4  0  [SMR0402IA]  37.46 150.49 0 bottom
R8R5  0  [SMR0402IA]  36.57 150.49 180 bottom
R8R6  49.9K  [SMR0402IA]  45.08 150.24 180 bottom
R8R7  49.9K  [SMR0402IA]  38.35 149.6 180 bottom
R8R8  0  [SMR0402IA]  44.19 149.35 0 bottom
R8R9  0  [SMR0402IA]  43.3 149.35 180 bottom
R8R10  49.9K  [SMR0402IA]  38.35 148.84 180 bottom
R8R11  0  [SMR0402IA]  37.46 147.95 0 bottom
R8R12  0  [SMR0402IA]  36.57 148.84 180 bottom
R9A3  1K  [SMR0402IA]  10.16 272.67 0 top
R9A4  0  [SMR0603IA]  10.03 271.4 0 top
R9A5  0  [SMR0402IA]  13.3 271.15 90 top
R9A6  0  [SMR0402IA]  14.45 271.15 90 top
R9A7  0  [SMR0402IA]  15.72 271.15 90 top
R9A8  0  [SMR0402IA]  16.86 271.15 90 top
R9A9  0  [SMR0603IA]  10.03 270.13 0 top
R9A10  0  [SMR0402IA]  14.47 269.62 270 top
R9A11  0  [SMR0402IA]  15.74 269.62 270 top
R9A12  33  [SMR0402IA]  16.89 268.73 90 top
R9A13  33  [SMR0402IA]  11.04 268.1 180 top
R9A14  0  [SMR0402IA]  12.44 267.59 0 top
R9A15  33  [SMR0402IA]  11.04 267.33 180 top
R9A16  0  [SMR0402IA]  11.04 266.57 180 top
R9A17  0  [SMR0402IA]  11.04 265.43 180 top
R9A18  0  [SMR0402IA]  17.14 263.4 180 top
R9A19  0  [SMR0603IA]  10.16 263.02 0 top
R9A20  0  [SMR0402IA]  17.14 262.38 180 top
R9A21  0  [SMR0603IA]  10.16 261.87 0 top
R9A22  33K  [SMR0402IA]  16.25 261.36 0 top
R9A23  0.01  [SMR4_0603ID_RVP]  13.84 260.86 270 top
R9A24  0  [SMR0402IA]  16.25 260.35 0 top
R9A25  0  [SMR0603IA]  10.16 259.84 0 top
R9B1  0  [SMR0402IA]  16.25 259.21 0 top
R9B2  0  [SMR0603IA]  10.16 258.7 0 top
R9B3  33  [SMR0402IA]  11.04 257.68 180 top
R9B4  0  [SMR0402IA]  11.04 256.92 180 top
R9B5  0  [SMR0402IA]  11.04 256.16 180 top
R9B6  0  [SMR0402IA]  11.04 255.4 180 top
R9B7  0  [SMR0402IA]  13.58 254.38 270 top
R9B8  0  [SMR0402IA]  11.04 253.11 180 top
R9B9  33  [SMR0402IA]  24.51 252.73 0 top
R9B10  0  [SMR0402IA]  11.04 252.35 180 top
R9B11  0  [SMR0402IA]  13.58 250.32 90 top
R9B12  0  [SMR0402IA]  12.31 245.62 270 top
R9B13  0  [SMR0402IA]  12.31 245.62 90 top
R9B14  0  [SMR0402IA]  13.58 245.62 90 top
R9B15  0  [SMR0402IA]  13.58 245.62 270 top
R9B16  0  [SMR0402IA]  16.12 244.6 0 top
R9B17  0  [SMR0402IA]  16.12 244.6 180 top
R9B18  0  [SMR0402IA]  16.12 242.95 0 top
R9B19  0  [SMR0402IA]  16.12 242.95 180 top
R9B20  0  [SMR0402IA]  12.31 242.44 270 top
R9B21  0  [SMR0402IA]  13.58 242.44 270 top
R9B22  0  [SMR0402IA]  16.12 241.3 0 top
R9B23  0  [SMR0402IA]  16.12 241.3 180 top
R9B24  0  [SMR0402IA]  12.31 239.77 90 top
R9B25  0  [SMR0402IA]  13.58 239.77 90 top
R9B26  0  [SMR0402IA]  24.51 240.03 0 top
R9B27  0  [SMR0402IA]  16.12 239.65 180 top
R9B28  0  [SMR0402IA]  16.12 239.65 0 top
R9B29  0  [SMR0402IA]  24.51 239.14 0 top
R9C1  220  [SMR0402IA]  16.89 217.04 270 top
R9C2  0  [SMR0805IA]  11.3 215.26 90 top
R9C3  1K  [SMR0402IA]  16.89 214.63 270 top
R9C4  0  [SMR0402IA]  16.89 212.72 270 top
R9C5  3.3K  [SMR0402IA]  11.17 212.22 270 top
R9C6  6.2K  [SMR0402IA]  14.35 212.22 0 top
R9C7  15K  [SMR0402IA]  12.57 211.33 90 top
R9C8  2.2K  [SMR0402IA]  15.24 211.33 180 top
R9C9  0  [SMR0402IA]  14.35 210.44 270 top
R9C10  0  [SMR0402IA]  15.24 210.44 270 top
R9C11  0  [SMR0402IA]  14.35 208.53 0 top
