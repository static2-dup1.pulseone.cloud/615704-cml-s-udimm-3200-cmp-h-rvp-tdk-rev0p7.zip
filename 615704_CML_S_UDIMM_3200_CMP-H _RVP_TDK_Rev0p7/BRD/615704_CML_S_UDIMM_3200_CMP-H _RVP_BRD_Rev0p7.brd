# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VPP on BOTTOM: 158.31,103.06 158.52,102.84 158.52,101.91 157.64,101.02 157.64,101.01 157.53,100.91 157.53,99.87 158.5,98.91 158.5,98.22 158.36,98.08 155.05,98.08 154.92,98.21 154.92,113.7 153.94,114.68 153.94,115.06 154.66,115.78 154.66,131.61 153.94,132.33 153.94,132.68 154.23,132.97 157.17,132.97 157.6,132.54 157.6,132.54 157.69,132.42 157.82,132.34 157.84,132.33 157.84,130.83 157.94,130.73 157.94,130.73 158.27,130.4 158.27,130.27 158.3,130.2 158.3,129.91 158.27,129.84 158.27,129.69 157.89,129.31 157.89,128.41 157.81,128.33 157.81,127.44 157.89,127.37 157.89,126.97 157.94,126.92 157.94,126.9 158.19,126.64 158.19,126.59 158.25,126.51 158.25,126 158.19,125.93 158.19,125.86 157.86,125.53 157.86,124.54 157.84,124.51 157.84,123.11 157.86,123.09 157.86,123.06 158.32,122.6 158.32,121.74 157.61,121.03 157.61,119.4 157.66,119.35 158.32,118.69 158.32,115.51 158.53,115.29 158.53,114.36 157.71,113.54 157.71,112.83 157.84,112.7 157.84,112.7 158.3,112.24 158.3,111.48 157.56,110.74 157.56,109.47 158.42,108.61 158.42,107.47 158.38,107.4 158.31,107.4
+VPP_VR_OUT on TOP: 143.38,110.49 144.27,110.49 145.16,109.6 146.81,109.6 146.93,109.47 146.93,106.81 146.68,106.55 143,106.55 142.74,106.81 142.74,109.85
+VPP_VR_PHASE on TOP: 140.97,112.39 141.98,112.39 142.24,112.14 142.24,106.93 142.11,106.81 141.73,106.81 141.73,107.69 140.71,108.71 140.71,112.14
+VPP_VR_VIN on TOP: 137.41,108.71 140.33,108.71 141.47,107.57 141.47,106.93 141.22,106.68 141.09,106.68 140.71,106.3 137.28,106.3 137.28,108.58
+VREG_PS2 on TOP: 81.53,22.6 81.4,22.73 77.72,22.73 77.59,22.6 77.59,20.7 77.85,20.45 81.15,20.45 81.53,20.83
+VREG_PS2 on LAY6: 75.94,21.59 79.12,21.59 79.37,21.33 79.37,18.79 77.97,17.4 77.97,14.98 80.51,12.44 80.51,11.43 75.94,6.86 73.4,6.86 72.89,7.36 72.89,18.54
+VREG_PS2_FB on TOP: 83.82,23.62 83.69,23.49 81.66,23.49 81.4,23.24 80.64,23.24 80.51,23.37 80.51,25.02 80.89,25.4 83.69,25.4 83.82,25.27
+VTT on TOP: 257.17,84.71 255.01,84.71 254.76,84.96 254.76,86.87 255.01,87.12 257.04,87.12 257.3,86.87 257.3,84.83
+VTT on TOP: 218.71,133.18 218.7,133.16 218.7,131.23 218.43,130.96 217.92,130.96 217.07,131.82 217.07,132.56 216.9,132.72 216.9,133.83 217.37,133.83 217.39,133.84 217.39,133.85 217.86,134.33 218.29,134.33 218.71,133.9
+VTT on TOP: 215.88,114.55 215.24,113.92 215.24,113.91 214.72,113.39 214.72,108.47 215.24,107.95 215.24,105.66 215.28,105.63 215.28,105.03 214.75,104.51 214.75,99.4 215.28,98.87 216.64,97.51 216.64,95.76 216.89,95.5 218.8,95.5 218.93,95.63 218.93,97.53 218.8,97.66 218.8,116.97 218.54,117.22 218.54,120.39 218.29,120.65 217.02,120.65 215.88,119.51
+VTT on BOTTOM: 217.67,133.09 218.06,133.09 218.63,132.52 218.63,119.96 218.31,119.63 217.04,119.63 216.78,119.89 216.78,132.21
+VTT on LAY5: 217.42,97.03 218.69,97.03 225.93,89.79 254.25,89.79 257.3,86.74 257.3,85.6 257.04,85.34 225.8,85.34 216.66,94.49 216.66,96.26
+VTT_LDO_VIN on TOP: 263.01,82.17 262.76,82.17 262.63,82.29 262.63,83.69 262.12,84.2 262.12,87.63 262.25,87.76 263.27,87.76 263.39,87.63 263.39,84.2 263.14,83.95 263.14,82.29
+VTT_OUT on TOP: 256.03,84.45 259.84,84.45 260.47,83.82 262.25,83.82 262.5,83.56 262.5,82.04 260.35,82.04 259.96,82.42 255.77,82.42 255.65,82.55 255.65,84.07
+VTYPEC_VR_IN_BP on TOP: 108.96,268.1 110.74,268.1 111.76,267.08 111.76,262.63 110.99,261.87 109.22,261.87 108.96,262.13
AUDIO_AGND on TOP: 163.19,290.57 163.19,287.78 162.94,287.53 161.29,287.53 159.76,286 159.76,284.73 159,283.97 154.94,283.97 151.89,287.02 150.24,287.02 148.71,288.54 121.66,288.54 120.39,287.27 119.76,287.27 119.63,287.4 119.63,287.78 119.25,288.16 116.45,288.16 115.95,288.67 115.95,290.45 116.33,290.83 162.94,290.83
AUDIO_AGND on BOTTOM: 163.19,290.57 163.19,284.22 162.56,283.59 162.56,282.07 162.3,281.81 160.27,281.81 158.75,280.29 155.06,280.29 151.51,283.84 151.51,285.11 150.11,286.51 150.11,287.91 148.2,289.81 148.2,290.57 148.46,290.83 162.94,290.83
AUDIO_AGND on LAY2, LAY4, LAY7, LAY9: 115.82,290.85 163.19,290.85 163.19,284.07 162.69,283.57 162.69,281.03 161.16,279.5 161.16,278.49 160.67,278 155.59,278 155.47,277.87 147.55,277.87 146.04,279.38 146.04,284.2 143.23,287.01 136.42,287.01 132.21,282.8 132.21,275.95 131.97,275.71 131.37,275.71 131.12,275.84 129.41,275.84 128.07,277.66 127.73,278 126.72,278 126.48,278.23 126.48,281.03 126.21,281.3 121.68,281.3 121.28,280.9 121.28,276.63 122.05,275.87 122.05,275.45 121.53,275.04 121.35,274.95 120.29,274.95 119.13,273.79 119.13,272.77 118.89,272.54 116.94,272.54 116.7,272.77 116.7,280.76 115.94,281.65 115.94,283.11 116.18,283.34 116.94,283.34 117.59,283.99 117.59,285.6 117.19,286 115.92,286 115.82,286.11
AUDIO_AGND on LAY3, LAY5, LAY6, LAY8: 163.19,290.57 163.19,284.22 162.68,283.72 162.68,281.05 161.16,279.53 161.16,278.64 160.52,278 147.44,278 146.05,279.4 146.05,284.35 143.38,287.02 136.39,287.02 132.2,282.83 132.2,276.1 131.95,275.84 131.31,275.84 131.19,275.97 129.92,275.97 127.76,278.13 126.87,278.13 126.61,278.38 126.61,281.05 126.23,281.43 121.66,281.43 121.28,281.05 121.28,276.48 121.79,275.97 121.79,275.59 121.41,275.21 120.39,275.21 119.12,273.94 119.12,272.92 118.87,272.67 116.96,272.67 116.71,272.92 116.71,281.05 116.07,281.68 116.07,282.95 116.33,283.21 116.96,283.21 117.72,283.97 117.72,285.62 117.22,286.13 116.07,286.13 115.95,286.26 115.95,290.45 116.33,290.83 162.94,290.83
FAN_PWREN on TOP: 293.37,139.7 295.27,139.7 295.4,139.57 295.4,137.54 295.27,137.41 294.89,137.41 293.62,138.68 293.37,138.68 293.24,138.81 293.24,139.57
LAN_1P0_CTRL on TOP: 189.48,259.46 192.91,259.46 193.16,259.21 193.16,258.44 193.04,258.32 191,258.32 190.24,259.08 189.48,259.08 189.35,259.21 189.35,259.33
PD_DRAIN1 on TOP: 138.55,267.21 141.22,267.21 141.47,266.95 141.47,263.65 141.35,263.52 139.7,263.52 139.57,263.65 139.57,266.7 139.31,266.95 138.55,266.95
PD_DRAIN2 on TOP: 139.7,271.14 141.35,271.14 141.47,271.02 141.47,267.59 141.35,267.46 138.55,267.46 138.55,267.59 138.68,267.71 139.31,267.71 139.57,267.97 139.57,271.02
REAR_FAN_TACH_DRIVER on TOP: 5.71,215.77 5.2,215.26 5.2,213.87 5.84,213.23 8.12,213.23 9.65,214.76 11.81,214.76 11.93,214.88 11.93,215.64 11.81,215.77
UNNAMED_177_DIODETVSUNI_I16_C on TOP: 113.03,285.37 116.96,285.37 117.09,285.24 117.09,284.22 116.71,283.84 113.15,283.84 112.9,284.1 112.9,285.24
UNNAMED_178_RES_I136_B on TOP: 35.05,231.01 33.14,231.01 33.02,231.14 33.02,231.77 34.03,232.79 34.03,233.3 34.16,233.42 34.92,233.42 35.17,233.17 35.17,231.14
UNNAMED_179_CAPP_I69_A on TOP: 80.26,256.67 80.26,250.95 80.01,250.7 75.31,250.7 74.29,251.71 74.29,258.57 74.42,258.7 78.23,258.7
UNNAMED_179_MOSFETN1G1D3S2_I217_S3 on TOP: 72.89,258.57 73.66,258.57 73.78,258.44 73.78,256.92 73.15,256.28 72,256.28 71.88,256.41 71.88,257.81 72,257.94 72.26,257.94
UNNAMED_187_CAP_I52_B on TOP: 156.21,217.17 156.97,217.17 157.09,217.04 157.09,215.64 156.97,215.52 156.46,215.52 156.33,215.39 156.33,214.25 156.08,213.99 154.81,213.99 154.68,214.12 154.68,215.64 154.81,215.77 155.19,215.77 155.44,216.03 155.44,216.41
UNNAMED_194_CAP_I97_A on TOP: 129.66,265.81 131.19,265.81 131.31,265.68 131.31,264.67 132.33,263.65 132.33,262.76 132.08,262.51 130.3,262.51 129.54,263.27 129.54,265.68
UNNAMED_194_RES_I30_B on TOP: 136.52,173.1 136.77,172.85 136.77,169.92 136.39,169.54 134.62,169.54 134.49,169.67 134.49,172.85 134.74,173.1
USBC_FP3_ESD_CC2 on TOP: 115.69,200.02 114.42,200.02 114.04,199.64 114.04,197.36 114.3,197.1 115.44,197.1 115.82,197.48 115.82,199.9
V_0P9_LAN on TOP: 189.48,259.97 190.5,259.97 191,260.48 194.94,260.48 195.19,260.22 195.19,257.3 194.94,257.05 194.31,257.05 193.42,257.94 193.42,258.32 193.29,258.44 193.29,259.33 193.04,259.59 189.48,259.59 189.35,259.71 189.35,259.84
V_0P9_LAN on LAY5: 190.24,261.75 192.27,261.75 194.18,259.84 194.18,259.08 193.8,258.7 192.27,258.7 190.11,260.86 190.11,261.62
V_0P9_LAN on LAY6: 185.03,262.63 185.29,262.63 186.18,263.52 186.94,263.52 187.57,262.89 188.08,262.89 188.21,263.02 188.21,263.4 188.46,263.65 188.97,263.65 189.1,263.52 189.1,261.49 189.48,261.11 190.62,261.11 191.26,261.75 191.26,263.14 189.35,265.05 185.03,265.05 184.65,264.67 184.65,263.02
V_0P9_LAN on LAY6: 184.15,255.9 192.27,255.9 194.31,257.94 194.69,257.94 194.94,257.68 194.94,255.4 193.67,254.13 188.97,254.13 188.08,255.01 184.15,255.01 183.89,255.27 183.89,255.65
VCORE_VSWH_PH1 on TOP: 246.22,241.91 247.62,241.91 248.25,241.27 248.25,237.72 247.87,237.34 242.16,237.34 242.03,237.46 242.03,240.26 242.16,240.38 245.84,240.38 246.1,240.64 246.1,241.78
VCORE_VSWH_PH2 on TOP: 232.91,241.93 234.31,241.93 234.95,241.3 234.95,239.14 233.17,237.36 228.85,237.36 228.72,237.49 228.72,240.28 228.85,240.41 232.53,240.41 232.79,240.66 232.79,241.81
VCORE_VSWH_PH3 on TOP: 222.85,241.91 224.25,241.91 224.89,241.27 224.89,237.72 224.51,237.34 218.79,237.34 218.66,237.46 218.66,240.26 218.79,240.38 222.47,240.38 222.73,240.64 222.73,241.78
VCORE_VSWH_PH4 on TOP: 209.55,241.93 210.94,241.93 211.58,241.3 211.58,238.89 210.05,237.36 205.48,237.36 205.35,237.49 205.35,240.28 205.48,240.41 209.16,240.41 209.42,240.66 209.42,241.81
VCORE_VSWH_PH5 on TOP: 269.46,241.91 270.86,241.91 271.5,241.27 271.5,237.72 271.11,237.34 265.4,237.34 265.27,237.46 265.27,240.26 265.4,240.38 269.08,240.38 269.34,240.64 269.34,241.78
VCORE_VSWH_PH6 on TOP: 256.15,241.93 257.55,241.93 258.19,241.3 258.19,239.14 256.41,237.36 252.09,237.36 251.96,237.49 251.96,240.28 252.09,240.41 255.77,240.41 256.03,240.66 256.03,241.81
VCORE_VSWH_PH7 on TOP: 199.87,241.91 201.26,241.91 201.9,241.27 201.9,237.72 201.52,237.34 195.8,237.34 195.68,237.46 195.68,240.26 195.8,240.38 199.49,240.38 199.74,240.64 199.74,241.78
VCORE_VSWH_PH8 on TOP: 186.56,241.93 187.96,241.93 188.59,241.3 188.59,239.01 186.94,237.36 182.49,237.36 182.37,237.49 182.37,240.28 182.49,240.41 186.18,240.41 186.43,240.66 186.43,241.81
VSW_TYPEC_HV on TOP: 114.42,264.92 115.82,264.92 116.2,265.3 117.34,265.3 117.6,265.05 117.6,260.6 117.47,260.48 116.33,260.48 116.2,260.6 116.2,263.27 115.44,264.03 114.55,264.03 114.42,264.16

Small or netless copper shapes (teardrops, artwork): 10 on TOP, 1031 on BOTTOM, 264 on LAY3, 14 on LAY5, 1 on LAY6, 1 on LAY8

## Text on the board
BOTTOM: 10 | K72015-001
Ref Des/Silkscreen Bottom: B | C | A | E | SLP_S0 | D | F | A2 | DDR4 UDIMM CH A DIMM1 | DDR4 UDIMM CH A DIMM0 | DDR4 UDIMM CH B DIMM0 | DDR4 UDIMM CH B DIMM1 | I | P | R | L | U | M | W | T | N | V | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1 | INTEL CONFIDENTIAL | REFERENCE & VALIDATION PLATFORM | INTEL(R) 1151 SOCKET H4 PROCESSOR CANNONLAKE CHIPSET | INTEL(R) 1151 SOCKET H4 PROCESSOR KABYPOINT CHIPSET | CFL-S EVCRB | FAB1
User.Comments: A | L | B | M | C | N | D | P | E | R | F | T | G | U | H | V | J | W | 9 | 8 | 7 | 10mm | 0mm | 6 | 5 | 4 | 3 | 2 | 1 | 08/29 | 1. DIMENSIONS ARE IN INCHES | 2. DO NOT SCALE DRAWING | UNLESS OTHERWISE SPECIFIED: | DRN BY | CHK BY | ENGR | APVD | SIGNATURE | 2019 | DATE | SCALE | TITLE | SIZE | DCLC | CLASS CODE | DOCUMENT NUMBER | INTEL CONFIDENTIAL | 3065 BOWERS AVE | SANTA CLARA | CALIF.  95051 | SHEET | OF | REV
TOP: 1
Ref Des/Silkscreen Top: T | U | H | L | I | X | V | B | K | J | R | S | AI | W | Y | F | BH | Z | CA | BI | BG | CD | AA | CE | AH | BD | BE | BC | AD | BA | BF | AB | G | P | AG | E | Q | AF | AE | AC | CB | O | A | M | C | N | CC | D | 1 | CML-S RVP UDIMM-CMP-H CRB FAB3 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | MAD ADD# Label | S/N#+W/O# Label
LAY2: 2 | +V5S | +V3P3S | GND | +V5DSW_R | +V12S | +V3P3DSW | AUDIO_AGND | +V5DSW | +V5DUAL | +VCCPGPPR_3P3_1P8 | +VCCPGPPC_G_3P3 | +VCCPGPPD_3P3_1P8 | +VCCPGPPBC_3P3_1P8 | +VCCPGPPHK_3P3_1P8 | +VCCIN_AUX_PCH | +VCCA_CLKLDO_1P8 | +VCCPRIM_1P8 | +VCC1P05 | +VCCIO | +VDDQ | +VCCPGPPA_3P3_1P8 | +VCCPFUSE_3P3 | +V3P3A_V1P8A_PCH_SPI | +VCCPGPPEF_3P3_1P8 | +VCCDPHY_1P24
LAY3: 3
LAY4: 4 | AUDIO_AGND | GND
LAY5: 5
LAY6: 6
LAY7: 7 | AUDIO_AGND | GND
LAY8: 8
LAY9: 9 | +V12S | AUDIO_AGND | GND | +V12S_CPU
COMPVAL_TYPE_TOP: E | REV | 01 | DESCRIPTION | DFT | REVISIONS | DATE | CHK | APVD | PB,FAB DWG,CML-S CMP-H CRB,FAB3 | 9 | 2X  0.991  0.025 | 4X  3.175  0.05 | 0.05 | 0.025 | 5 | B | M | 0 | A | D | 19 | 6 | C | 7 | 1200 | PER ARTWORK | 0.2 | 8 | 3X  3.8    0.025 | 4X  4.03   0.05 | 16.51mm | 227.33mm | 204.47mm | 72.39mm | 237.49mm | 54.483mm | .010mm | COPPER % BY LAYER. | ROUT PATHS CONSIST OF THE 2.00MM PERIMETER SURROUNDING THE MAIN IMAGE | (INCLUDING TAB LOCATIONS). BALANCE THE OUTRIGGER COPPER % TO THE MAIN IMAGE | WITH THE EXCEPTION OF THE POST-ASSEMBLY 2.00MM ROUT PATHS. THE POST ASSEMBLY | 18 THIS BOARD REQUIRES VIA PLUGGING. | 25 VENDER TO ADD THEIVING WHERE REQUIRED TO BALANCE COPPER. | 26 VENDER TO MARK UL&DATE CODE APPROXIMATELY WHERE SHOWN. | 15 NO SILKSCREEN ALLOWED ON SOLDERABLE SURFACES. | 24 VENDER SHOULD DO FIRST ARTICAL INSPECTION OF FINISHED PCB PER 6.10.2 OF | 20 COPPER FILL AND OVER PLATE ALL MICRO VIAS ON THE TOP AND BOTTOM LAYERS. | 23 THIS BOARD IS TO BE FABRICATED USING HALOGEN FREE MATERIALS PER INTEL PRINTED | 19 SOLDERMASK WITHIN THIS REGION NOT TO EXCEED 0.0254 MM (1.0 MIL) | 17 SIZES SPECIFIED ARE DRILL SIZES. | 14 SILKSCREEN TO BE HALOGEN FREE AND WHITE IN COLOUR. | 16 SIZES SPECIFIED ARE FINISHED HOLE SIZES. | 13 SOLDERMASK TO BE HALOGEN FREE AND GREEN IN COLOUR. | 21 OUTRIGGER (WASTE MATERIAL) TO CONTAIN FULL METALIZATION (SOLID OR PAD PATTERN) | NOTES: UNLESS OTHERWISE SPECIFIED: (CCG STANDARD PB NOTES REV_04) | 22 PCB FABRICATION PROCESS AND MATERIALS MUST BE COMPLIANT WITH THE RESTRICTION | 12 SURFACE FINISH:     ENIG    OSP    ENEPIG (NiPdAu) | 9  THESE HOLES REQUIRE PRECISION DRILLING BASED ON AN ETCH LAYER | 11 ALL CONTROLLED IMPEDENCE IS  +/- 10%. | 10 DIMENSIONING AND TOLERANCING PER ANSI Y14.5M. | 6  DATUM -C- IS DEFINED THROUGH THE CENTER OF THIS HOLE | 4  DATUM -A- IS DEFINED AS THE PRIMARY SURFACE. | 5  DATUM -B- IS DEFINED AS THE HORIZONTIAL LINE THROUGH THE | 8  DATUM -E- IS DEFINED THROUGH THE CENTER OF THIS PAD | 7  DATUM -D- IS DEFINED THROUGH THE CENTER OF THESE TWO | 3  FABRICATE PER INTEL SPECIFICATION A84501,LATEST REVISION. | 2  THIS DRAWING ALSO EXISTS ON ELECTRONIC MEDIA. | 1  PART NUMBER IS PARENT ITEM IDENTIFICATION NUMBER ON | THE VIA PLUG MUST FILL BETWEEN 40-90% OF THE THICKNESS OF THE BOARD. | FOLLOW GERBER FOR SOLDERMASK APERTURES. | FOR VIPPO AND EPOXY/RESIN ONLY, ALL VIAS =< 0.3048MM SHOULD BE PLUGGED. | A84501 LATEST REVISION SOFT COPY OF DATA SHOULD BE SHARED WITH INTEL | PLEASE REFER TO TOP AND BOTTOM PLUG ARTWORK LAYERS FOR LOCATIONS. | USE INTEL SUGGESTED MATERIAL FROM APPROVED STACKUP | CIRCUIT BOARD SPECIFICATION A84501. | MAXIMUM DIMPLE CAN BE UP TO 0.0254MM (1.0 MIL). | ON THE USE OF HAZARDOUS SUBSTANCES (ROHS) DIRECTIVE. | MEASURED FROM THE SOLDER RESIST OPENING. | ENIPIG/NiPdAu  ELECTROLESS NICKEL ELECTROLESS PALLADIUM IMMERSION GOLD | OSP            ORGANIC SURFACE PRESERVATIVE PER PCB SPEC A84501. | ENIG           ELECTROLESS NICKEL IMMERSION GOLD PER PCB SPEC A84501. | Ni: 3-6um MIN, Pd: 0.05um (MIN) 0.15um (MAX), Au: 0.03um (MIN) 0.3um (MAX) | FIDUCIAL CENTERING DRILL PROCESS. | AND PERPENDICULAR TO -B- | CENTER OF HOLE AS SHOWN. | AND PERPENDICULAR TO -D- | COPPER PADS. | ENGINEERING BILL OF MATERIAL. | X | SOLDERMASK FILL | VIPPO (VIA IN PAD PLATE OVER) | 1:1 | 1 | 2 | 16 | 28.448mm | 68.6385mm | 72.7197mm | 78.74mm | 95.5594mm | 103.6385mm | 124.46mm | 161.417mm | 167.8034mm | 171.0084mm | 232.0284mm | 242.8034mm | 281.94mm | 288.29mm | 300.355mm | PROCESS FLOW | 5XR 5.000mm | K62288 | 03 | PRIMARY SIDE
PAGE_OUTLINE: THIS DRAWING CONTAINS INFORMATION | WHICH IS THE PROPRIETARY PROPERTY | OF INTEL CORPORATION. THIS DRAWING | IS RECEIVED IN CONFIDENCE AND ITS | CONTENTS MAY NOT BE DISCLOSED WITH- | OUT THE PRIOR WRITTEN CONSENT OF | INTEL CORPORATION. | D | C | B | A | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1
DIMENSION: 7 | 2 | 6 | 1 | 3 | 4 | 5 | 8 | P1 | P20 | P10 | P11 | 2.5mm | 10.5mm | Area E (M/B 8.89mm=350mil) | A5 | C5 | D5 | B5 | C4 | D4 | A4 | B4 | A1 | B1 | D1 | C1 | B9 | A9 | C9 | D9 | 7.85mm | 9 | 10 | 11 | 12 | 13 | 14 | 16 | 15 | 17 | 18 | 19 | 20 | 44 | 74 | 75 | 2.0mm | 5mm | 4.3mm | Area C (M/B 38.10mm=1500mil) | 32 | 31 | 21 | 22 | 23 | 24 | 25 | 26 | 27 | 30 | 28 | 29 | 0mm | 11mm | 6.00MM | 5.0 | mm | D7 | D6 | D3 | D2 | D8 | C7 | C3 | C6 | C8 | C2 | B7 | B3 | B6 | B8 | B2 | A7 | A6 | A3 | H1 | H2 | A8 | A2 | 15MM | 3MM | 15.00MM | 80 | 60 | Area B (M/B 15.24mm=600mil) | (Expansion Slot Area) | 16mm | 12.2mm | 65.5mm | 1.5mm | Area G (M/B 5.08mm=200mil) | 2mm | Area D (M/B 30.48mm=1200mil) | 3mm | (Chassis(clearance) 76.20mm) | 15.24MM | R4H4 | J4H1 | R3H10 | C3H9 | 40 | 39 | 59 | 79 | 99 | 100
DISPLAY_BOTTOM: 4.3mm | 11mm | 10.5mm | 16mm | 12.2mm | 65.5mm | 1.5mm | 0mm | 2mm | 5mm
User.8: 0mm
User.11: 15.24MM | 5mm | 80 | 60 | 1 | Area B (M/B 15.24mm=600mil) | (Expansion Slot Area) | 32 | 19 | 31 | 5 | 13 | 20 | 14 | 4 | 21 | 6 | 15 | 12 | 22 | 3 | 7 | 23 | 16 | 11 | 24 | 2 | 8 | 25 | 17 | 10 | 26 | 9 | 18 | 27 | 30 | 28 | 29 | Area G (M/B 5.08mm=200mil) | 2.5mm | 10.5mm | H1 | D1 | A1 | B1 | C1 | 0mm | D2 | B2 | A2 | C2 | B3 | C3 | D3 | A3 | D4 | A4 | B4 | C4 | D5 | B5 | A5 | C5 | A6 | D6 | B6 | C6 | A7 | B7 | C7 | D7 | D8 | C8 | A8 | B8 | B9 | A9 | D9 | C9 | H2 | A12 | B12 | Area D (M/B 30.48mm=1200mil) | Area C (M/B 38.10mm=1500mil) | 13mm | 12mm | 7.85mm | 11mm | 42 | P1 | P20 | P10 | P11 | 15MM | 3MM | 6.00MM | 15.00MM | (Chassis(clearance) 76.20mm) | Area E (M/B 8.89mm=350mil)
User.14: 38.1 | 38.3
User.15: 38.1 | 38.3
User.20: REV | EVCRB | 01 | DESCRIPTION | DFT | PB,FAB DWG,CML-S CMP-H CRB,FAB3 | REVISIONS | DATE | CHK | APVD | PRPREG (99.6um) | PREPREG (73.7um)) | PREPREG (73.7um) | CORE (101.6um) | CORE (177.8um) | PRPREG (300.7um) | FINISHED PCB THICKNESS TO BE 1.6mm 0.232mm/-0.127mm | LAYER 1-SIGNAL-40.6um Cu+PLATING | LAYER 2-PLANE -30.5um Cu. | LAYER 5-SIGNAL -30.5um Cu. | LAYER 8-SIGNAL-30.5um Cu. | LAYER 10-SIGNAL-40.6um Cu+PLATING | LAYER 3-SIGNAL-30.5um Cu. | LAYER 4-PLANE -30.5um Cu. | LAYER 6-SIGNAL -30.5um Cu. | LAYER 7-PLANE -30.5um Cu. | LAYER 9-PLANE -30.5um Cu. | *Attention to POOL effect on impedance control. | (POOL : Planes On Outer Layers) | Refer to Intel white papaer#45163 | LAYER 1-SIGNAL(Ch.A;4L reference) | LAYER 2-PLANE(GND/PWR/GND;4L refernce)) | LAYER 5-EMPTY | LAYER 8-EMPTY | LAYER 10-PLANE(GND;4L reference) | LAYER 3-PLANE(PWR/PWR/GND) | LAYER 4-PLANE/SIG(GND/GND/ECC) | LAYER 6-EMPTY | LAYER 7-EMPTY | LAYER 9-SIGNAL(Ch.B;4L reference)* | MEMORY IMPEDANCE FOR TOP LAYER with tabbed routing (ChA) | 190 UM | MEMORY IMPEDANCE FOR LAY 4 (ECC) | MEMORY IMPEDANCE FOR LAY 9 (ChB) | STRIPLINE IMPEDANCE FOR  LAY 3, LAY8 | 127 UM | 165 UM | 175 UM | DUAL STRIPLINE IMPEDANCE FOR LAY 5 AND LAY 6 | 100 UM | 215 UM | LINE | 200 UM | WIDTH | 115 UM | MICROSTRIP IMPEDANCE FOR TOP & BOTTOM LAYERS | 125 UM | 88 UM | 90 UM | 11 | NA | 140 UM | 230 UM | SPACING | DIFF | 42 OHM | 70 OHM | TARGET | 38.3 OHM | 43.7 OHM | IMPEDANCE | 75.3 OHM | 35 OHM | 65.1 OHM | 40 OHM | 68 OHM | 62 OHM | 50 OHM | 55 OHM | 100 OHM | 80 OHM | 85 OHM | LAY 4 | LAY 3 | LAY 8 | LAY 5 or 6 | LAYER | LAY 9 | TOP | TOP/BOT | LAY10&LAY3 or LAY10&LAY 4 | 1:1 | LAY 3 and LAY 10 | LAY 2/LAY9 | LAY 2 | LAY 4 and LAY 7 | LAY 4 and LAY2 | LAY 7 and LAY9 | REF. LAYER | 2 | Non Memory Area | Memory Area | LAYER STACKUP | K62288 | 03 | IMPEDANCE TABLE | D
User.33: AM,PB,VIA PLUG,                       ,S | K62302
User.34: AM,PB,VIA PLUG,                       ,P | K62301
User.45: FIGURE | FINISHED_SIZE | 0.2032 | 0.254 | 0.3048 | 0.3556 | 0.37 | 0.4064 | 0.55 | 0.5588 | 0.6 | 0.6096 | 0.635 | 0.66 | 0.6604 | 0.7 | 0.7112 | 0.7366 | 0.8 | 0.8382 | 0.8636 | 0.889 | 0.9 | 0.9398 | 0.94 | 0.95 | 0.9652 | 1.0 | 1.016 | 1.02 | 1.143 | 1.15 | 1.1684 | 1.19 | 1.1938 | 1.2192 | 1.2954 | 1.35 | 1.397 | 1.4224 | 1.5748 | 1.8 | 2.2 | 2.3 | 2.3114 | 4.32 | 0.85 | 0.991 | 1.0922 | 1.1 | 1.4986 | 1.6 | 1.6002 | 1.61 | 1.7 | 2.0 | 2.35 | 2.3622 | 2.9972 | 3.175 | 3.2512 | 3.8 | 3.8608 | 3.9624 | 4.0 | 4.03 | 1.25x0.7 | 1.5x0.7 | 1.7526x0.8382 | 1.9x0.6 | 2.0x0.4 | 2.0x0.7 | 2.0828x1.016 | 2.1x0.9 | 2.2x0.8 | 2.2098x0.8128 | 2.3x1.2 | 2.7x0.8 | 2.7x0.9 | 0.85x0.6 | 2.4384x1.1938 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | PLATED | NON-PLATED | QTY | 158 | 431 | 609 | 8069 | 2155 | 88 | 36 | 20 | 19 | 21 | 4 | 40 | 1152 | 164 | 3 | 13 | 10 | 2 | 12 | 6 | 32 | 38 | 54 | 52 | 8 | 11 | 124 | 49 | 126 | 15 | 9 | 5 | 1
