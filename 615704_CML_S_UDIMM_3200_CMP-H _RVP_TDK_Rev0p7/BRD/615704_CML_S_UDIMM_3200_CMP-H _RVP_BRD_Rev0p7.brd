# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_LAN_N_SLG: length 1.2
  TOP w0.1: EU4B2.2 172.46,256.28 R4B6.2
SLP_M_N_PULLUP: length 2.6
  TOP w0.1: R8J23.2 49.14,14.6 J8J10.3
SLP_S0_EC_N: length 376.8
  TOP w0.1: R7E28.2 68.12,141.02 66.53,141.02 66.05,140.54 62.53,140.54 v1(61.97,141.1) ; v1(126.07,18.49) J6J2.90 ; U8F6.33 17.79,105.09 v1(16.07,106.81) R9F22.2 ; J6J2.194 v1(141.55,19.51)
  LAY3 w0.1: v1(16.07,106.81) 16.07,106.19 11.24,101.36 11.24,95.79 8.83,93.37 3.9,93.37 3.29,92.76 3.29,36.41 4.4,35.3 8.09,35.3 10.46,32.93 10.46,20.54 13.35,17.64 13.35,16.06 14.61,14.8 18.47,14.8 21.78,11.5 41.22,11.5 41.59,11.12 66.33,11.12 69.07,8.38 80.89,8.38 81.66,7.61 98.09,7.61 101.75,11.27 106.14,11.27 106.96,12.09 108.07,12.09 112.81,7.36 114.89,7.36 115.94,6.31 126.31,6.31 126.77,6.76 126.77,8.24 v1(126.92,8.39)
  LAY5 w0.125: v1(10.82,140.97) 10.82,139.79 12.4,138.21 12.4,132.97 11.76,132.33 11.76,121.6 15.47,117.89 15.47,107.41 v1(16.07,106.81)
  LAY6 w0.125: v1(141.55,19.51) 141.01,18.97 126.55,18.97 v1(126.07,18.49)
  BOTTOM w0.1: v1(141.55,19.51) 142.11,18.96 142.11,16.25 140.04,14.18 140.04,9.85 138.45,8.27 133.62,8.27 131.85,6.49 127.95,6.49 126.92,7.52 v1(126.92,8.39) ; v1(10.82,140.97) 17.72,140.97 18.63,141.88 24.73,141.88 30.98,135.63 34.54,135.63 35.1,136.19 36.68,136.19 40,139.51 45.97,139.51 46.83,138.66 50.9,138.66 51.77,139.53 52.87,139.53 53.98,140.64 61.51,140.64 v1(61.97,141.1)
SLP_S0_LED_D: length 1.7
  TOP w0.38: 62.73,40.51 DS7H1.1
SLP_S0_LED_DRV: length 9.5
  TOP w0.305: DS7H1.2 62.73,45.34 62.99,45.59 62.99,48.39 61.59,49.78 60.01,49.78 59.7,49.48 EU8H2.3
SLP_S0_N: length 601.3
  TOP w0.1: v1(62.68,141.1) 63.01,140.77 65.96,140.77 66.67,141.48 R7E31.1 67.69,141.48 R7E28.1 68.83,142.62 R7E26.1 ; R2A56.1 v1(262.76,263.9) ; U8D8.3 36.89,171.89 36.77,172.01 36.77,172.26 R8D70.1 37.08,172.97 37.08,174.37 36.44,175 v1(34.67,175) ; v1(31.87,175) R8D64.1 TP8D2.1 R8D71.1 ; v1(72.72,73.33) 72.72,74.46 R7G30.2 ; v1(60.32,49.15) 60.2,49.03 EU8H2.2
  LAY5 w0.125: v1(51.91,47.37) 52.56,46.73 54.65,46.73 55.54,47.62 57.69,47.62 59.23,49.15 v1(60.32,49.15) ; v1(262.76,263.9) 260.34,261.48 254.06,261.48 251.93,259.35 237.14,259.35 236.52,258.72 233.62,258.72 232.33,257.43 230.68,257.43 230.3,257.81 226.55,257.81 226.17,258.19 225.04,258.19 224.52,257.67 216.2,257.67 214.65,259.21 211.66,259.21 210.77,258.33 208.74,258.33 208.08,257.67 199.72,257.67 197.79,255.74 195.73,255.74 194.76,254.76 193.54,254.76 193.15,254.37 182.43,254.37 180.24,252.18 174.41,252.18 173.88,252.71 147.8,252.71 147.19,252.1 137.79,252.1 134.8,249.1 131.97,249.1 130.61,247.74 130.61,246.76 129.72,245.87 126.72,245.87 125.51,244.66 116.8,244.66 116.37,245.09 111.57,245.09 111.36,244.87 109.48,244.87 108.18,246.18 95.22,246.18 94.25,245.21 92.16,245.21 91.19,246.18 87.32,246.18 84.85,248.64 83.2,248.64 82.54,249.3 79.72,249.3 79.24,249.78 79.24,250.32 78.99,250.57 72.65,250.57 70.97,252.25 70.12,252.25 69.77,252.61 52.14,252.61 51.79,252.25 51.09,252.25 50.5,252.85 49.06,252.85 48.21,252 42,252 v1(41.65,252.35) ; v1(72.72,73.33) 72.72,73.1 67.66,68.05 55.52,68.05 54.48,69.09 v1(54.48,69.32)
  LAY6 w0.125: v1(41.65,252.35) 40.85,252.35 37.88,249.38 37.88,247.99 36.07,246.18 36.07,245.47 32.26,241.66 32.26,238.02 32.76,237.51 32.76,236.46 31.5,235.19 31.5,227.69 30.86,227.05 30.86,223.93 31.75,223.05 31.75,217.85 32.91,216.69 32.91,211.98 32.56,211.63 32.56,210.89 32.89,210.56 34.16,210.56 35.81,208.91 35.81,207.82 37.85,205.78 37.85,201.43 37.59,201.17 37.59,199.63 38.17,199.05 38.17,197.68 37.97,197.48 37.97,192.53 37.71,192.28 37.71,191.51 37.08,190.88 37.08,184.13 34.92,181.97 34.92,175.92 34.67,175.66 v1(34.67,175) 34.18,174.52 34.18,170.54 35.51,169.21 35.51,166.83 34.67,165.99 34.67,153.8 32.25,151.38 32.25,145.32 36.84,140.74 36.84,138.44 34.54,136.14 v1(34.54,135.13) ; J8J13.32 54.35,10.29 52.83,10.29 51.48,11.63 51.48,40.56 51.81,40.89 51.81,47.27 v1(51.91,47.37) 51.91,51 51.42,51.5 51.42,53.43 52.96,54.96 52.96,61.98 52.32,62.62 52.32,65.91 52.96,66.55 52.96,68.83 53.44,69.32 v1(54.48,69.32) 54.97,69.81 54.97,72.68 54.38,73.26 54.38,73.82 54.96,74.4 54.96,75.77 55.37,76.17 55.37,80.32 52.39,83.29 52.39,93.45 51.78,94.06 51.78,110.92 57.78,116.92 57.78,130.63 58.16,131.01 58.16,137.41 61.08,140.33 61.92,140.33 v1(62.68,141.1)
  BOTTOM w0.1: v1(34.67,175) 34.16,174.5 32.38,174.5 v1(31.87,175) ; v1(62.68,141.1) 62,140.41 54.58,140.41 52.59,138.43 46.73,138.43 45.88,139.28 40.09,139.28 36.78,135.97 35.19,135.97 34.54,135.31 v1(34.54,135.13)
SLP_S0_PLT_EC_N: length 2.6
  TOP w0.1: R9G1.1 16.38,97.03 16.84,97.49 U8F6.51
SLP_S0_PLT_N: length 628.6
  TOP w0.1: v1(36.44,168.15) 36.57,168.27 R8D78.2 ; v1(17.73,172.16) 18.66,173.1 24,173.1 24.76,173.86 26.79,173.86 26.92,173.99 v1(27.55,173.99) ; U5C2.6 154.56,201.08 v1(154.43,201.22) ; v1(13.71,96.9) 14.35,96.9 R9G1.2 ; U8D11.6 35.05,171.86 34.95,171.96 34.54,171.96 34.26,172.24 34.26,172.85 35.17,173.76 35.17,174.37 35.43,174.62 36.06,174.62 v1(36.57,174.12) R8D70.2 ; v1(234.88,275.72) U3A4.2 ; U8C3.6 33.44,203.24 v1(33.52,203.33) ; v1(33.04,211.33) 32.99,211.33 32.63,211.68 U8C1.6
  LAY5 w0.125: v1(234.88,275.72) 233.88,274.72 230.5,274.72 228.58,272.79 226.46,272.79 225.8,272.14 225.8,270.76 224.53,269.48 220.79,269.48 220.05,270.22 209.71,270.22 208.86,269.37 206.83,269.37 206.62,269.57 205.83,269.57 205.19,270.21 197.31,270.21 192.86,274.66 180.74,274.66 180.32,275.08 180.11,275.08 180.1,275.08 177.59,275.08 176.32,273.81 169.28,273.81 166.85,276.24 163.46,276.24 161.93,274.72 147.05,274.72 143.02,278.75 138.89,278.75 134.37,274.22 134.37,272.03 133.76,271.43 133.76,270.03 130.36,266.63 130.36,266.13 126.23,262 123.69,262 122.01,260.32 116.2,260.32 115.79,260.73 109.88,260.73 107.77,258.62 102.98,258.62 99.09,262.51 91.79,262.51 90.85,261.57 89.87,261.57 87.61,263.83 85.96,263.83 85.38,264.41 81.06,264.41 79.54,265.94 68.73,265.94 68.6,265.8 65.75,265.8 64.93,266.63 60.83,266.63 60.25,266.04 52.42,266.04 51.61,265.23 47.25,265.23 46.11,264.09 44.81,264.09 44.23,264.67 41.27,264.67 v1(40.13,263.52) ; v1(163.93,206.65) 163.6,206.65 162.81,205.87 158.77,205.87 157.48,207.16 157.48,211.55 157.32,211.71 155.73,211.71 155.14,211.12 155.14,205.74 155.34,205.54 155.34,202.13 v1(154.43,201.22)
  LAY6 w0.125: v1(36.44,168.15) 36.14,168.45 36.14,170.33 35.8,170.67 35.8,173.34 v1(36.57,174.12) ; v1(17.73,172.16) 17.73,171.27 17.08,170.63 17.08,160.15 17.4,159.83 17.4,146.06 17.69,145.77 17.69,138.94 15.81,137.06 15.81,136.48 15.14,135.82 15.14,132.75 13.51,131.12 13.51,121.75 15.05,120.21 15.05,110.61 13.51,109.07 13.51,108.09 14.52,107.08 14.52,104.35 13.2,103.03 13.2,97.41 v1(13.71,96.9) ; v1(27.55,173.99) 26.54,175 26.54,178.43 27.55,179.44 27.55,182.94 30.16,185.55 32.89,185.55 33.65,186.31 33.65,197.74 33.17,198.22 33.17,202.97 v1(33.52,203.33) 32.13,204.72 32.13,205.59 31.12,206.6 31.12,207.59 29.42,209.29 29.42,211.97 29.67,212.22 29.67,216.03 28.32,217.38 28.32,222.63 27.71,223.23 27.71,227.68 25.37,230.03 25.37,233.65 27.42,235.7 27.42,237.38 26.83,237.97 26.83,239.3 29.85,242.32 29.85,243.94 30.86,244.95 30.86,248.54 32,249.68 32,254.38 33.59,255.97 33.59,256.48 37.65,260.54 37.65,261.81 38.86,263.02 39.62,263.02 v1(40.13,263.52) ; v1(163.93,206.65) 163.93,207.01 166.11,209.2 166.11,213.99 167,214.88 167.76,214.88 168.91,216.03 168.91,218.57 167.76,219.71 163.06,219.71 162.46,220.31 162.46,224.82 165.73,228.09 165.73,232.56 167.9,234.73 167.9,235.45 168.66,236.21 170.53,236.21 171.15,235.58 173.58,235.58 176.91,238.92 176.91,245.08 179.76,247.93 184.64,247.93 185.54,248.83 187.77,248.83 188.45,249.52 189.66,249.52 191.45,251.3 198.41,251.3 199.06,251.96 203,251.96 203.94,252.9 208.95,252.9 209.55,253.49 213.74,253.49 215.18,252.04 215.94,252.04 216.8,252.9 224.58,252.9 225.8,254.12 230.75,254.12 v1(233.42,256.79)
  BOTTOM w0.1: v1(234.88,275.72) 234.28,275.11 233.19,275.11 229.23,271.15 229.23,265.29 230.94,263.58 230.94,260.54 232.66,258.82 232.66,257.55 v1(233.42,256.79) ; 31.32,208.79 30.98,208.79 30.6,209.17 29.71,209.17 29.46,209.42 29.46,210.82 29.97,211.33 v1(33.04,211.33) 33.04,205.92 33.52,205.43 v1(33.52,203.33) ; v1(27.55,173.99) 27.94,173.99 28.67,174.72 30.45,174.72 31.24,175.51 35.17,175.51 v1(36.57,174.12)
SLP_S0_PLT_N_R: length 1.1
  TOP w0.1: U8D8.4 36.89,170.11 R8D78.1
SLP_S3_AIC: length 4
  TOP w0.1: R6H45.1 124.33,31.65 J6J1.16
SLP_S3_APS_N: length 2.9
  TOP w0.1: J9H3.2 18.41,42.92 R9H13.1
SLP_S3_EC_N: length 173.2
  TOP w0.1: U8F6.113 34.02,98.69 34.29,98.42 34.29,97.15 34.54,96.9 v1(34.79,96.9) 34.79,96.65 R8G3.2 ; J6J2.55 v1(119.72,13.16)
  LAY3 w0.1: v1(34.79,96.9) 34.79,88.64 35.43,88.01 35.43,78.82 36.01,78.23 36.01,72.55 36.78,71.78 36.78,68.41 36.19,67.82 36.19,67.18 39.04,64.33 39.04,60.97 39.63,60.38 41.45,60.38 44.09,57.74 44.09,51.91 40.64,48.45 40.64,46.39 39.07,44.83 39.07,42.39 39.97,41.49 44.41,41.49 44.91,41.99 50.33,41.99 50.57,41.74 52.74,41.74 56.23,38.25 61.61,38.25 65.13,34.73 67.71,34.73 67.95,34.49 101.57,34.49 103.26,32.8 110.45,32.8 111.59,33.95 114.89,33.95 v1(116.33,32.51)
  LAY8 w0.1: v1(119.72,13.16) 119.25,13.63 119.25,22.6 114.17,27.68 114.17,31.23 115.45,32.51 v1(116.33,32.51)
SLP_S3_LAN_RR_N: length 5.6
  TOP w0.1: R8C54.1 R8C53.2 50.16,203.2 48.76,204.6 48.76,205.36 49.65,206.25 Q8C6.1
SLP_S3_N: length 798.9
  TOP w0.1: R8D80.1 v1(33.9,168.15) ; R6A26.1 v1(102.74,281.18) R6A21.1 ; R2G19.1 253.49,78.87 254.38,77.98 v1(254.38,76.96) 254.38,76.45 253.36,75.44 R2G32.1 ; R8C58.1 50.8,202.44 49.78,202.44 49.4,202.82 R8C53.1 R8C52.1 46.99,203.71 44.83,203.71 v1(44.57,203.45) 44.32,203.2 40.76,203.2 40.51,203.45 38.88,203.45 38.88,203.4 38.3,202.82 38.3,201.75 37.95,201.41 Q8C9.5 36.81,201.41 36.44,201.04 36.44,200.28 37.08,199.64 R8C65.1 ; v1(51.18,170.31) 50.41,170.31 R8D98.1 ; v1(39.11,168.15) 39.24,168.15 39.87,167.51 42.03,167.51 42.39,167.86 43.27,167.86 43.56,168.15 43.56,168.52 43.89,168.84 43.89,169.47 43.3,170.05 R8D93.1 42.79,169.67 41.75,169.67 41.65,169.77 R8D76.1 ; v1(27.55,170.81) U8D9.1 ; R9H13.2 v1(22.22,42.92) ; R7E58.2 78.96,130.78 76.88,130.78 73.48,127.38 v1(72.89,127.38) ; Q8D6.1 v1(45.59,189.99)
  LAY5 w0.125: v1(22.22,42.92) 23.62,41.53 28.85,41.53 31.13,39.24 33,39.24 33.27,38.97 35.99,38.97 36.64,39.62 39.11,39.62 39.49,39.24 42.03,39.24 v1(42.41,39.62) ; v1(92.45,54.86) 93.59,56.01 93.59,57.15 94.74,58.29 124.58,58.29 126.11,59.82 145.92,59.82 146.94,58.8 161.39,58.8 181.36,78.77 196.01,78.77 198.27,81.03 208.61,81.03 209.4,80.24 216.65,80.24 218.41,78.48 219.78,78.48 220.17,78.87 227.7,78.87 228.08,78.49 243.94,78.49 244.95,79.5 251.84,79.5 252.22,79.12 v1(254.38,76.96) ; v1(13.84,16.38) 14.6,17.14 19.43,17.14 20.19,16.38 23.24,16.38 26.77,12.85 41.93,12.85 v1(42.29,13.21) 42.64,12.85 50.31,12.85 51.44,13.98 51.44,16.01 J8J11.2 ; v1(102.74,281.18) 101.72,282.19 101.72,286.69 98.47,289.94 63.88,289.94 56.51,282.57 v1(56.51,282.32)
  LAY6 w0.125: v1(65.53,141.22) 65.78,140.97 65.78,137.79 71.27,132.31 71.27,129.01 v1(72.89,127.38) ; v1(51.18,170.31) 51.68,170.81 51.68,183.13 48.38,186.43 47.75,186.43 47.49,186.69 47.49,187.32 46.7,188.11 46.7,188.85 45.59,189.96 v1(45.59,189.99) 45.33,190.24 45.33,200.91 44.57,201.67 v1(44.57,203.45) ; v1(13.84,16.38) 13.84,9.27 15.74,7.36 J9J5.1 ; v1(42.29,13.21) 42.67,13.59 42.67,39.37 v1(42.41,39.62) 43.94,39.62 45.21,38.35 46.22,38.35 46.99,39.11 46.99,40.64 46.48,41.15 46.48,42.16 46.99,42.67 46.99,48.77 47.91,49.69 47.91,54.89 47.24,55.56 47.24,59.05 47.62,59.44 47.62,62.05 46.86,62.81 46.86,66.92 46.35,67.44 46.35,68 45.2,69.14 45.2,72.65 43.43,74.42 43.43,81.04 42.6,81.87 42.6,90.92 41.14,92.38 41.14,97.53 40.38,98.3 40.38,100.07 41.52,101.22 41.52,101.47 40.76,102.24 40.76,104.62 40.24,105.15 40.24,111.28 41.52,112.57 41.52,133.03 41.17,133.38 41.17,135.1 39.87,136.4 v1(39.87,136.78) 40.1,137 40.1,149.25 39.75,149.6 39.75,151.53 38.5,152.78 38.5,165.89 39.11,166.49 v1(39.11,168.15)
  BOTTOM w0.1: v1(65.53,141.22) 65.02,141.22 63.98,140.18 54.67,140.18 52.69,138.2 46.64,138.2 45.78,139.05 42.15,139.05 v1(39.87,136.78) ; v1(56.51,282.32) 58.03,282.32 60.19,280.16 60.19,271.62 64.04,267.77 64.04,263.11 61.46,260.53 61.46,253.11 55.09,246.73 55.09,245.46 54.57,244.95 54.57,233.32 54.99,232.9 54.99,208.04 50.41,203.45 v1(44.57,203.45) ; v1(51.18,170.31) 50.54,169.67 47.37,169.67 46.65,170.38 43.63,170.38 42.54,169.29 42.54,168.15 42.06,167.67 39.59,167.67 v1(39.11,168.15) 38.65,167.69 34.36,167.69 v1(33.9,168.15) 33.45,167.69 30.17,167.69 27.55,170.31 v1(27.55,170.81) ; J8J11.2 54.48,16 57.53,16 58.16,15.37 58.92,15.37 59.3,15.75 59.3,19.97 64.13,24.79 64.13,30.61 65.15,31.62 66.16,31.62 70.42,35.88 70.42,36.26 74.04,39.88 77.08,39.88 78.48,41.27 78.48,44.22 78.58,44.32 78.61,44.32 85.21,50.93 88.13,50.93 92.07,54.86 v1(92.45,54.86)
SLP_S3_N_1P8S: length 2.1
  TOP w0.25: U8D2.2 28.19,184.91 28.57,185.29 R8D22.2
SLP_S3_N_AUX: length 2
  TOP w0.1: R8D76.2 42.54,170.81 42.41,170.94 U8D5.1
SLP_S3_N_PULLUP: length 2.5
  TOP w0.1: R8J24.2 53.21,14.73 J8J11.3
SLP_S3_N_XSTR_PIN1: length 3.7
  TOP w0.1: Q4J1.1 R4J8.2 R4J7.1 172.33,6.86 171.45,5.97
SLP_S3_N_XSTR_PIN1_R: length 7.4
  TOP w0.1: J4J3.2 172.46,11.3 172.46,7.87 R4J6.1
SLP_S3_N_XSTR_Q19LH_PIN3: length 3.8
  TOP w0.1: Q8C10.6 41.4,202.06 41.27,201.93 41.27,201.55 41.41,201.41 Q8C10.5 43.32,201.41 R8C63.2
SLP_S3_N_XSTR_Q19LH_PIN5: length 3.1
  TOP w0.1: Q8C10.2 39.22,201.41 C8C20.1 38.86,200.28 R8C65.2
SLP_S3_N_XSTR_Q19LH_PIN6: length 1.7
  TOP w0.1: Q8C10.3 39.59,200.76 39.37,200.53 R8C66.1
SLP_S3_PCH_N: length 761.7
  TOP w0.089: U6E1.BF42 91.56,138.23 91.44,138.11 88.79,138.11 87.07,136.39 86.87,136.39
  TOP w0.1: v1(143.89,40) 143.89,31.62 144.52,30.99 J5J1.15 ; v1(11.17,188.97) 11.65,188.49 12.19,188.49 12.7,189 14.95,189 15.62,188.34 21.84,188.34 22.6,187.58 26.03,187.58 26.41,187.96 28.32,187.96 v1(28.57,187.7) R8D22.1 ; 86.87,136.39 86.34,136.39 84.65,134.71 84.65,133.95 83.68,132.98 82.68,132.98 82.16,132.46 80.64,132.46 80.26,132.08 R7E58.1 79.62,130.55 76.97,130.55 73.16,126.74 v1(71.5,126.74) ; J8J13.9 32.51,6.09 18.66,6.09 J9J5.2 ; R8G3.1 v1(37.33,95.76) ; EU8H1.2 54.46,49 v1(55.11,49.66) ; R9B6.1 v1(11.81,255.4) ; v1(46.39,45.21) Q8H4.3 45.35,45.99 C8H18.1 45.33,45.56 45.23,45.46 42.54,45.46 R8H40.1 40.89,45.97 39.64,44.73 39.64,38.88 38.48,37.72 v1(37.46,37.72) ; v1(123.57,35.43) R6H45.2 ; v1(73.53,63.24) 73.44,63.33 R7H9.1 ; v1(153.92,262.38) 154.68,263.14 154.68,263.4 R5A43.2
  LAY5 w0.125: v1(143.89,40) 141.85,37.97 132.1,37.97 131.08,38.99 126.42,38.99 125.85,38.42 125.85,35.94 125.34,35.43 v1(123.57,35.43) 122.41,36.59 103.18,36.59 102.66,36.07 90.93,36.07 89.96,35.1 70.05,35.1 v1(69.46,35.69) 68.88,35.1 62,35.1 61.54,35.56 52.37,35.56 50.97,34.16 48.2,34.16 47.53,34.84 47.53,35.9 46.6,36.83 38.35,36.83 v1(37.46,37.72) ; v1(153.92,262.38) 153.44,261.9 153.44,261.14 153.18,260.88 140.67,260.88 139.81,260.02 132.51,260.02 128.38,255.89 126.75,255.89 125.84,256.79 125.53,256.79 124.05,258.28 116.14,258.28 115.79,257.92 110.03,257.92 107.63,255.53 102.21,255.53 100.58,257.16 99.91,257.16 99.67,257.39 91.92,257.39 90.88,256.34 86.61,256.34 86.1,255.83 86.1,254.24 85.85,253.98 84.57,253.98 84.19,254.37 84.19,255.17 83.08,256.28 77.01,256.28 72.06,261.24 69.82,261.24 67.66,259.07 64.64,259.07 63.88,259.84 62.86,259.84 62.48,259.46 60.58,259.46 59.69,260.35 44.82,260.35 43.82,259.34 38.37,259.34 35.43,262.28 35.43,272.73 31.69,276.48 v1(31.11,276.48)
  LAY6 w0.125: v1(37.33,95.76) 36.83,96.26 36.83,97.07 37.08,97.32 37.08,97.92 36.27,98.72 36.27,102.62 36.55,102.91 36.55,109.96 37.08,110.49 37.08,111.48 38.48,112.88 38.48,123.4 37.57,124.32 37.57,137.71 37.84,137.97 37.84,141.15 36.7,142.29 36.7,156.08 35.89,156.89 35.89,170.23 35.3,170.81 35.3,173.35 35.17,173.48 35.17,181.87 37.33,184.03 37.33,186.43 v1(37.59,186.69) ; v1(69.46,35.69) 69.46,37.49 74.67,42.7 74.67,45.21 73.02,46.86 73.02,48.55 73.87,49.4 73.87,62.39 73.53,62.74 v1(73.53,63.24) 73.53,63.64 74.58,64.69 74.58,74.27 73.9,74.95 73.9,81.93 74.69,82.72 74.69,87.99 73.48,89.2 73.48,92.72 72.51,93.7 v1(72.51,97.66) 72.51,98.65 68.94,102.22 68.94,109.94 70.03,111.02 70.03,117.27 73.66,120.9 73.66,124.59 v1(71.5,126.74) ; v1(11.81,255.4) 11.91,255.29 12.09,255.29 12.44,255.65 12.44,258.32 11.53,259.23 11.53,262.87 12.81,264.15 12.81,266.94 14.35,268.48 14.35,271.35 15.12,272.12 15.12,272.8 18.49,276.18 19.67,276.18 20.67,277.18 22.38,277.18 22.9,277.7 27.91,277.7 29.13,276.48 v1(31.11,276.48) ; v1(37.46,37.72) 37.05,37.31 37.05,32.54 37.46,32.13 37.46,23.11 36.95,22.6 36.95,21.08 37.46,20.57 37.46,10.31 36.57,9.42 36.57,6.6 36.06,6.09 34.54,6.09 J8J13.9
  BOTTOM w0.1: v1(28.57,187.7) 28.95,187.32 36.95,187.32 v1(37.59,186.69) ; v1(72.51,97.66) 71.75,97.66 71.34,98.07 65.11,98.07 63.58,96.54 46.38,96.54 45.85,96.01 37.59,96.01 v1(37.33,95.76) ; v1(11.17,188.97) 9.39,190.75 9.39,198.49 4.6,203.28 4.6,215.84 9.11,220.35 9.11,226.85 9.79,227.53 9.79,228.71 7.08,231.42 7.08,250.23 11.17,254.32 11.17,254.76 v1(11.81,255.4) ; v1(46.39,45.21) 46.6,45.21 49.02,47.62 51.06,47.62 52.35,48.92 54.38,48.92 v1(55.11,49.66)
SLP_S4_APS_N: length 5.7
  TOP w0.1: R9H18.2 20.32,38.35 16.38,38.35 J9H3.5
SLP_S4_EC_N: length 187.1
  TOP w0.1: R8G1.2 35.56,96.9 v1(34.79,97.66) 34.79,98.3 34,99.09 U8F6.114 ; J6J2.71 v1(122.43,13.33)
  LAY3 w0.1: v1(118.61,32.51) 118.11,33.02 116.14,33.02 114.98,34.17 111.5,34.17 110.35,33.03 106.92,33.03 105.23,34.72 68.04,34.72 67.8,34.96 65.22,34.96 61.71,38.47 60.07,38.47 59.05,39.5 55.31,39.5 52.83,41.97 50.67,41.97 49.65,42.99 47.78,42.99 47.21,42.42 45.29,42.42 45.21,42.5 42.73,42.5 41.94,41.72 40.06,41.72 39.3,42.48 39.3,44.74 43.05,48.49 43.05,50.42 45.21,52.58 45.21,53.21 44.89,53.53 44.89,54.67 44.32,55.24 44.32,57.84 41.54,60.61 39.73,60.61 39.27,61.07 39.27,64.54 37.21,66.6 37.21,67.94 37.01,68.14 37.01,71.87 36.24,72.64 36.24,78.32 35.66,78.91 35.66,88.1 35.02,88.74 35.02,95.86 35.3,96.14 35.3,97.15 v1(34.79,97.66)
  LAY8 w0.1: v1(122.43,13.33) 121.28,14.48 121.28,24.83 124.49,28.04 127.41,28.04 128.42,29.05 128.42,31.3 127.21,32.51 v1(118.61,32.51)
SLP_S4_N: length 559.7
  TOP w0.089: 87.01,136.15 87.13,136.15 88.9,137.92 91.93,137.92 92.21,138.2 U6E1.BE42
  TOP w0.1: v1(71.5,125.98) 71.88,126.36 73.1,126.36 77.07,130.32 80.24,130.32 80.91,130.99 80.91,131.31 81.78,132.18 82.34,132.18 82.91,132.75 83.77,132.75 84.88,133.86 84.88,134.61 86.42,136.15 87.01,136.15 ; R8G1.1 v1(37.33,96.9) ; v1(46.39,43.31) Q8H6.3 46.33,44.09 45.72,44.7 C8H19.1 45.33,44.29 45.23,44.19 42.54,44.19 R8H45.1 40.38,44.7 39.87,44.19 39.87,38.79 38.16,37.08 36.44,37.08 v1(36.06,36.7) ; U2G2.10 249.46,78.83 v1(249.3,78.99) ; v1(59.43,150.23) 59.31,150.23 58.05,151.49 58.05,159.75 55,162.81 55,165.23 55.56,165.79 55.56,168.4 54.77,169.19 51.84,169.19 R8D99.1 R8D97.1 ; v1(53.97,49.66) 54.06,49.57 EU8H1.3 ; R9H18.1 v1(22.22,38.61) ; R7H10.1 74.71,63.24 73.44,61.97 v1(72.89,61.97) ; R6H47.2 125.85,35.94 125.85,36.45 v1(125.34,36.96)
  LAY5 w0.125: v1(126.11,52.17) 126.39,52.45 128.77,52.45 129.4,51.82 145.2,51.82 151.67,58.29 161.59,58.29 181.57,78.26 194.4,78.26 195.07,77.6 202.69,77.6 203.58,78.48 203.58,79.12 204.19,79.73 216.44,79.73 218.58,77.6 224.79,77.6 225.42,78.23 248.54,78.23 v1(249.3,78.99) ; v1(125.34,36.96) 125.21,37.09 104.77,37.09 103.89,37.97 92.71,37.97 91.44,36.7 90.85,36.7 89.93,35.78 79.23,35.78 78.64,36.37 75.86,36.37 75.1,35.61 70.79,35.61 69.59,36.8 v1(68.42,36.8) 67.32,35.7 62.11,35.7 61.74,36.07 51.76,36.07 51.26,36.57 48,36.57 46.73,37.84 45.46,37.84 45.08,38.23 40.08,38.23 39.82,37.97 38.32,37.97 37.82,38.48 36.57,38.48 36.19,38.1 36.19,36.83 v1(36.06,36.7) 35.59,36.23 31.3,36.23 28.54,38.99 26.16,38.99 25.78,38.61 v1(22.22,38.61)
  LAY6 w0.125: v1(36.06,36.7) 35.17,35.81 35.17,25.14 35.56,24.76 35.56,23.37 35.17,22.99 35.17,18.67 J8J7.2 34.92,16.13 34.92,9.78 34.54,9.4 34.54,8.09 J8J13.11 ; v1(68.42,36.8) 72,40.38 72,44.32 72.39,44.7 72.39,48.63 72.75,48.99 72.75,52.83 73.62,53.7 73.62,61.25 v1(72.89,61.97) 72.89,62.1 72.77,62.23 72.77,63.24 74.33,64.8 74.33,74.16 73.65,74.84 73.65,82.03 74.44,82.82 74.44,87.89 73.23,89.09 73.23,92.62 72.26,93.59 72.26,96.83 71.93,97.15 v1(71.93,98.17) 71.93,98.88 68.69,102.12 68.69,110.04 69.78,111.13 69.78,117.38 73.4,121 73.4,124.08 v1(71.5,125.98) 70.5,125.98 68.96,127.52 68.96,129.55 67.76,130.75 67.76,131.77 65.41,134.11 63.24,134.11 63.11,134.24 62.73,134.62 62.73,135.13 63.62,136.02 63.79,136.02 64.64,136.86 64.64,142.12 63.38,143.38 62.1,143.38 58.67,146.81 58.67,149.47 v1(59.43,150.23) ; v1(125.34,36.96) 125.85,37.47 125.85,40.34 125.14,41.06 125.14,46.52 127.19,48.57 127.19,49.97 126.11,51.05 v1(126.11,52.17)
  BOTTOM w0.1: v1(37.33,96.9) 37.59,97.15 43.3,97.15 43.81,96.65 45.97,96.65 46.14,96.82 61.23,96.82 62.71,98.3 71.8,98.3 v1(71.93,98.17) ; v1(46.39,43.31) 45.84,43.85 45.84,46.1 47.59,47.85 50.96,47.85 52.26,49.15 53.46,49.15 v1(53.97,49.66)
SLP_S4_N_PULLUP: length 2.4
  TOP w0.1: R8J20.2 J8J7.3
SLP_S5_EC_N: length 175
  TOP w0.1: J6J2.39 v1(116.15,13.16) ; U8F6.71 21.62,90.07 21.36,89.81 v1(21.36,89.53) 21.08,89.53 20.06,88.52 R9G16.2
  LAY3 w0.1: v1(21.36,89.53) 21.36,89.43 20.32,88.4 20.32,84.74 18.31,82.73 18.31,74 15.4,71.09 15.4,61.49 13.08,59.17 13.08,50.86 14.31,49.62 14.25,49.56 14.25,45.63 15.33,44.55 18.25,44.55 19.27,43.53 19.27,40.13 20.82,38.58 20.82,34.99 21.17,34.64 21.87,34.64 23.38,33.13 23.38,32.87 24.51,31.75 24.51,30.99 25.01,30.48 26.03,30.48 27.17,29.34 28.22,29.34 28.44,29.11 28.44,28.07 31.49,25.02 35.01,25.02 36.9,23.13 53.47,23.13 54.07,23.73 55.69,23.73 56.93,22.48 58.29,22.48 58.6,22.17 59.3,22.17 60.42,21.05 61.63,21.05 62.11,20.57 64.09,20.57 65.18,19.48 71.87,19.48 72.43,20.03 81.02,20.03 81.76,20.78 83.74,20.78 84.48,20.03 86.54,20.03 87.04,19.54 98.54,19.54 99.16,18.92 100.21,18.92 101.12,18.01 105.43,18.01 106.01,18.59 107.38,18.59 110.51,15.47 112.29,15.47 114.59,13.16 v1(116.15,13.16)
SLP_S5_PCH_N: length 755.3
  TOP w0.089: U6E1.BC42 93.01,138.5 92.96,138.54 92.67,138.54 92.59,138.62 92.11,138.62 92.08,138.65 91.72,138.65 91.54,138.83 91.12,138.83 90.96,138.68 88.55,138.68 86.98,137.11 86.96,137.11
  TOP w0.1: EU8H1.4 53.66,48.95 53.06,49.55 v1(53.06,49.66) ; R9G16.1 19.78,86.84 19.78,85.62 20.44,84.96 23.87,84.96 v1(24,84.83) ; v1(79.37,73.02) 79.37,75.85 78.77,76.45 77.85,76.45 77.25,75.86 R7G31.2 ; v1(70.4,127.89) 70.66,128.14 72.64,128.14 72.77,128.27 72.77,129.95 73.93,131.11 75.67,131.11 76.1,131.55 77.03,131.55 78.46,132.97 79.82,132.97 79.92,133.07 81.79,133.07 85.83,137.11 86.96,137.11 ; v1(41.27,43.86) 41.7,43.43 R8H49.1 42.54,42.92 44.83,42.92 C8H20.1 ; v1(37.71,273.68) 29.97,273.68 27.43,276.22 13.71,276.22 v1(12.95,276.99) ; R6H46.2 v1(125.34,36.19)
  LAY5 w0.125: v1(70.4,127.89) 70.4,124.25 70,123.85 70,116.69 71.24,115.44 71.24,111.12 74.8,107.57 v1(74.8,106.17) ; v1(12.95,276.99) 12.43,276.99 8.56,273.12 8.56,260.42 9.13,259.85 9.13,257.44 10.76,255.8 10.76,251.3 11.55,250.51 11.55,233.93 15.36,230.12 15.36,218.33 16.64,217.06 16.64,210.42 14.35,208.13 14.35,187.37 13.55,186.57 13.55,178.09 14.31,177.33 14.31,170.94 13.71,170.34 13.71,167.38 14.21,166.89 14.21,159.01 14.96,158.26 14.96,153.81 15.24,153.54 15.74,153.54 17.64,151.65 17.64,150.5 23.05,145.1 23.05,119.06 24.13,117.98 24.13,114.26 23.8,113.94 23.8,108.97 23.51,108.67 23.51,88.9 23.92,88.49 23.92,84.91 v1(24,84.83) 24,80.39 24.9,79.49 24.9,76.18 23,74.28 23,65.76 27.58,61.18 30.38,61.18 30.73,60.83 30.73,60.07 31.05,59.75 38.06,59.75 38.77,60.46 41.1,60.46 42.28,61.64 42.28,62.31 42.83,62.86 44.47,62.86 46.46,64.86 46.46,65.57 49.47,68.58 53.87,68.58 v1(54.12,68.32) 54.65,67.8 71.6,67.8 75.81,72.01 78.48,72.01 79.37,72.9 v1(79.37,73.02) ; v1(37.71,273.68) 37.71,271.02 38.98,269.75 38.98,267.33 39.62,266.7 39.62,263.27 39.87,263.02 40.77,263.02 42.17,264.41 44.13,264.41 44.7,263.84 46.21,263.84 47.23,264.86 52.89,264.86 53.21,264.54 55.75,264.54 56.26,265.05 60.19,265.05 61.52,266.38 64.82,266.38 65.65,265.55 68.7,265.55 68.83,265.68 79.24,265.68 84.07,260.86 87.24,260.86 88.13,259.97 88.13,259.71 88.44,259.41 90.75,259.41 92.83,261.49 98.42,261.49 98.67,261.24 99.44,261.24 103.02,257.65 107.62,257.65 110.19,260.23 115.58,260.23 115.99,259.81 122.22,259.81 123.9,261.5 126.44,261.5 130.86,265.92 130.86,266.42 134.26,269.82 134.26,271.22 134.87,271.82 134.87,274.01 138.09,277.23 141.99,277.23 145.01,274.21 162.03,274.21 v1(163.19,273.05) ; v1(28.57,36.57) 28.82,36.83 30.35,36.83 31.24,35.94 36.06,35.94 36.83,36.7 36.83,38.1 36.95,38.23 37.71,38.23 38.75,37.19 41.63,37.19 v1(42.16,37.72) 42.69,37.19 46.77,37.19 47.64,36.32 49.4,36.32 49.91,35.81 61.64,35.81 62.1,35.35 68.19,35.35 68.63,35.78 69.12,36.28 69.76,36.28 70.69,35.35 77.26,35.35 77.97,36.07 78.58,36.07 79.12,35.53 90.03,35.53 90.82,36.32 102.56,36.32 103.08,36.84 124.7,36.84 v1(125.34,36.19)
  LAY6 w0.125: J8J13.5 28.57,8.06 28.57,12.57 29.21,13.21 29.21,20.57 28.57,21.21 28.57,23.75 28.86,24.04 28.86,34.76 28.57,35.05 v1(28.57,36.57) ; v1(53.06,49.66) 52.42,50.29 52.42,51.56 52.7,51.84 52.7,53.11 53.46,53.87 53.46,63.12 53.59,63.25 53.59,67.79 v1(54.12,68.32) ; v1(79.37,73.02) 79.24,73.02 79.02,73.25 79.02,78.77 79.83,79.58 79.83,83.3 79.62,83.51 79.62,94 76.84,96.79 76.84,104.06 74.8,106.1 v1(74.8,106.17) ; v1(41.27,43.86) 41.27,43.81 41.91,43.18 41.91,37.97 v1(42.16,37.72)
  BOTTOM w0.1: R5L1.2 163.06,272.41 163.06,272.79 163.19,272.92 v1(163.19,273.05) ; v1(41.27,43.86) 42.06,44.65 42.06,45.81 45.32,49.07 49.39,49.07 50.1,49.78 52.93,49.78 v1(53.06,49.66)
SLP_S5_S4_AIC: length 4.7
  TOP w0.1: 126.36,30.89 R6H47.1 R6H46.1
SLP_SUS_EC_N: length 216.7
  TOP w0.1: U8F6.120 34.28,101.49 35.31,100.46 C8F19.1 35.68,100.07 35.81,99.95 37.08,99.95 v1(37.33,99.69) 38.1,98.93 R8F52.2 ; J6J2.98 v1(127.34,18.49)
  LAY3 w0.1: v1(128.77,8.25) 129.26,7.77 129.26,6.74 127.92,5.4 115.57,5.4 114.52,6.45 112.19,6.45 111.54,5.8 104.34,5.8 102.65,4.11 90.97,4.11 88.9,2.03 62.48,2.03 58.71,5.8 47.41,5.8 46.6,6.6 46.6,8.03 J8J13.22
  LAY6 w0.125: v1(37.33,99.69) 37.33,98.73 38.47,97.59 38.47,95.44 38.22,95.18 38.22,92.84 37.2,91.82 37.2,90.55 37.59,90.17 38.1,90.17 38.6,89.66 38.6,80.31 41.39,77.52 41.39,69.78 42.92,68.25 42.92,67.1 45.09,64.94 45.09,61.06 44.19,60.17 44.19,55.83 44.65,55.37 45.82,55.37 46.82,54.36 46.82,51.34 41.71,46.23 41.1,46.23 39.5,44.63 39.5,38.43 39.24,38.18 39.24,36.81 39.24,36.81 39.24,12.95 40.87,11.32 43.32,11.32 J8J13.22
  LAY8 w0.1: v1(127.34,18.49) 127.34,16.34 126.74,15.75 126.74,10.03 127.25,9.52 127.5,9.52 v1(128.77,8.25)
SLP_SUS_FET2_EC: length 7.6
  TOP w0.1: R6J15.1 133.85,21.97 133.7,21.82 133.7,15.72 J6J2.141
SLP_SUS_FET_EC: length 7.8
  TOP w0.1: J6J2.149 133.93,15.7 133.93,21.54 134.62,22.22 R5J7.1
SLP_SUS_N: length 885.3
  TOP w0.089: U6E1.BD39 92.87,139.85 92.7,139.68 92.32,139.68 92.17,139.82 91.85,139.82 91.82,139.79 90.72,139.79 90.59,139.65 88.18,139.65 87.09,138.57 85.73,138.57
  TOP w0.1: R8D89.1 42.41,163.57 43.05,162.94 43.05,160.57 44.74,158.88 v1(45.97,158.88) ; R6A22.1 v1(103.5,281.18) R6A27.1 ; v1(41.02,98.42) 40.51,98.93 R8F52.1 ; v1(47.87,104.39) 49.02,103.25 CR8F4.3 50.1,103.88 51.56,103.88 R8F44.1 ; 36.19,183.77 36.83,183.13 37.71,183.13 37.97,182.88 37.97,181.48 37.71,181.23 36.83,181.23 36.51,180.91 CR8D1.3 36.51,179.09 36.02,178.61 33.73,178.61 v1(33.27,179.07) 33.27,180.34 32.76,180.85 31.24,180.85 R8D45.1 ; v1(124.2,21.74) 124.2,22.73 R6J4.1 R6J3.1 ; v1(183,57.66) R4H12.1 R4H22.1 ; EU8H1.5 53.26,48.84 53.08,49.02 50.92,49.02 v1(50.67,49.27) ; v1(172.33,92.45) 171.7,93.09 170.18,93.09 R5G9.1 ; Q8H7.3 46.37,42.04 C8H21.1 44.83,41.53 42.54,41.53 R8H53.1 41.78,42.29 41.78,42.42 v1(41.27,42.92) 40.76,42.42 40.76,38.99 37.84,36.07 36.19,36.07 33.27,33.15 33.27,29.84 J8J4.1 ; 85.73,138.57 85.19,138.57 81.96,135.33 78.94,135.33 77.21,133.6 77.21,132.69 76.75,132.23 75.82,132.23 75.39,131.8 73.65,131.8 72.66,130.81 70.61,130.81 68.85,129.05 68.85,124.57 68.49,124.2 TP7F1.1 v1(67.31,124.2) ; R9B5.1 v1(11.81,256.16)
  TOP w0.3: v1(47.75,148.21) 47.62,148.21 46.99,148.84 R8E28.1 ; R8E44.1 v1(47.01,139.18)
  LAY3 w0.1: v1(70.35,25.93) 70.61,25.67 77.36,25.67 78.05,26.36 81.55,26.36 82.25,27.07 88.68,27.07 89.29,26.46 96.91,26.46 97.37,26.01 97.88,26.01 98.8,25.08 102.19,25.08 104.76,22.52 111.24,22.52 112.54,21.22 113.91,21.22 114.4,20.73 115.45,20.73 115.97,21.26 123.72,21.26 v1(124.2,21.74)
  LAY5 w0.125: v1(172.33,92.45) 167.25,87.37 165.58,87.37 161.26,83.06 159.69,83.06 157.21,80.58 149.76,80.58 149.24,80.07 139.2,80.07 138.83,79.7 136.39,79.7 134.54,77.85 117.42,77.85 114.37,80.9 105.97,80.9 105.33,80.26 101.43,80.26 85.23,64.06 85.23,63.5 83.58,61.85 78.28,61.85 76.66,60.24 75.17,60.24 74.54,59.6 74.54,58.46 73.74,57.66 71.7,57.66 70.94,56.9 66.57,56.9 64.93,55.26 54.39,55.26 53.9,54.76 50.72,54.76 50.29,54.33 v1(49.65,54.33) ; v1(103.5,281.18) 101.98,282.7 101.98,286.79 98.57,290.2 63.5,290.2 58.29,284.99 34.02,284.99 30.72,281.68 26.4,281.68 24.31,279.59 23.66,279.59 20.27,276.2 12.84,276.2 9.95,273.31 9.95,257.64 11.53,256.06 11.7,256.06 v1(11.81,256.16)
  LAY6 w0.125: v1(50.67,49.27) 50.16,49.78 50.16,50.14 49.4,50.9 49.4,54.08 v1(49.65,54.33) 49.4,54.58 49.4,62.23 48.89,62.73 48.89,64.97 48.44,65.43 48.44,66.48 48.88,66.92 48.88,69.1 46.86,71.12 46.86,73.53 47.62,74.29 47.62,79.05 45.99,80.68 45.99,94.24 47.36,95.61 47.36,97.5 48,98.14 48,98.8 47.37,99.44 47.37,103.88 v1(47.87,104.39) 46.86,105.4 46.86,114.94 v1(47.87,115.95) 52.95,121.03 52.95,125.73 52.57,126.11 52.57,132.59 52.19,132.97 48.38,132.97 47.01,134.34 v1(47.01,139.18) 47.62,139.79 47.62,143.89 47.01,144.5 47.01,147.72 47.49,148.21 v1(47.75,148.21) 48.28,148.74 48.28,151.15 50.94,153.81 50.94,156.58 48.64,158.88 v1(45.97,158.88) ; v1(33.14,159.03) 33.65,159.54 33.65,160.65 33.4,160.91 33.4,167.89 32.51,168.78 32.51,170.43 33.27,171.19 v1(33.27,179.07) ; J8J4.1 31.11,27.68 31.11,14.1 32.51,12.7 32.51,6.48 33.27,5.71 41.52,5.71 42.41,6.6 42.41,7.49 42.92,8 43.94,8 44.45,7.49 44.45,6.48 45.21,5.71 56.13,5.71 J8J13.33
  LAY8 w0.1: v1(70.35,25.93) 70.35,24.38 63.75,17.78 63.75,14.35 62.48,13.08 61.59,13.08 58.54,10.03 58.54,8.13 J8J13.33
  BOTTOM w0.1: v1(183,57.66) 182.49,57.15 180.22,57.15 177.31,60.06 176.17,60.06 174.48,61.75 174.48,70.2 176.78,72.5 176.78,75.18 178.94,77.34 178.94,82.93 178.18,83.69 178.18,87.25 172.97,92.45 v1(172.33,92.45) ; v1(41.27,42.92) 42.29,43.94 42.29,45.72 45.05,48.49 49.37,48.49 50.16,49.27 v1(50.67,49.27) ; v1(47.87,104.39) 47.11,103.63 44.83,103.63 42.67,101.47 42.67,99.95 41.65,98.93 41.52,98.93 v1(41.02,98.42) ; v1(47.87,115.95) 55.46,115.95 59.39,119.89 62.99,119.89 v1(67.31,124.2) ; v1(11.81,256.16) 10.94,255.3 10.94,254.41 6.85,250.32 6.85,231.33 9.57,228.61 9.57,227.63 8.89,226.95 8.89,220.44 4.37,215.93 4.37,203.19 9.17,198.39 9.17,188.95 11.04,187.07 14.28,187.07 17.84,183.51 17.84,173.83 16.11,172.09 16.11,169.81 16.76,169.16 16.76,167.22 16.94,167.04 16.94,161.14 19.91,158.17 23.73,158.17 24.14,158.58 31.11,158.58 31.49,158.96 33.08,158.96 v1(33.14,159.03) 33.4,159.29 45.56,159.29 v1(45.97,158.88)
SLP_SUS_N_EV: length 2.8
  TOP w0.1: J8J4.2 31.75,25.78 R8J9.2
SLP_WLAN_N: length 344.8
  TOP w0.089: U6E1.BD42 92.66,138.28 92.51,138.43 92.03,138.43 92,138.46 91.64,138.46 91.46,138.64 91.19,138.64 91.04,138.49 88.63,138.49 87.02,136.88 86.88,136.88
  TOP w0.1: 86.88,136.88 85.89,136.88 81.88,132.87 80.01,132.87 79.83,132.69 78.71,132.69 77.97,131.95 v1(77.97,131.82) 77.38,131.23 76.11,131.23 74.67,129.79 C7F1.1 R7F3.1 ; R7B1.1 61.46,259.46 v1(60.96,259.97) ; R6J12.2 v1(126.74,24.13)
  LAY3 w0.1: v1(77.97,131.82) 75.79,129.64 75.79,123.03 71.88,119.12 71.88,114.55 74.8,111.63 74.8,109.6 76.2,108.2 76.2,105.92 76.53,105.59 84.15,105.59 86.23,103.5 86.23,101.46 89.63,98.06 91.68,98.06 93.08,96.66 97.54,96.66 99.73,94.48 112.53,94.48 122.3,84.71 123.31,84.71 124.84,83.18 v1(124.84,81.02)
  LAY5 w0.125: v1(77.97,131.82) 77.97,135.49 78.86,136.38 78.86,137.79 80.18,139.11 80.18,144.78 78.73,146.23 78.73,148.63 80.13,150.03 80.13,152.57 81.8,154.25 81.8,159.25 82.16,159.61 82.16,164.69 81.4,165.46 81.4,172.87 83.45,174.92 83.45,183.65 82.04,185.06 82.04,191.64 79.75,193.93 79.75,195.45 83.69,199.39 v1(84.2,199.39) ; v1(60.96,259.97) 61.08,260.09 63.98,260.09 64.75,259.32 67.55,259.32 69.72,261.49 72.16,261.49 77.12,256.53 83.19,256.53 84.7,255.01 v1(84.7,254.63)
  LAY6 w0.125: v1(84.2,199.39) 87.32,202.51 87.32,225.01 87.63,225.32 87.63,245.89 85.45,248.06 85.45,251.12 84.7,251.87 v1(84.7,254.63)
  LAY8 w0.1: v1(124.84,81.02) 122.41,78.6 122.41,76.18 119.33,73.1 119.33,59.15 121.39,57.09 121.39,50.06 122.2,49.26 122.2,35.67 123.82,34.04 126.97,34.04 129.35,31.65 129.35,26.74 v1(126.74,24.13)
SLP_WLAN_N_R: length 19.3
  TOP w0.1: 62.61,259.46 63.24,258.82 63.24,258.57 63.64,258.17 Q7B1.2 65.19,258.17 65.4,257.96 65.4,257.05 65.91,256.54 66.67,256.54 67.31,255.9 67.31,255.01 64.89,252.6 64.89,251.59 65.15,251.33 66.67,251.33 66.92,251.59 67.69,251.59 68.07,251.2 68.07,249.81 66.8,248.54 Q7B6.1
SLTA_MAIN_PWR_EN: length 11.1
  TOP w0.1: v1(133.85,38.48) 133.98,38.61 R5H6.2 134.62,32.51 135.63,31.49 J5J1.1
  BOTTOM w0.1: R5V6.2 v1(133.85,38.48)
SLTB_MAIN_PWR_EN: length 35.2
  TOP w0.1: v1(135.38,40) 135.12,39.75 135.12,36.7 135.63,36.19 J5J1.2 ; R6H36.2 v1(116.13,39.24) ; R5H11.2 v1(140.58,40)
  LAY5 w0.125: v1(116.13,39.24) 118.61,39.24 119.36,39.99 124.45,39.99 124.96,40.5 126.6,40.5 126.87,40.77 133.73,40.77 134.49,40 v1(135.38,40) 135.89,40.51 139.06,40.51 139.31,40.26 139.31,39.75 139.57,39.5 140.08,39.5 v1(140.58,40)
  BOTTOM w0.1: R5V5.2 v1(135.38,40)
SLTC_MAIN_PWR_EN: length 43.3
  TOP w0.1: v1(139.82,40) 140.08,39.75 140.08,31.49 140.71,30.86 J5J1.9 ; R6H5.2 v1(117.85,56.51)
  BOTTOM w0.1: R5V2.2 v1(139.82,40) 139.52,40 131.84,47.69 125.35,47.69 120.6,52.43 120.6,56.26 120.12,56.74 118.07,56.74 v1(117.85,56.51)
SLTD_MAIN_PWR_EN: length 4.5
  TOP w0.1: R5H11.1 140.71,38.23 J5J1.10
SMB_CLK_EC: length 951.1
  TOP w0.1: R8G10.2 34.79,92.58 34.5,92.29 U8F6.97 32.29,92.29 31.7,92.88 30.05,92.88 v1(29.59,93.34) ; v1(133.47,70.36) 132.9,70.93 132.9,75.01 130.15,77.75 124.44,77.75 113.55,88.64 99.93,88.64 98.04,90.53 98.04,91.03 v1(97.15,91.92) ; v1(70.98,73.33) 70.9,73.25 J7G1.16 ; v1(23.11,149.33) 22.55,149.89 19.93,149.89 ; v1(169.79,33.02) R4H54.2 ; v1(138.81,5.23) 138.81,6.83 139.44,7.47 139.44,8 139.62,8.18 139.62,11.28 J6J2.184 ; v1(56,267.59) 55.62,267.21 50.96,267.21 49.98,266.22 44.44,266.22 v1(43.45,267.21) ; R2C24.1 279.06,215.97 279.57,215.97 v1(280.03,215.52)
  LAY5 w0.125: v1(280.03,215.52) 279.9,215.64 279.9,216.41 280.16,216.66 280.67,216.66 281.93,215.4 281.93,206.25 282.7,205.48 283.84,205.48 285.36,203.96 285.36,200.66 286.26,199.76 286.26,196.21 289.41,193.06 289.41,181.41 287.02,179.02 287.02,177.34 287.91,176.45 287.91,171.29 287.25,170.63 287.25,168 286.68,167.43 286.37,167.43 283.32,164.38 280.24,164.38 276.09,160.23 276.09,157.7 277.07,156.73 277.07,148.19 276.77,147.89 276.77,146.68 278.11,145.34 278.11,141.53 281.12,138.52 281.12,137.14 283.96,134.3 283.96,97.89 281.12,95.05 281.12,95.05 274.31,88.24 274.31,85.95 268.35,79.99 267.28,79.99 265.83,78.54 261.09,78.54 258.35,81.28 255.39,81.28 253.58,83.09 244.6,83.09 244.14,82.63 231.69,82.63 230.5,83.82 226.62,83.82 225.85,84.59 220.72,84.59 220.37,84.24 210.86,84.24 209.81,85.29 209.81,86.56 204.15,92.22 192.1,92.22 190.08,90.19 186.85,90.19 186.33,89.67 179.45,89.67 175.02,85.23 171.56,85.23 165.66,79.33 165.66,78.61 163.76,76.72 156.92,76.72 154.67,74.46 144.92,74.46 141.2,70.74 133.86,70.74 v1(133.47,70.36) ; v1(169.79,33.02) 169.28,32.5 169.28,30.02 168.6,29.33 168.6,23.33 152.49,7.23 146.8,7.23 145.55,5.98 139.56,5.98 v1(138.81,5.23) 138.06,5.98 118.37,5.98 117.49,6.86 111.71,6.86 111.28,6.44 104.04,6.44 100.91,3.31 88.63,3.31 88.14,3.8 85.89,3.8 84.76,2.67 82.61,2.67 80.01,5.27 75.75,5.27 73.14,2.66 69.73,2.66 68.83,3.55 67.69,3.55 66.16,2.02 31.88,2.02 v1(30.48,3.43) ; v1(31.41,60.81) 32.44,60.81 33,60.25 37.85,60.25 38.56,60.96 40.89,60.96 41.78,61.85 41.78,62.52 42.5,63.24 44.31,63.24 46.08,65.01 46.08,65.73 49.57,69.21 53.59,69.21 54.22,69.85 54.63,69.85 55.52,68.96 56.88,68.96 57.27,69.34 59.18,69.34 59.94,68.58 66.23,68.58 v1(70.98,73.33) 71.46,73.81 73.15,73.81 74.57,72.39 77.19,72.39 78.33,73.53 79.16,73.53 80.76,75.14 80.76,76.19 83.19,78.63 83.92,78.63 86.02,80.72 90.15,80.72 91.44,82.01 91.44,82.68 91.82,83.06 92.46,83.06 94.78,85.39 94.78,87.04 96.64,88.9 96.64,91.41 v1(97.15,91.92)
  LAY6 w0.125: v1(23.11,149.33) 23.11,150.14 22.32,150.93 22.32,157.1 22.07,157.35 22.07,168.48 19.04,171.51 19.04,178.15 19.93,179.04 19.93,188.59 23.49,192.15 23.49,196.37 24.51,197.38 24.51,202.31 25.78,203.58 25.78,205.31 26.41,205.94 26.41,207.64 25.8,208.25 25.8,211.56 25.14,212.22 25.14,218.69 24.61,219.23 24.61,224.81 23.74,225.68 23.74,227.33 22.86,228.22 22.86,234.69 23.36,235.2 23.36,238.66 24.13,239.42 24.13,241.64 24.29,241.81 24.29,242.99 25.78,244.47 25.78,255.4 26.28,255.9 26.28,261.39 28.03,263.13 31.58,263.13 33.49,265.04 36.16,265.04 38.33,267.21 v1(43.45,267.21) ; v1(30.48,3.43) 30.48,7.62 29.52,8.57 J8J13.6 29.52,10.34 30.36,11.17 30.36,29.6 30.68,29.92 30.68,36.45 29.96,37.16 29.96,39.38 29.45,39.89 29.45,42.12 28.92,42.65 28.92,51.61 31.22,53.91 31.22,60.62 v1(31.41,60.81) 31.41,61.34 30.33,62.43 30.33,66.08 29.51,66.9 29.51,79.56 28.68,80.39 28.68,82.79 27.99,83.48 27.99,88.66 28.18,88.84 28.18,90.22 29.84,91.89 29.84,93.09 v1(29.59,93.34) 29.33,93.6 29.33,102.59 29.85,103.11 29.85,104.64 28.56,105.92 28.56,108.97 27.17,110.36 27.17,112.14 27.68,112.65 27.68,113.28 26.66,114.31 26.66,122.04 27.7,123.08 28.67,123.08 29.03,123.44 29.03,123.87 27.96,124.94 27.96,128.37 27.17,129.16 27.17,131.15 26.69,131.62 26.69,141.76 26.94,142.01 26.94,149.38 v1(27.67,150.11)
  BOTTOM w0.1: v1(56,267.59) 56.51,267.08 U8L2.6 ; v1(23.11,149.33) 23.58,149.33 24.56,150.31 27.48,150.31 v1(27.67,150.11) ; v1(43.45,267.21) 43.96,266.7 44.83,266.7 45.84,267.71 U8L1.2
SMB_CLK_MAIN: length 829.4
  TOP w0.1: v1(101.85,229.61) 95.63,229.61 94.21,231.03 88.62,231.03 R7B73.1 87.75,231.9 85.09,231.9 84.07,230.88 Q7B9.2 ; J1F1.141 158.69,123.88 157.86,123.06 155.7,123.06 152.69,126.07 152.69,130.03 151.15,131.57 147.57,131.57 146.55,132.59 146.55,147.62 148.97,150.04 148.97,156.4 147.28,158.09 140.75,158.09 130.69,168.15 v1(129.79,168.15) ; v1(94.36,30.66) 93.59,29.89 J7J1.13 ; J1C1.53 292.01,211.74 291.79,211.96 290.83,211.96 v1(290.32,211.45) ; R4H53.2 v1(169.79,34.16) ; R2A42.1 v1(249.93,266.83) ; R7J13.1 v1(67.43,24) ; v1(264.92,75.44) 264.92,75.19 U2G3.5
  LAY5 w0.125: v1(67.94,4.57) 69.59,6.22 71.23,6.22 71.69,5.77 82.98,5.77 84.58,7.36 87.5,7.36 89.28,5.59 v1(89.28,3.81) 100.71,3.81 105.02,8.13 108.56,8.13 109.75,6.94 111.08,6.94 111.5,7.36 117.69,7.36 118.57,6.48 144.98,6.48 146.5,8 152.27,8 168.1,23.83 168.1,29.54 168.78,30.22 168.78,33.15 v1(169.79,34.16) ; v1(290.32,255.9) 289.94,255.52 289.94,247.58 291.23,246.29 291.23,240.84 292.48,239.59 292.48,230.38 291.46,229.36 291.46,227.73 290.45,226.73 290.45,222.89 288.16,220.6 288.16,217.42 289.05,216.53 289.05,212.72 v1(290.32,211.45) 289.68,211.45 288.3,210.07 288.3,198.72 290.98,196.03 290.98,180.37 290.12,179.5 290.12,169.74 288.83,168.46 288.83,167.39 287.32,165.88 287.04,165.88 286.25,165.09 286.25,161.59 285.57,160.92 282.65,160.92 281.51,159.77 279.86,159.77 279.56,159.47 279.56,157.57 278,156.01 278,147.54 279.03,146.5 279.03,141.91 280.74,140.21 281.68,140.21 281.79,140.1 281.79,139.16 282.33,138.62 282.71,138.62 282.88,138.45 282.88,137.24 284.88,135.23 284.88,97.5 283.33,95.95 283.33,95.12 282.82,94.61 281.99,94.61 275.24,87.86 275.24,85.57 268.97,79.3 268.97,77.8 267.99,76.82 266.3,76.82 v1(264.92,75.44) 258.18,75.44 252.85,80.77 245.16,80.77 243.63,79.24 229.1,79.24 227.95,80.39 225.43,80.39 224.79,81.03 218.23,81.03 217.76,81.5 209.92,81.5 208.36,83.06 198.02,83.06 196.46,81.5 182.33,81.5 181.38,80.54 177.9,80.54 177.41,81.02 v1(177.41,81.53) 177.03,81.53 176.48,80.98 173.11,80.98 170.99,78.87 v1(169.41,78.87) ; v1(129.79,168.15) 126.23,168.15 124.32,170.06 124.32,174.83 123.44,175.71 v1(123.44,184.4)
  LAY6 w0.125: v1(290.32,255.9) 289.8,256.42 275.47,256.42 274.26,257.63 274.26,258.69 275.34,259.77 275.34,265.22 275,265.56 269.63,265.56 269.62,265.56 267.84,265.56 266.71,266.69 263.49,266.69 262.42,265.62 261.43,265.62 260.98,265.17 259.46,265.17 258.18,266.45 253.35,266.45 252.98,266.83 v1(249.93,266.83) ; v1(101.85,229.61) 102.5,228.96 102.5,227.08 103,226.58 103,213.49 106.18,210.32 106.18,202.07 113.92,194.32 118.57,194.32 119.59,193.3 120.74,193.3 122.05,191.99 122.05,185.79 v1(123.44,184.4) ; v1(89.28,3.81) 89.53,4.06 89.53,17.86 93.34,21.67 93.34,27.05 94.36,28.07 v1(94.36,30.66) ; v1(67.94,4.57) 67.94,5.02 68.96,6.04 68.96,6.98 68.06,7.88 68.06,9.82 66.66,11.22 66.66,21.38 67.31,22.02 67.31,23.87 v1(67.43,24)
  BOTTOM w0.089: 158.47,101.7 158.47,104.38 J1F3.141
  BOTTOM w0.1: v1(177.41,81.53) 176.3,82.64 176.3,87.98 173.99,90.3 172.72,90.3 171.32,91.69 171.32,96.23 170.23,97.31 160.6,97.31 160.12,97.79 159.25,97.79 158.75,98.3 158.75,99.34 157.86,100.23 157.86,101.09 158.47,101.7 ; J1E5.141 158.68,131.65 158.68,128.98 157.97,128.27 157.97,127.52 158.5,126.99 158.5,124.04 J1F1.141 158.47,123.71 158.47,121.03 157.97,120.52 157.97,119.78 158.47,119.27 158.47,115.57 158.69,115.36 158.69,113.48 ; J1F3.141 158.58,104.64 158.58,108.74 157.97,109.35 157.97,110.62 158.5,111.15 158.5,113.29 158.69,113.48 ; v1(169.79,34.16) 170.29,34.65 170.29,51.58 169.54,52.32 169.54,67.24 167.47,69.31 167.47,77.43 168.91,78.87 v1(169.41,78.87) ; 158.69,113.48 J1F2.141
SMB_CLK_MAIN_FRU: length 23
  TOP w0.1: R7J13.2 64.64,24.38 64.51,24.51 62.61,24.51 62.1,24 U8J2.6 60.57,24 v1(60.32,24.26)
  LAY6 w0.125: J8J13.37 60.44,8.19 60.44,17.53 59.94,18.03 59.94,23.87 v1(60.32,24.26)
SMB_CLK_RESUME: length 754.5
  TOP w0.1: v1(6.85,99.57) 8.12,100.84 J9F6.1 ; v1(85.21,231.33) Q7B9.3 86.8,231.33 87.24,230.88 87.24,230.22 87.6,229.87 R7B76.1 ; J7B1.B5 59.72,242.36 57.31,242.36 55.98,241.04 51.73,241.04 51.37,241.39 47.42,241.39 46.92,240.88 43.75,240.88 42.74,241.9 39.02,241.9 38.47,242.45 37.03,242.45 36.91,242.58 34.68,242.58 R8B18.1 ; v1(83.05,62.48) 82.42,63.12 79.41,63.12 R7H13.1 ; R7E24.1 71.5,143.89 70.23,143.89 C7E13.2 69.03,144.4 v1(68.58,143.94)
  LAY5 w0.125: J5B2.B5 141.28,242.61 139.34,240.66 139.25,240.66 138.17,239.58 138.17,239.11 137.61,238.55 137.61,236.5 135.63,234.52 135.63,234.06 132.46,230.89 130.73,230.89 129.11,229.26 121.95,229.26 121.29,228.6 119.12,228.6 117.85,229.87 116.84,229.87 113.41,233.3 108.7,233.3 105.91,230.51 105.91,228.34 104.77,227.2 100.45,227.2 98.42,229.23 87.31,229.23 v1(85.21,231.33) 83.92,231.33 80.96,234.29 74.31,234.29 72.77,235.84 v1(72.36,235.84) ; v1(5.96,9.52) 7.94,9.52 12.06,5.41 40.7,5.41 41.63,4.47 65.3,4.47 66.76,5.93 66.76,7.2 67.91,8.35 70.19,8.35 72.89,11.05 83.82,11.05 v1(85.97,13.21) 87.13,12.06 103.63,12.06 103.64,12.07 109.08,12.07 109.75,11.4 125.47,11.4 125.88,11.82 131.66,11.82 131.87,11.61 143.05,11.61 143.25,11.4 144.8,11.4 146.51,13.11 149.98,13.11 150.66,12.44 152.01,12.44 164.55,24.98 164.55,33.48 168.83,37.76 171.95,37.76 175.83,41.64 184.94,41.64 187.25,43.95 195.56,43.95 202.14,50.53 211.87,50.53 217.42,44.98 217.42,41.05 v1(217.28,40.9) ; v1(77.08,200.91) 77.08,196.98 75.46,195.35 74.95,195.35 74.54,194.94 74.54,194.47 73.63,193.55 73.63,170.59 70.8,167.76 70.8,165.1 70.61,164.9 70.61,162.69 70.8,162.49 70.8,160.34 69.69,159.23 69.69,152.37 69.07,151.75 69.07,150.13 69.34,149.86 69.34,144.55 68.73,143.94 v1(68.58,143.94)
  LAY6 w0.125: v1(77.08,200.91) 76.58,201.42 75.56,201.42 74.2,202.78 74.2,221.17 72.78,222.6 72.78,235.42 v1(72.36,235.84) 72.36,236.57 73.91,238.12 73.91,239.01 73.53,239.39 72.89,239.39 72.64,239.65 72.64,240.54 72,241.17 70.19,241.17 68.8,242.57 68.8,245.27 66.42,247.65 61.97,247.65 61.59,247.27 61.59,244.23 J7B1.B5 ; v1(83.05,62.48) 82.82,62.24 82.82,47.89 81.28,46.35 81.28,42.42 83.31,40.38 83.31,21.28 84.2,20.4 84.2,18.58 85.47,17.31 85.47,13.71 v1(85.97,13.21) ; v1(5.96,9.52) 5.96,55.62 6.09,55.75 6.09,62.86 6.85,63.63 8.12,63.63 8.64,64.14 8.64,69.46 6.73,71.37 6.73,99.44 v1(6.85,99.57) 6.68,99.74 6.68,120.34 7.69,121.36 7.69,137.21 7.23,137.67 7.23,141.1 8.38,142.24 v1(8.89,142.24)
  BOTTOM w0.1: v1(68.58,143.94) 68.4,143.76 64.38,143.76 63.83,143.21 59.86,143.21 58.6,141.95 53.57,141.95 52.37,140.75 38.52,140.75 34.61,144.66 24.01,144.66 23.37,144.02 14.91,144.02 14.41,143.51 11.56,143.51 10.28,142.24 v1(8.89,142.24)
SMB_CLK_RESUME_R: length 20.3
  TOP w0.089: U6E1.BE26 92.26,146 92.19,145.92 91.88,145.92 91.77,146.03 88.15,146.03 88,145.88 83.96,145.88 83.81,145.73 83.67,145.73 83.19,145.25 79.04,145.25 78.99,145.3
  TOP w0.1: 78.99,145.3 73.8,145.3 R7E24.2
SMB_CLK_TTK: length 3.1
  TOP w0.1: J7G1.27 78.52,64.9
SMB_DATA_EC: length 1095.4
  TOP w0.1: R8G14.2 34.84,91.44 v1(34.27,90.87) 33.95,90.55 32.89,90.55 32.25,89.91 31.76,89.91 31.62,90.05 U8F6.96 ; J7G1.14 69.63,73.19 70.48,74.04 v1(70.99,74.04) ; v1(280.41,216.15) 279.9,216.15 279.65,216.41 R2C25.1 ; v1(22.22,149.35) 22.11,149.24 19.93,149.24 ; v1(44.45,267.21) 48.26,267.21 48.76,266.7 49.78,266.7 51.56,268.48 59.05,268.48 v1(59.56,267.97) ; R4J3.2 v1(169.79,27.3) ; v1(97.15,93.32) 98.39,92.08 98.39,90.68 100.07,88.99 113.69,88.99 124.58,78.1 130.3,78.1 133.47,74.93 v1(133.47,71.12) ; J6J2.192 v1(140.79,10.54)
  LAY5 w0.125: v1(169.79,27.3) 169.79,23.47 152.93,6.6 147.72,6.6 146.47,5.36 140.61,5.36 139.44,4.19 v1(139.44,3.94) 139.06,4.32 128.16,4.32 127.12,5.36 118.11,5.36 117.23,6.24 111.97,6.24 111.54,5.81 104.3,5.81 101.17,2.68 89.42,2.68 88.64,1.9 88.26,1.9 87.12,3.05 86.36,3.05 85.21,1.9 68.96,1.9 v1(68.32,2.54) 67.43,1.65 30.35,1.65 v1(28.57,3.43) ; v1(97.15,93.32) 96.27,92.44 96.27,89.05 94.41,87.2 94.41,85.54 92.3,83.44 91.66,83.44 91.15,82.93 90.42,82.93 90.17,82.68 90.17,82.17 89.2,81.2 85.97,81.2 83.77,79 80.76,79 79.86,78.1 79.86,76.99 80.12,76.74 80.12,75.02 79,73.91 78.18,73.91 77.03,72.76 74.72,72.76 73.3,74.18 71.13,74.18 v1(70.99,74.04) 70.83,74.04 67.63,70.84 59.91,70.84 58.95,69.88 57.27,69.88 56.73,69.33 55.67,69.33 54.79,70.22 54.07,70.22 53.43,69.59 49.41,69.59 45.71,65.88 45.71,65.17 44.16,63.61 40.51,63.61 37.64,60.75 33.21,60.75 32.52,61.44 27.68,61.44 23.25,65.87 23.25,74.18 25.15,76.08 25.15,79.75 24.51,80.4 24.51,85.01 24.17,85.35 24.17,88.56 24.51,88.9 24.51,90.41 25.01,90.92 25.01,98.42 24.01,99.42 24.01,108.47 24.31,108.76 24.31,113.38 24.76,113.83 24.76,124.62 25.11,124.97 25.11,130.17 24,131.28 24,147.57 v1(22.22,149.35) 17.01,154.56 17.01,158.49 15.72,159.79 15.72,161.16 15.57,161.32 15.57,167.71 15.72,167.87 15.72,173.46 15.85,173.58 15.85,177.32 15.62,177.54 15.11,177.54 14.73,177.93 14.73,208.15 16.89,210.31 16.89,217.17 15.62,218.44 15.62,230.22 11.81,234.03 11.81,250.62 11.13,251.29 11.13,256.09 9.65,257.58 9.65,273.84 12.26,276.45 20.16,276.45 v1(23.87,280.16) ; v1(133.47,71.12) 141.05,71.12 144.77,74.84 154.51,74.84 156.76,77.09 163.6,77.09 165.28,78.77 165.28,79.48 171.4,85.61 174.86,85.61 179.3,90.04 186.17,90.04 186.69,90.57 189.92,90.57 191.95,92.59 204.31,92.59 210.19,86.71 210.19,85.44 211.02,84.61 220.21,84.61 220.56,84.96 226.44,84.96 226.68,85.21 241.05,85.21 241.68,84.58 243.58,84.58 244.09,85.09 252.22,85.09 255.65,81.66 258.5,81.66 261.24,78.91 265.68,78.91 267.13,80.36 268.19,80.36 273.93,86.1 273.93,88.39 283.58,98.04 283.58,134.15 280.74,136.99 280.74,138.36 277.73,141.37 277.73,145.18 276.4,146.52 276.4,148.05 276.7,148.35 276.7,156.35 275.72,157.32 275.72,160.38 280.09,164.75 283.16,164.75 286.22,167.81 286.52,167.81 286.88,168.16 286.88,175.64 286.25,176.26 286.25,178.78 289.04,181.57 289.04,192.9 285.88,196.05 285.88,199.61 284.99,200.5 284.99,203.81 283.68,205.11 282.54,205.11 281.55,206.1 281.55,215.01 v1(280.41,216.15)
  LAY6 w0.125: J8J13.4 27.52,8.54 28.57,7.49 v1(28.57,3.43) ; v1(70.73,97.15) 70.68,97.1 70.68,92.26 70.86,92.08 70.86,84.1 71.44,83.52 71.44,82.65 71.11,82.32 71.11,80.95 71.44,80.62 71.44,74.49 v1(70.99,74.04) 71.45,73.58 71.45,70.52 69.16,68.24 69.16,64.72 68.45,64.01 68.45,59.11 68.19,58.85 68.19,52.51 69.55,51.15 69.55,38.7 67.18,36.32 67.18,33.15 67.81,32.51 67.81,30.49 67.96,30.35 67.96,18.56 67.16,17.76 67.16,11.43 68.56,10.03 68.56,8.09 69.5,7.14 69.5,5.88 68.58,4.95 68.58,2.79 v1(68.32,2.54) ; v1(59.56,267.97) 64.13,267.97 66.16,270 66.16,272.97 63.29,275.84 57.65,275.84 52.57,280.92 24.63,280.92 v1(23.87,280.16)
  BOTTOM w0.1: v1(59.56,267.97) 59.18,268.35 U8L2.5 ; v1(140.79,10.54) 140.79,9.23 139.44,7.87 v1(139.44,3.94) ; v1(34.27,90.87) 35.48,92.07 39.24,92.07 39.75,91.57 42.73,91.57 47.03,95.86 66.57,95.86 66.75,95.68 67.99,95.68 69.72,97.41 70.48,97.41 v1(70.73,97.15) ; v1(44.45,267.21) 45.59,268.35 U8L1.1
SMB_DATA_MAIN: length 832.8
  TOP w0.1: R4J1.2 v1(169.79,29.59) ; v1(291.21,211.45) 291.46,211.45 291.68,211.24 J1C1.51 ; v1(265.63,75.44) 266.35,74.72 U2G3.4 ; J1F1.285 158.67,120.08 158.68,120.09 157.23,121.54 155.7,121.54 155.19,122.05 155.19,122.9 152.22,125.87 152.22,129.8 150.92,131.1 147.27,131.1 146.01,132.36 146.01,147.75 148.49,150.24 148.49,156.2 147.08,157.62 140.37,157.62 130.6,167.38 v1(129.79,167.38) ; Q7B10.2 87.88,226.95 R7C1.1 88.01,226.44 88.26,226.19 89.91,226.19 92.83,229.11 102.1,229.11 102.36,229.36 102.36,229.87 v1(101.85,230.38) ; R7J15.1 v1(66.29,22.73) ; R2A40.1 v1(249.93,267.84) ; v1(93.59,30.66) J7J1.14
  LAY5 w0.125: v1(169.79,29.59) 169.1,28.89 169.1,23.13 152.82,6.85 147.61,6.85 146.37,5.61 139.97,5.61 138.93,4.57 128.27,4.57 127.23,5.61 118.21,5.61 117.33,6.49 111.86,6.49 111.44,6.07 104.2,6.07 101.07,2.93 88.78,2.93 v1(88.39,2.54) 87.63,3.3 86.1,3.3 84.96,2.16 69.52,2.16 68.63,3.05 67.94,3.05 v1(67.43,2.54) ; v1(165.08,75.93) 165.98,75.93 168,77.95 170.78,77.95 173.21,80.38 176.9,80.38 v1(177.03,80.52) 177.51,80.04 181.58,80.04 182.54,81 196.67,81 197.46,81.79 208.93,81.79 209.72,81 217.56,81 218.02,80.53 220.71,80.53 221.86,79.37 228.26,79.37 228.9,78.74 243.84,78.74 245.36,80.26 252.65,80.26 257.98,74.93 265.17,74.93 265.63,75.39 v1(265.63,75.44) 266.52,76.32 268.73,76.32 271.27,78.87 271.27,80.89 275.74,85.36 275.74,86.26 277.43,87.95 277.43,89.34 282.2,94.11 283.03,94.11 283.83,94.91 283.83,95.74 285.38,97.3 285.38,135.44 283.38,137.45 283.38,138.66 282.92,139.12 282.54,139.12 282.29,139.37 282.29,140.48 281.55,141.22 280.54,141.22 280.01,141.75 280.01,146.23 278.5,147.75 278.5,155.8 283.11,160.42 285.78,160.42 286.75,161.38 286.75,163.94 287.9,165.1 287.9,165.73 289.33,167.16 289.33,168.25 290.62,169.54 290.62,179.29 291.48,180.16 291.48,196.23 288.8,198.92 288.8,209.04 v1(291.21,211.45) 289.55,213.11 289.55,220.92 291.21,222.58 291.21,226.41 291.74,226.95 293.29,226.95 294.09,227.75 294.09,239.04 291.98,241.15 291.98,246.6 290.69,247.89 290.69,254.88 v1(291.71,255.9) ; v1(123.44,185.29) 123.56,185.41 123.95,185.41 125.22,184.14 125.22,169.87 126.3,168.78 129.92,168.78 130.3,168.4 130.3,167.89 v1(129.79,167.38)
  LAY6 w0.125: v1(88.39,2.54) 88.39,3.68 89.03,4.33 89.03,18.07 92.2,21.23 92.2,26.69 93.59,28.09 v1(93.59,30.66) ; v1(123.44,185.29) 122.55,186.18 122.55,192.19 120.94,193.8 119.8,193.8 118.78,194.82 114.13,194.82 106.68,202.28 106.68,210.53 103.5,213.7 103.5,226.79 103,227.29 103,229.23 v1(101.85,230.38) ; v1(66.29,22.73) 65.91,22.35 65.91,10.91 67.31,9.51 67.31,2.67 v1(67.43,2.54) ; v1(249.93,267.84) 257.93,267.84 259.46,266.32 262.38,266.32 263.27,267.21 272.53,267.21 273.68,266.06 275.2,266.06 275.84,265.43 275.84,259.33 275.2,258.7 275.2,257.39 275.68,256.92 290.7,256.92 v1(291.71,255.9)
  BOTTOM w0.1: v1(177.03,80.52) 177.16,80.52 177.92,81.28 177.92,83.18 176.78,84.33 176.78,88.17 174.18,90.77 172.91,90.77 171.79,91.89 171.79,96.42 170.43,97.79 160.79,97.79 160.4,98.19 160.4,99.33 158.96,100.77 J1F3.285 158.65,101.04 158.83,101.22 158.83,103.62 159.36,104.16 159.36,105.03 158.85,105.54 158.85,109.47 J1F2.285 158.85,109.85 158.85,112.39 159.49,113.03 159.49,113.92 159.11,114.3 159.11,115.57 158.83,115.85 158.83,119.91 J1F1.285 158.83,120.26 158.83,122.78 159.49,123.44 159.49,124.84 158.85,125.47 158.85,127.69 158.69,127.86 J1E5.285 ; v1(165.08,75.93) 165.08,70.24 168.52,66.8 168.52,30.86 v1(169.79,29.59)
