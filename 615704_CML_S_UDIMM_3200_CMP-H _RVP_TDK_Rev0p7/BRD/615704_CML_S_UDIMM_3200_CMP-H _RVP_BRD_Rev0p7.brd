# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DQS_A_DP<4>: length 56.2
  TOP w0.165: v3(209.44,164.72) J3D1.AV8
  LAY2 w0.088: 210.53,160.9 210.53,162.61 210.39,162.76 210.39,163.53 209.84,164.08 209.84,164.35 209.47,164.72 v3(209.44,164.72)
  LAY2 w0.089: J1F1.245 192.61,120.39 192.61,122.31 192.62,122.78 193.42,123.58 193.42,123.78 193.24,124.34 193.24,125.39 192.88,125.99 192.88,126.6 193.11,126.83 193.11,127.42 J1E5.245 193.19,127.86 193.27,127.94 193.27,128.94 193.01,129.2 192.69,129.2 192.6,129.29 192.6,130.3 192.3,130.6 192.3,130.79 192.46,130.95 192.61,130.95 192.77,130.79 192.89,130.79 193.16,131.06 193.4,131.06 193.49,131.15 193.49,131.47 193.38,131.58 193.38,131.71 193.49,131.82 193.49,132.02 195.57,134.1 195.57,134.55 195.77,134.75 196.21,134.75 196.72,135.26 196.72,145.91 208.83,158.02 208.83,158.66 210.53,160.36 210.53,160.9
M_DQS_A_DP<5>: length 58.3
  TOP w0.15: v3(205.78,164.72) J3D1.AV3
  LAY2 w0.088: 183.23,126.93 183.23,126.35 J1E5.256 183.41,126.17 183.41,125.67 ; 204.91,162.45 204.91,162.45 205.2,162.73 205.2,163.35 206.06,164.21 206.06,164.38 v3(205.78,164.72)
  LAY2 w0.089: 183.23,126.93 183.23,129.01 184,129.77 184,130.44 183.23,131.21 183.23,131.96 189.99,138.72 189.99,148.29 204.15,162.45 204.91,162.45 ; 183.41,125.67 183.32,125.58 183.32,123.39 184.09,122.62 184.09,122.05 183.88,121.83 183.88,120.79 183.31,120.22 183.31,118.5 J1F1.256
M_DQS_A_DP<6>: length 69.8
  TOP w0.15: v3(204.86,168.36) J3D1.AP3
  LAY2 w0.089: J1F1.267 173.91,120.39 173.91,122.31 173.91,122.78 174.72,123.58 174.72,123.78 174.54,124.34 174.54,125.39 174.18,125.99 174.18,126.6 174.41,126.83 174.41,127.42 J1E5.267 174.49,127.86 174.57,127.94 174.57,128.94 174.31,129.2 173.99,129.2 173.9,129.29 173.9,130.3 173.6,130.6 173.6,130.79 173.76,130.95 173.91,130.95 174.07,130.79 174.19,130.79 174.76,131.37 174.76,132.24 174.65,132.35 174.65,134.73 174.92,135 175.42,135 175.68,134.74 175.68,134 175.77,133.91 176.09,133.91 176.49,134.32 176.49,134.83 176.36,134.96 176.36,135.96 178.44,138.04 178.44,145.78 199.39,166.73 200.8,166.73 202.23,168.16 202.91,168.16 203.22,168.47 203.88,168.47 204.36,167.99 204.38,167.99 204.38,167.99 204.5,167.99 v3(204.86,168.36)
M_DQS_A_DP<7>: length 80.6
  TOP w0.165: v3(204.86,173.06) J3D1.AJ3
  LAY2 w0.088: 164.71,125.67 164.71,126.17 J1E5.278 164.53,126.93
  LAY2 w0.089: J1F1.278 164.61,118.5 164.61,120.22 165.18,120.79 165.18,121.83 165.39,122.05 165.39,122.62 164.62,123.39 164.62,125.58 164.71,125.67 ; v3(204.86,173.06) 204.49,172.68 204,172.68 203.65,173.04 200.94,173.04 200.84,173.14 196.9,173.14 171.56,147.8 167.23,140.13 167.23,137.12 167.14,137.03 166.63,137.03 166.43,136.83 166.43,135.99 166.63,135.79 167.14,135.79 167.23,135.7 167.23,135.15 167.14,135.07 166.67,135.07 166.47,134.87 166.47,134.11 166.67,133.92 167.03,133.92 167.12,133.83 167.12,133.51 166.85,133.24 166.4,133.24 165.76,132.6 165.09,132.6 164.54,132.04 164.54,131.96 164.54,131.2 165.3,130.44 165.3,129.77 164.53,129.01 164.53,126.93
M_DQS_A_DP<8>: length 77.5
  TOP w0.165: J3D1.AJ30 231.79,172.07 v3(231.79,172.07) ; J1E5.197 238.86,126.96 238.86,126.65 238.74,126.54 238.74,125.98 238.8,125.92 238.8,125.5 239.28,124.41 239.28,123.59 238.43,122.73 238.43,121.89 237.86,121.33 237.86,120.5 237.85,120.48 237.85,120.48 237.73,120.36 237.73,120.13 237.85,120.01 238.01,120.01 J1F1.197
  LAY8 w0.089: v3(231.79,172.07) 232.07,172.07 232.18,171.96 232.18,171.81 232.04,171.67 228.81,171.67 228.46,171.32 228.46,169.15 228.22,168.92 226.92,168.92 226.52,168.51 226.52,167.98 226.67,167.82 226.67,165.27 226.3,164.9 226.22,164.9 226.21,164.89
  LAY8 w0.19: 226.21,164.89 225.66,164.34 225.66,160.3 226.22,159.74 226.22,154.88 226.44,154.66 226.44,149.58 225.17,148.31 225.17,147.53 225.72,146.98 226.16,146.98 227.2,145.95 227.2,145.68 225.78,144.26 225.78,143.73 226.36,143.14 226.89,143.14 228.31,144.56 228.58,144.56 228.99,144.16 228.99,143.89 227.56,142.47 227.56,141.94 228.15,141.35 228.68,141.35 229.37,142.04 229.74,142.04 230.44,141.34 230.44,140.96 229.8,140.32 229.8,139.71 231.52,137.98 231.52,137.28 232.33,136.47 232.94,136.47 233.57,135.83 233.57,135.23 235.86,132.94 235.86,131.24 236.71,130.39 236.71,129.86 236.71,129.85 236.71,129.64 237.3,129.05 237.88,129.05 238.28,128.65 238.83,128.65 239.26,128.22 239.26,127.56 239.09,127.39 238.93,127.39 238.8,127.43 J1E5.197
M_DQS_B_DN<0>: length 112.3
  TOP w0.088: J1F3.152 276.8,101.11 276.03,102.94 276.03,103.74 276.59,104.3 276.59,104.87 276.34,105.13 v1(276.34,105.48) 276.03,105.79 276.03,106.27 276.12,106.36 277.22,106.36 277.42,106.56 277.42,107.05 277.2,107.26 276.14,107.26 276,107.4 276,108.07 276.05,108.12 276.05,108.24 276,108.29 276,108.49 276.19,108.68 276.38,108.68 276.51,108.55 J1F2.152
  TOP w0.165: J3D1.AE34 v3(236.33,175.69)
  LAY9 w0.089: v3(236.33,175.69) 236.7,175.32 238.3,175.32 239.2,176.22 241.28,176.22 241.67,175.82 243.53,175.82 243.87,175.49 249.13,175.49 258.07,166.56 258.07,161.92 273.16,146.83 273.16,134.9 272.84,134.57 272.84,134.11 273.16,133.78 273.16,132.24 273.41,131.99 273.41,131.49 273.51,131.39 273.52,131.39 274.37,130.53 274.37,129.52 275.19,128.69 275.19,127.4 274.45,126.66 274.45,125.64 275.19,124.9 275.19,123.33 274.33,122.48 274.33,121.69 275.23,120.8 275.23,119.72 274.37,118.87 274.37,118.02 274.92,117.47 274.92,114.33 275.2,114.06 275.2,113.16 276.03,112.32 276.03,111.6 276.92,110.09 276.92,109.22 276.05,108.35 276.05,107.8 276.32,107.53 276.32,107.14 276.05,106.87 276.05,105.77 v1(276.34,105.48)
M_DQS_B_DN<1>: length 100.4
  TOP w0.088: J1F3.163 267.25,100.29 267.1,100.14 266.88,100.14 266.79,100.23 266.79,101.08 267.56,102.91 267.56,103.72 268.09,104.25 268.09,104.86 267.84,105.12 v1(267.84,105.48) 267.84,105.49 267.56,105.77 267.56,105.92 267.65,106.01 267.91,106.01 268.14,106.23 268.14,106.73 267.94,106.93 267.47,106.93 267.22,106.68 266.84,106.68 266.76,106.77 266.76,107.06 266.89,107.2 267.06,107.2 267.59,107.73 267.59,108.1 267.6,108.1 267.6,108.29 267.59,108.29 267.59,108.57 267.37,108.79 267.37,109.07 J1F2.163
  TOP w0.165: J3D1.AK34 v3(236.33,171.12)
  LAY9 w0.089: v1(267.84,105.48) 267.55,105.77 267.55,106.46 267.8,106.71 267.8,107.18 267.55,107.43 267.55,108.54 266.86,109.22 265.98,111.66 265.98,112.2 266.68,112.9 266.68,113.93 265.86,118.1 265.86,118.85 266.59,119.59 266.59,120.4 265.96,122.02 265.96,122.61 266.58,123.23 266.58,124.05 265.95,126.07 265.95,126.66 266.6,127.31 266.6,128.09 265.87,129.85 265.87,130.53 265.1,131.3 265.1,132.23 265.25,132.38 265.25,145.8 260.68,150.37 259.81,150.37 259.37,150.81 259.37,151.68 252.01,159.04 252.01,164.15 250.02,166.15 246.1,166.15 243.06,169.19 242.46,169.19 242.31,169.34 241.66,169.34 241.13,169.88 239.29,169.88 239.28,169.87 238.95,169.87 238.94,169.88 238.93,169.88 238.72,170.09 238.72,170.44 238.4,170.76 236.69,170.76 236.62,170.83 v3(236.33,171.12)
M_DQS_B_DN<2>: length 92.1
  TOP w0.088: J1F3.174 258.1,101.11 257.33,102.94 257.33,103.74 257.89,104.3 257.89,104.87 257.64,105.13 v1(257.64,105.48) 257.33,105.79 257.33,106.27 257.42,106.36 258.52,106.36 258.72,106.56 258.72,107.05 258.5,107.26 257.44,107.26 257.3,107.4 257.3,108.07 257.35,108.12 257.35,108.24 257.3,108.29 257.3,108.49 257.49,108.68 257.68,108.68 257.81,108.55 J1F2.174
  TOP w0.165: J3D1.AP35 v3(237.29,167.46)
  LAY9 w0.089: v3(237.29,167.46) 236.96,167.46 236.88,167.37 236.88,166.36 237.1,166.14 237.52,166.14 237.83,165.83 237.83,165.45 238.02,165.26 238.36,165.26 238.69,164.93 238.69,164.59 238.92,164.36 239.28,164.36 239.64,164 239.64,163.56 239.81,163.39 240.22,163.39 240.31,163.29 240.31,163.29 240.57,163.03 240.57,162.86 241.21,162.22 241.21,159.57 253.5,147.28 253.5,138.49 256.09,135.9 256.09,135.08 256.18,134.99 256.87,134.99 257.07,134.79 257.07,134.08 256.87,133.88 256.18,133.88 256.09,133.8 256.09,133.29 256.18,133.2 256.86,133.2 257.06,133.01 257.06,132.46 256.52,131.91 256.52,131.39 257.37,130.53 257.37,129.52 258.19,128.69 258.19,127.4 257.45,126.66 257.45,125.64 258.19,124.9 258.19,123.33 257.33,122.48 257.33,121.69 258.23,120.8 258.23,119.72 257.37,118.87 257.37,117.99 258,117.37 258,114.17 258.18,113.98 258.18,112.94 257.4,112.15 257.4,111.52 258.16,110.76 258.16,109.25 257.34,108.43 257.34,107.31 257.55,107.1 257.55,106.68 257.34,106.47 257.34,105.78 v1(257.64,105.48)
M_DQS_B_DN<3>: length 85.8
  TOP w0.088: J1F3.185 248.55,100.29 248.4,100.14 248.18,100.14 248.09,100.23 248.09,101.08 248.86,102.91 248.86,103.72 249.39,104.25 249.39,104.86 249.14,105.12 v1(249.14,105.48) 249.14,105.49 248.86,105.77 248.86,105.92 248.95,106.01 249.21,106.01 249.44,106.23 249.44,106.73 249.24,106.93 248.77,106.93 248.52,106.68 248.14,106.68 248.06,106.77 248.06,107.06 248.19,107.2 248.36,107.2 248.89,107.73 248.89,108.1 248.9,108.1 248.9,108.29 248.89,108.29 248.89,108.57 248.67,108.79 248.67,109.07 J1F2.185
  TOP w0.115: J3D1.AP30 v3(232.67,167.46)
  LAY9 w0.089: v3(232.67,167.46) 232.42,167.46 232.31,167.35 232.31,163.55 233.2,162.66 233.2,161.31 235.2,159.3 235.2,157.11 245.13,147.18 245.13,136.6 248.02,133.72 248.02,131.39 248.87,130.53 248.87,130.03 249.6,128.23 249.6,127.31 248.98,126.69 248.98,126.03 249.61,124.13 249.61,123.26 248.96,122.61 248.96,121.97 249.59,120.47 249.59,119.58 248.82,118.81 248.82,115.83 249.6,113.84 249.6,112.86 248.96,112.22 248.96,111.37 249.62,110.2 249.62,109.17 248.82,108.37 248.82,107.57 249.01,107.38 249.01,106.96 248.82,106.76 248.82,105.78 249.12,105.48 v1(249.14,105.48)
M_DQS_B_DN<4>: length 91.1
  TOP w0.088: J1F2.244 193.21,108.55 193.08,108.68 192.89,108.68 192.7,108.49 192.7,108.29 192.75,108.24 192.75,108.12 192.7,108.07 192.7,107.4 192.84,107.26 193.9,107.26 194.12,107.05 194.12,106.56 193.92,106.36 192.82,106.36 192.73,106.27 192.73,105.79 v1(193.04,105.48) 193.04,105.13 193.29,104.87 193.29,104.3 192.73,103.74 192.73,102.94 193.5,101.11 J1F3.244
  TOP w0.115: J3D1.AN12 215.75,168.71 215.42,168.38 v3(215.29,168.38)
  LAY9 w0.088: v3(215.29,168.38) 215.29,168.73 215.21,168.82 215.05,168.82 213.8,167.56 213.8,166.43 213.5,166.13 213.5,162.24 213.41,162.15 213.41,162.15 213.36,162.1
  LAY9 w0.089: v1(193.04,105.48) 192.75,105.77 192.75,106.55 192.95,106.75 192.95,107.17 192.75,107.37 192.75,108.35 193.51,109.12 193.51,110.29 194.49,111.27 194.49,112.31 195.21,113.03 195.21,116.9 196.17,117.86 196.17,118.87 197.03,119.72 197.03,120.8 196.13,121.69 196.13,122.48 196.99,123.33 196.99,124.9 196.25,125.64 196.25,126.66 196.99,127.4 196.99,128.69 196.17,129.52 196.17,130.56 195.31,131.42 195.31,135.27 195.4,135.36 195.53,135.36 195.7,135.53 195.7,136.19 195.53,136.37 195.4,136.37 195.31,136.46 195.31,137.08 198.53,140.3 198.53,141.18 198.53,147.27 213.36,162.1
M_DQS_B_DN<5>: length 94.2
  TOP w0.088: J1F3.255 183.95,100.29 183.8,100.14 183.58,100.14 183.49,100.23 183.49,101.08 184.26,102.91 184.26,103.72 184.79,104.25 184.79,104.86 184.54,105.12 v1(184.54,105.48) 184.54,105.49 184.26,105.77 184.26,105.92 184.35,106.01 184.61,106.01 184.84,106.23 184.84,106.73 184.64,106.93 184.17,106.93 183.92,106.68 183.54,106.68 183.46,106.77 183.46,107.06 183.59,107.2 183.76,107.2 184.29,107.73 184.29,108.1 184.3,108.1 184.3,108.29 184.29,108.29 184.29,108.57 184.07,108.79 184.07,109.07 J1F2.255
  TOP w0.165: J3D1.AP7 v3(209.44,168.38)
  LAY9 w0.088: 204.63,163.29 206,163.29 206.08,163.21 206.91,163.21 207.3,163.6 207.3,164.16 207.46,164.32 207.86,164.32 207.87,164.32 207.91,164.32 208.1,164.52 208.1,166.83 209.08,167.8 209.08,168.29 209.17,168.38 v3(209.44,168.38)
  LAY9 w0.089: 204.63,163.29 204.63,163.28 204.61,163.28 204.38,163.05 204.38,162.74 190.93,149.28 190.93,146.88 192.22,145.58 192.22,142.85 185.13,135.76 185.13,131.37 185.97,130.53 185.97,129.52 186.79,128.69 186.79,127.4 186.05,126.66 186.05,125.64 186.79,124.9 186.79,123.33 185.93,122.48 185.93,121.69 186.83,120.8 186.83,119.72 185.96,118.85 185.96,115.16 185.23,114.43 185.23,113.1 184.27,112.14 184.27,110.7 183.52,109.95 183.52,109.3 184.25,108.57 184.25,107.41 184.47,107.19 184.47,106.82 184.25,106.59 184.25,105.77 v1(184.54,105.48)
M_DQS_B_DN<6>: length 103.4
  TOP w0.088: J1F2.266 174.51,108.55 174.38,108.68 174.19,108.68 174,108.49 174,108.29 174.05,108.24 174.05,108.12 174,108.07 174,107.4 174.14,107.26 175.2,107.26 175.42,107.05 175.42,106.56 175.22,106.36 174.12,106.36 174.03,106.27 174.03,105.79 v1(174.34,105.48) 174.34,105.13 174.59,104.87 174.59,104.3 174.03,103.74 174.03,102.94 174.8,101.11 J1F3.266
  TOP w0.165: v3(210.37,171.12) 210.35,171.12 J3D1.AL8
  LAY9 w0.088: v3(210.37,171.12) 210.43,171.19 210.43,171.45 210.3,171.58 209.93,171.58 208.96,170.61 208.23,170.61 207.89,170.94 206.76,170.94 206.23,170.41 206.09,170.41 205.75,170.07 205.58,170.07 205.17,169.66 204.32,169.66 204.26,169.72 203.74,169.72 203.18,169.16 202.31,169.16
  LAY9 w0.089: 202.31,169.16 202.07,169.16 176.66,143.76 176.66,136.36 175.77,135.47 175.77,132.86 174.86,131.95 174.86,131.43 175.77,130.51 175.77,129.52 176.59,128.69 176.59,127.4 175.85,126.66 175.85,125.64 176.59,124.9 176.59,123.33 175.73,122.48 175.73,121.69 176.63,120.8 176.63,119.72 175.77,118.87 175.77,118.21 175.26,117.7 175.26,116.24 174.88,115.87 174.88,112.94 174.1,112.15 174.1,111.52 174.86,110.76 174.86,109.25 174.04,108.43 174.04,107.38 174.23,107.2 174.23,106.78 174.04,106.59 174.04,105.78 v1(174.34,105.48)
M_DQS_B_DN<7>: length 116.8
  TOP w0.088: J1F3.277 165.25,100.29 165.1,100.14 164.88,100.14 164.79,100.23 164.79,101.08 165.56,102.91 165.56,103.72 166.09,104.25 166.09,104.86 165.84,105.12 v1(165.84,105.48) 165.84,105.49 165.56,105.77 165.56,105.92 165.65,106.01 165.91,106.01 166.14,106.23 166.14,106.73 165.94,106.93 165.47,106.93 165.22,106.68 164.84,106.68 164.76,106.77 164.76,107.06 164.89,107.2 165.06,107.2 165.59,107.73 165.59,108.1 165.6,108.1 165.6,108.29 165.59,108.29 165.59,108.57 165.37,108.79 165.37,109.07 J1F2.277
  TOP w0.165: J3D1.AG8 v3(209.44,174.78)
  LAY9 w0.088: v3(209.44,174.78) 209.1,175.11 207.41,175.11 206.98,175.54 206.24,175.54 205.72,176.06 202.32,176.06 202.32,176.06 202.27,176.06
  LAY9 w0.089: v1(165.84,105.48) 165.55,105.77 165.55,106.72 165.73,106.9 165.73,107.32 165.57,107.49 165.57,108.41 166.42,109.27 166.42,110.37 165.51,111.28 165.51,112.07 166.46,113.02 166.46,113.79 165.76,114.49 164.62,114.49 164.53,114.58 164.53,115.5 164.62,115.58 165.75,115.58 165.97,115.81 165.97,116.6 165.52,117.05 165.52,117.64 165.69,117.81 165.69,117.93 165.52,118.1 165.52,118.81 166.43,119.72 166.43,120.72 166.43,120.72 166.43,120.8 165.53,121.69 165.53,122.48 166.39,123.33 166.39,124.9 165.65,125.64 165.65,126.66 166.39,127.4 166.39,128.69 165.57,129.52 165.57,130.53 164.72,131.39 164.72,132.08 164.82,132.19 164.82,132.32 164.72,132.43 164.72,133.2 164.43,133.49 164.43,138.65 164.98,139.2 165.51,139.2 165.75,139.44 165.75,141.59 199.88,175.73 201.56,175.73 201.89,176.06 202.27,176.06
M_DQS_B_DN<8>: length 94.1
  TOP w0.088: J1F2.196 239.11,108.55 238.98,108.68 238.79,108.68 238.6,108.49 238.6,108.29 238.65,108.24 238.65,108.12 238.6,108.07 238.6,107.4 238.74,107.26 239.8,107.26 240.02,107.05 240.02,106.56 239.82,106.36 238.72,106.36 238.63,106.27 238.63,105.79 v1(238.94,105.48) 238.94,105.13 239.19,104.87 239.19,104.3 238.63,103.74 238.63,102.94 239.4,101.11 J1F3.196 ; v3(229.05,172.07) J3D1.AJ26
  BOTTOM w0.088: v3(229.05,172.07) 229.05,172.42 228.96,172.51 228.74,172.51 228.65,172.42 228.65,169.08 228.3,168.73 227.02,168.73 226.78,168.49 226.78,168.01 226.87,167.92 226.87,165.27 226.61,165 226.61,164.77 226.73,164.64 226.73,163.48 227.47,162.74 227.47,154.42 228.84,153.05 228.84,137.86 233.8,132.9 233.94,132.9 234.46,132.38 234.46,131.73
  BOTTOM w0.165: 234.46,131.73 234.46,131.19 233.67,130.4 233.67,128.99 234.41,128.25 234.41,127.42 233.63,126.64 233.63,125.49 234.42,124.7 234.42,123.37 233.62,122.57 233.62,122 233.64,121.99 233.64,121.31 234.42,120.53 234.42,119.74 235.32,118.84 235.32,118 235.64,117.67 237,117.67 237.38,117.3 237.38,116.5 237,116.12 235.91,116.12 235.75,115.96 235.75,115.21 235.91,115.04 236.16,115.04 236.5,114.71 236.5,114.2 236.16,113.87 236.16,113.14 237,112.31 237,111.37 237.89,110.48 237.89,109.38 238.73,108.54 238.73,105.69 v1(238.94,105.48)
M_DQS_B_DP<0>: length 112.3
  TOP w0.088: J1F3.153 276.16,100.29 276.3,100.14 276.52,100.14 276.61,100.23 276.61,101.08 275.84,102.91 275.84,103.72 275.31,104.25 275.31,104.86 275.57,105.12 v1(275.57,105.48) 275.57,105.49 275.84,105.77 275.84,106.35 276.05,106.55 277.14,106.55 277.23,106.64 277.23,106.97 277.13,107.07 276.06,107.07 275.81,107.32 275.81,108.57 276.04,108.79 276.04,109.03 J1F2.153
  TOP w0.165: J3D1.AF34 v3(236.33,174.78)
  LAY9 w0.089: v1(275.57,105.48) 275.86,105.77 275.86,105.9 275.77,105.99 275.67,105.99 275.58,106.08 275.58,106.29 275.67,106.38 275.77,106.38 275.86,106.47 275.86,106.95 276.13,107.22 276.13,107.45 275.86,107.72 275.86,108.42 276.73,109.3 276.73,110.04 275.84,111.55 275.84,112.24 275.01,113.08 275.01,113.98 274.73,114.25 274.73,117.39 274.19,117.94 274.19,118.95 275.04,119.8 275.04,120.72 274.14,121.61 274.14,122.56 275,123.41 275,124.82 274.26,125.56 274.26,126.74 275,127.48 275,128.62 274.18,129.44 274.18,130.45 273.22,131.42 273.22,131.91 272.97,132.16 272.97,133.7 272.65,134.03 272.65,134.65 272.97,134.98 272.97,146.75 257.88,161.84 257.88,166.48 249.06,175.31 243.79,175.31 243.46,175.64 241.59,175.64 241.2,176.03 239.28,176.03 238.38,175.13 236.68,175.13 v3(236.33,174.78)
M_DQS_B_DP<1>: length 100.4
  TOP w0.088: J1F2.164 266.9,108.55 267.02,108.68 267.22,108.68 267.4,108.49 267.4,108.29 267.34,108.22 267.34,108.03 267.4,107.96 267.4,107.81 266.98,107.39 266.81,107.39 266.57,107.14 266.57,106.69 266.76,106.49 267.29,106.49 267.55,106.74 267.86,106.74 267.95,106.66 267.95,106.31 267.83,106.2 267.57,106.2 267.37,106 267.37,105.79 v1(267.07,105.48) 267.07,105.13 266.81,104.87 266.81,104.3 267.37,103.74 267.37,102.94 266.6,101.11 J1F3.164
  TOP w0.165: J3D1.AL34 v3(236.33,170.2)
  LAY9 w0.089: v3(236.33,170.2) 236.27,170.26 236.27,170.52 236.38,170.64 236.54,170.64 236.61,170.57 238.32,170.57 238.53,170.36 238.53,170.01 238.85,169.69 238.86,169.69 238.87,169.68 239.36,169.68 239.37,169.69 241.05,169.69 241.59,169.15 242.23,169.15 242.38,169 242.99,169 246.03,165.96 249.94,165.96 251.82,164.08 251.82,158.96 259.18,151.6 259.18,150.73 259.73,150.18 260.6,150.18 265.06,145.72 265.06,132.45 264.91,132.31 264.91,131.22 265.68,130.45 265.68,129.81 266.41,128.05 266.41,127.39 265.76,126.74 265.76,126.04 266.39,124.03 266.39,123.31 265.77,122.69 265.77,121.99 266.41,120.37 266.41,119.67 265.67,118.93 265.67,118.08 266.49,113.91 266.49,112.98 265.79,112.28 265.79,111.63 266.7,109.12 266.73,109.09 267.36,108.46 267.36,107.35 267.61,107.1 267.61,106.79 267.36,106.54 267.36,105.77 267.36,105.77 v1(267.07,105.48)
M_DQS_B_DP<2>: length 92
  TOP w0.088: J1F3.175 257.46,100.29 257.6,100.14 257.82,100.14 257.91,100.23 257.91,101.08 257.14,102.91 257.14,103.72 256.61,104.25 256.61,104.86 256.87,105.12 v1(256.87,105.48) 256.87,105.49 257.14,105.77 257.14,106.35 257.35,106.55 258.44,106.55 258.53,106.64 258.53,106.97 258.43,107.07 257.36,107.07 257.11,107.32 257.11,108.57 257.34,108.79 257.34,109.03 J1F2.175
  TOP w0.165: J3D1.AP34 v3(236.28,167.46)
  LAY9 w0.089: v1(256.87,105.48) 257.15,105.76 257.15,106.55 257.36,106.76 257.36,107.02 257.15,107.23 257.15,108.5 257.97,109.32 257.97,110.68 257.21,111.44 257.21,112.23 258,113.01 258,113.9 257.81,114.09 257.81,117.29 257.18,117.91 257.18,118.95 258.04,119.8 258.04,120.72 257.14,121.61 257.14,122.56 258,123.41 258,124.82 257.26,125.56 257.26,126.74 258,127.48 258,128.62 257.18,129.44 257.18,130.45 256.32,131.31 256.32,131.98 256.87,132.53 256.87,132.93 256.78,133.02 256.1,133.02 255.9,133.22 255.9,133.87 256.1,134.07 256.79,134.07 256.88,134.16 256.88,134.72 256.79,134.81 256.1,134.81 255.9,135 255.9,135.82 253.31,138.41 253.31,147.2 241.02,159.5 241.02,162.14 240.38,162.78 240.38,162.95 240.15,163.19 240.13,163.19 240.12,163.2 239.73,163.2 239.45,163.48 239.45,163.93 239.21,164.17 238.84,164.17 238.5,164.52 238.5,164.85 238.28,165.07 237.94,165.07 237.64,165.37 237.64,165.76 237.44,165.95 237.02,165.95 236.69,166.29 236.69,167.19 236.41,167.46 v3(236.28,167.46)
M_DQS_B_DP<3>: length 85.8
  TOP w0.088: J1F3.186 247.9,101.11 248.67,102.94 248.67,103.74 248.11,104.3 248.11,104.87 248.37,105.13 v1(248.37,105.48) 248.67,105.79 248.67,106 248.87,106.2 249.13,106.2 249.25,106.31 249.25,106.66 249.16,106.74 248.85,106.74 248.59,106.49 248.06,106.49 247.87,106.69 247.87,107.14 248.11,107.39 248.28,107.39 248.7,107.81 248.7,107.96 248.64,108.03 248.64,108.22 248.7,108.29 248.7,108.49 248.52,108.68 248.32,108.68 248.2,108.55 J1F2.186
  TOP w0.115: J3D1.AP29 v3(231.75,167.46)
  LAY9 w0.089: v1(248.37,105.48) 248.63,105.75 248.63,106.84 248.83,107.04 248.83,107.3 248.63,107.49 248.63,108.45 249.43,109.24 249.43,110.15 248.77,111.32 248.77,112.3 249.41,112.94 249.41,113.81 248.63,115.8 248.63,118.89 249.4,119.66 249.4,120.43 248.77,121.93 248.77,122.68 249.42,123.34 249.42,124.1 248.79,126 248.79,126.77 249.41,127.39 249.41,128.2 248.68,129.99 248.68,130.45 247.83,131.31 247.83,133.64 244.94,136.52 244.94,147.1 235.01,157.03 235.01,159.23 233.01,161.23 233.01,162.58 232.12,163.47 232.12,167.37 232.03,167.46 v3(231.75,167.46)
M_DQS_B_DP<4>: length 91
  TOP w0.088: J1F3.245 192.86,100.29 193,100.14 193.22,100.14 193.31,100.23 193.31,101.08 192.54,102.91 192.54,103.72 192.01,104.25 192.01,104.86 192.27,105.12 v1(192.27,105.48) 192.27,105.49 192.54,105.77 192.54,106.35 192.75,106.55 193.84,106.55 193.93,106.64 193.93,106.97 193.83,107.07 192.76,107.07 192.51,107.32 192.51,108.57 192.74,108.79 192.74,109.03 J1F2.245
  TOP w0.115: J3D1.AN11 v3(215.29,169.29)
  LAY9 w0.088: v3(215.29,169.29) 215.26,169.29 213.61,167.64 213.61,166.51 213.31,166.21 213.31,162.32 213.22,162.23
  LAY9 w0.089: v1(192.27,105.48) 192.56,105.77 192.56,106.63 192.76,106.83 192.76,107.09 192.56,107.29 192.56,108.43 193.33,109.2 193.33,110.37 194.31,111.35 194.31,112.39 195.03,113.11 195.03,116.98 195.99,117.94 195.99,118.95 196.84,119.8 196.84,120.72 195.94,121.61 195.94,122.56 196.8,123.41 196.8,124.82 196.06,125.56 196.06,126.74 196.8,127.48 196.8,128.62 195.98,129.44 195.98,130.49 195.12,131.34 195.12,135.34 195.32,135.54 195.45,135.54 195.52,135.61 195.52,136.11 195.45,136.18 195.32,136.18 195.12,136.38 195.12,137.16 198.34,140.38 198.34,141.25 198.34,141.25 198.34,147.35 213.22,162.23
M_DQS_B_DP<5>: length 94.1
  TOP w0.088: J1F2.256 183.6,108.55 183.72,108.68 183.92,108.68 184.1,108.49 184.1,108.29 184.04,108.22 184.04,108.03 184.1,107.96 184.1,107.81 183.68,107.39 183.51,107.39 183.27,107.14 183.27,106.69 183.46,106.49 183.99,106.49 184.25,106.74 184.56,106.74 184.65,106.66 184.65,106.31 184.53,106.2 184.27,106.2 184.07,106 184.07,105.79 v1(183.77,105.48) 183.77,105.13 183.51,104.87 183.51,104.3 184.07,103.74 184.07,102.94 183.3,101.11 J1F3.256
  TOP w0.165: J3D1.AP6 208.52,168.38 v3(208.54,168.38)
  LAY9 w0.088: 204.48,163.42 204.48,163.42 204.54,163.47 204.55,163.47 204.55,163.48 204.71,163.48 204.71,163.47 206.09,163.47 206.16,163.41 206.83,163.41 207.11,163.68 207.11,164.23 207.3,164.42 207.3,164.88 207.53,165.12 207.85,165.12 207.92,165.18 207.92,166.9 208.89,167.88 208.89,168.29 208.8,168.38 v3(208.54,168.38)
  LAY9 w0.089: v1(183.77,105.48) 184.06,105.77 184.06,106.67 184.28,106.89 184.28,107.11 184.06,107.33 184.06,108.49 183.33,109.22 183.33,110.03 184.08,110.78 184.08,112.22 185.04,113.17 185.04,114.5 185.77,115.24 185.77,118.93 186.64,119.8 186.64,120.72 185.74,121.61 185.74,122.56 186.6,123.41 186.6,124.82 185.86,125.56 185.86,126.74 186.6,127.48 186.6,128.62 185.78,129.44 185.78,130.45 184.94,131.3 184.94,135.83 192.03,142.93 192.03,145.5 190.74,146.8 190.74,149.36 204.19,162.82 204.19,163.13 204.48,163.42
M_DQS_B_DP<6>: length 103.3
  TOP w0.088: J1F3.267 174.16,100.29 174.3,100.14 174.52,100.14 174.61,100.23 174.61,101.08 173.84,102.91 173.84,103.72 173.31,104.25 173.31,104.86 173.57,105.12 v1(173.57,105.48) 173.57,105.49 173.84,105.77 173.84,106.35 174.05,106.55 175.14,106.55 175.23,106.64 175.23,106.97 175.13,107.07 174.06,107.07 173.81,107.32 173.81,108.57 174.04,108.79 174.04,109.03 J1F2.267
  TOP w0.165: v3(210.37,172.03) 209.91,172.49 J3D1.AK8
  LAY9 w0.088: 202.31,169.35 202.33,169.35 202.38,169.35 203.11,169.35 203.67,169.91 204.33,169.91 204.4,169.84 205.09,169.84 205.51,170.26 205.68,170.26 206.01,170.59 206.15,170.59 206.69,171.13 207.97,171.13 208.3,170.8 208.88,170.8 209.85,171.76 210.1,171.76 v3(210.37,172.03)
  LAY9 w0.089: 202.31,169.35 201.99,169.35 176.47,143.83 176.47,136.44 175.58,135.55 175.58,132.94 174.67,132.02 174.67,131.35 175.58,130.43 175.58,129.44 176.4,128.62 176.4,127.48 175.66,126.74 175.66,125.56 176.4,124.82 176.4,123.41 175.54,122.56 175.54,121.61 176.44,120.72 176.44,119.8 175.58,118.94 175.58,118.29 175.07,117.78 175.07,116.32 174.7,115.95 174.7,113.01 173.91,112.23 173.91,111.44 174.67,110.68 174.67,109.32 173.85,108.5 173.85,107.3 174.04,107.12 174.04,106.85 173.85,106.67 173.85,105.76 v1(173.57,105.48)
M_DQS_B_DP<7>: length 116.9
  TOP w0.088: J1F3.278 164.6,101.11 165.37,102.94 165.37,103.74 164.81,104.3 164.81,104.87 165.07,105.13 v1(165.07,105.48) 165.37,105.79 165.37,106 165.57,106.2 165.83,106.2 165.95,106.31 165.95,106.66 165.86,106.74 165.55,106.74 165.29,106.49 164.76,106.49 164.57,106.69 164.57,107.14 164.81,107.39 164.98,107.39 165.4,107.81 165.4,107.96 165.34,108.03 165.34,108.22 165.4,108.29 165.4,108.49 165.22,108.68 165.02,108.68 164.9,108.55 J1F2.278
  TOP w0.165: J3D1.AF8 v3(209.44,175.69)
  LAY9 w0.088: v3(209.44,175.69) 209.05,175.3 207.48,175.3 207.06,175.72 206.32,175.72 205.79,176.25 202.27,176.25
  LAY9 w0.089: v1(165.07,105.48) 165.36,105.78 165.36,106.8 165.54,106.98 165.54,107.24 165.38,107.41 165.38,108.49 166.23,109.35 166.23,110.29 165.32,111.2 165.32,112.15 166.27,113.1 166.27,113.72 165.68,114.3 164.54,114.3 164.34,114.5 164.34,115.57 164.54,115.77 165.67,115.77 165.78,115.89 165.78,116.52 165.33,116.97 165.33,118.89 166.24,119.8 166.24,120.72 165.34,121.61 165.34,122.56 166.2,123.41 166.2,124.82 165.46,125.56 165.46,126.74 166.2,127.48 166.2,128.62 165.38,129.44 165.38,130.45 164.52,131.31 164.52,133.12 164.24,133.41 164.24,138.73 164.9,139.39 165.43,139.39 165.56,139.52 165.56,141.67 199.8,175.92 201.48,175.92 201.81,176.25 202.27,176.25
M_DQS_B_DP<8>: length 94.2
  TOP w0.088: J1F3.197 238.76,100.29 238.9,100.14 239.12,100.14 239.21,100.23 239.21,101.08 238.44,102.91 238.44,103.72 237.91,104.25 237.91,104.86 238.17,105.12 v1(238.17,105.48) 238.17,105.49 238.44,105.77 238.44,106.35 238.65,106.55 239.74,106.55 239.83,106.64 239.83,106.97 239.73,107.07 238.66,107.07 238.41,107.32 238.41,108.57 238.64,108.79 238.64,109.03 J1F2.197 ; v3(229.05,172.95) J3D1.AJ27
  BOTTOM w0.088: v3(229.05,172.95) 228.71,172.79 228.46,172.54 228.46,169.16 228.22,168.92 226.94,168.92 226.59,168.57 226.59,167.93 226.68,167.84 226.68,165.34 226.42,165.08 226.42,164.69 226.3,164.57 226.3,163.3 227.04,162.56 227.04,154.24 228.41,152.87 228.41,137.68 233.62,132.46 233.76,132.46 234.17,132.06 234.17,131.73
  BOTTOM w0.165: 234.17,131.73 234.17,131.31 233.38,130.52 233.38,128.87 234.12,128.13 234.12,127.54 233.34,126.76 233.34,125.37 234.13,124.58 234.13,123.49 233.33,122.69 233.33,121.88 233.35,121.87 233.35,121.19 234.13,120.41 234.13,119.62 235.03,118.72 235.03,117.88 235.52,117.38 236.88,117.38 237.09,117.18 237.09,116.62 236.88,116.41 235.78,116.41 235.46,116.1 235.46,115.08 235.79,114.75 236.04,114.75 236.21,114.59 236.21,114.32 235.87,113.99 235.87,113.02 236.71,112.19 236.71,111.25 237.6,110.36 237.6,109.26 238.44,108.42 238.44,105.75 v1(238.17,105.48)
M_MAA_A<0>: length 57.1
  TOP w0.088: J1F1.79 211.37,123.88 211.66,125.1 211.66,125.43 211.37,125.72 211.37,126.82 212.22,127.67 212.22,127.84 212.06,128 212.06,128.08 211.37,128.76 211.37,130.57 211.81,131.01 211.81,131.21 J1E5.79 ; J3D1.AU18 221.21,165.15 221.21,164.76 220.9,164.45 220.9,163.94 220.66,163.69 220.66,162.04 220.75,161.95 220.75,161.46 220.95,161.26 220.95,158.06 220.05,157.16 220.05,156.65
  TOP w0.1: 212.22,127.84 212.32,127.94 212.32,128.5 211.84,128.98 211.84,129.52 211.57,129.79 211.57,130.36 212.16,130.95 212.16,131.84
  TOP w0.215: 220.05,156.65 220.05,156.65 220.05,152.09 213.57,145.61 213.57,137.61 213.4,137.44 213.19,137.44 213.05,137.58 213.05,140.21 212.9,140.36 212.68,140.36 212.53,140.21 212.53,136.57 212.16,136.19 212.16,131.84
M_MAA_A<1>: length 55.5
  TOP w0.088: 227.45,162.2 227.23,161.93 227.23,161.85 226.92,161.53 226.92,158.4 225.96,157.45 225.96,157.19 ; J1E5.72 222.69,129.64 222.69,129.52 222.58,129.41 222.26,129.41 222.16,129.32 222.16,129.18 222.27,129.08 222.59,129.08 222.77,128.9 222.77,128.25 222.63,128.12 222.63,127.59 223.03,127.19 223.03,126.68 223.06,126.65 223.06,126.09 222.75,125.34 222.75,124.38 222.61,124 222.61,123.62 222.71,123.52 222.71,123.12 222.42,122.28 J1F1.72
  TOP w0.089: 227.45,162.2 J3D1.AY25
  TOP w0.1: 223.03,126.68 222.94,126.68 222.43,127.19 222.43,128.54 221.77,129.2 221.77,130.54 220.92,131.39 220.92,132.01 221.15,132.24
  TOP w0.215: 221.15,132.24 221.33,132.42 222.09,132.42 222.39,132.72 222.39,137.21 222.7,137.52 222.7,139.31 222.55,139.46 222.34,139.46 222.18,139.3 222.18,137.96 222.01,137.79 221.79,137.79 221.66,137.93 221.66,144.1 221.81,144.26 222.71,144.26 222.86,144.41 222.86,144.62 222.7,144.78 221.81,144.78 221.66,144.93 221.66,145.29 225.55,149.19 225.96,149.6 225.96,157.19
M_MAA_A<2>: length 55.3
  TOP w0.088: 225.44,157.19 225.44,157.48 226.52,158.57 226.52,161.7 226.8,161.97 226.8,162.36 J3D1.AY24 ; J1E5.216 222.01,125.85 222.01,124.92 222.41,124.52 222.41,123.33 221.67,122.59 221.67,122.16 222.42,119.78 222.42,118.48 J1F1.216
  TOP w0.1: 221.67,122.59 221.54,122.71 221.54,122.93 222.2,123.59 222.2,124.18 221.55,124.82 221.55,126.92 222.22,127.58 222.22,128.13 221.38,128.98 221.38,130.31 221.37,130.32 221.37,130.33 220.84,130.86 220.84,131.06 220.65,131.25 220.65,131.56 220.55,131.67 220.55,132.23
  TOP w0.215: 220.55,132.23 220.55,132.25 220.95,132.66 220.95,136.13 221.1,136.28 221.6,136.28 221.76,136.44 221.76,136.65 221.6,136.81 221.1,136.81 220.95,136.96 220.95,137.36 221.14,137.55 221.14,140.7 220.98,140.85 220.4,140.85 220.23,141.02 220.23,141.24 220.37,141.37 220.98,141.37 221.14,141.52 221.14,145.51 225.44,149.81 225.44,157.19
M_MAA_A<3>: length 54.6
  TOP w0.088: J1E5.71 222.8,131.66 222.66,131.52 222.66,131.36 223.27,130.75 223.27,129.41 223.97,128.71 223.97,128.4 223.91,128.34 223.91,128.25 ; 223.91,128.25 223.83,128.25 223.74,128.35 ; 223.91,128.25 223.91,127.64 223.42,126.87 223.26,126.45 223.26,125.98 223.14,125.31 223.14,124.32 223.27,123.88 J1F1.71 ; 226.48,157.19 226.48,157.41 227.31,158.24 227.31,161.37 227.63,161.68 227.63,161.78 227.97,162.27 227.97,162.61 227.64,162.95
  TOP w0.089: 227.64,162.95 J3D1.AW25
  TOP w0.1: 223.74,128.35 222.99,129.09 222.99,129.71 223.07,129.92 223.07,130.33 222.71,130.69 222.55,130.69 222.23,131.01 222.23,131.76 222.7,132.23
  TOP w0.215: 222.7,132.23 222.93,132.46 222.93,137.02 223.25,137.34 223.25,139.91 223.09,140.06 222.36,140.06 222.21,140.21 222.21,143.28 222.34,143.42 222.56,143.42 222.73,143.25 222.73,140.91 222.87,140.77 223.08,140.77 223.25,140.93 223.25,143.82 226.78,147.36 226.78,148.32 226.48,148.62 226.48,157.19
M_MAA_A<4>: length 55.4
  TOP w0.088: J1E5.214 223.83,125.84 223.83,124.72 224.11,124.27 224.11,123.2 223.46,122.56 223.45,122.56 223.45,122.14 224.12,119.75 224.12,118.5 J1F1.214 ; 227.64,163.89 227.96,163.57 227.96,163.06 228.19,162.83 228.19,162.08 228.02,161.91 228.02,161.59 228.02,161.58 228.02,161.52 227.7,161.2 227.7,158.08 227,157.37 227,157.19
  TOP w0.089: J3D1.AV25 227.64,163.89
  TOP w0.1: 223.62,132.3 223.93,131.99 223.93,131.39 223.69,131.15 223.69,130.54 223.47,130.33 223.47,129.79 224.23,129.03 224.23,128.37 224.11,128.25 224.11,127.18 223.58,126.65 223.47,126.42 223.47,124.61 223.9,124.18 223.9,123.59 223.55,123.24 223.07,123.24 222.97,123.14 222.97,122.65 223.06,122.56 223.45,122.56
  TOP w0.215: 223.62,132.3 223.52,132.4 223.52,136.27 224.21,136.96 224.21,137.2 223.77,137.64 223.77,143.43 227.6,147.25 227.6,147.61 227.31,147.9 227.31,148.13 227.43,148.25 227.43,148.48 227,148.91 227,157.19
M_MAA_A<5>: length 54.2
  TOP w0.088: J3D1.AY26 228.55,162.13 228.41,161.88 228.41,161.42 228.41,161.42 228.41,161.36 228.1,161.04 228.1,157.91 227.52,157.34 227.52,157.19 ; J1E5.213 225.21,127.42 225.21,127.31 225.11,127.21 224.75,127.21 224.68,127.15 224.68,127.01 224.77,126.93 224.91,126.93 224.98,126.87 224.98,125.65 224.79,124.67 224.43,124.31 224.31,124.19 224.31,123.77 224.97,121.84 224.97,120.09 J1F1.213
  TOP w0.1: 224.43,124.31 224.32,124.42 224.17,124.69 224.17,125.39 224.77,125.98 224.77,126.46 224.42,127.01 224.42,127.3 224.32,127.72 224.32,128.13 224.61,128.42 224.61,129.62 224.77,129.78 224.77,130.33 224.42,130.68 224.3,130.68 224.19,130.79 224.19,131.12 224.3,131.23 224.3,132.23
  TOP w0.215: 224.3,132.23 224.3,132.37 224.14,132.53 224.14,136.15 225.33,137.34 225.33,138.81 225.15,138.99 224.93,138.99 224.81,138.86 224.81,137.86 224.66,137.71 224.44,137.71 224.29,137.86 224.29,143.21 225.32,144.24 225.65,144.24 226.05,144.64 226.05,144.98 228.12,147.04 228.12,148.54 227.52,149.14 227.52,157.19
M_MAA_A<6>: length 56.9
  TOP w0.088: 228.04,157.19 228.04,157.3 228.49,157.75 228.49,160.87 228.81,161.19 228.81,161.78 228.9,161.87 228.9,162.62 228.65,162.87 228.51,162.87 228.23,163.16 228.23,163.69 228.55,164.02 ; J1F1.69 224.97,123.88 225.32,125.62 225.32,125.86 225.18,126 225.18,126.36 225.61,127.7 225.61,128.14 225.55,128.33 225.42,128.33 225.26,128.49 225.09,128.49 224.98,128.61 224.98,128.87 225.05,128.95 225.05,129.1 224.97,129.19 224.97,130.41 225.07,130.5 225.07,130.62 224.99,130.7 224.79,130.7 224.7,130.79 224.7,130.93 224.78,131.01 225.08,131.01 225.16,131.09 225.16,131.15 J1E5.69
  TOP w0.089: 228.55,164.02 J3D1.AV26
  TOP w0.1: 225.55,128.33 225.55,128.68 225.34,128.89 225.34,129.58 225.17,129.82 225.17,130.25 225.4,130.6 225.4,131.13 225.62,131.35 225.62,132.02 225.38,132.26
  TOP w0.215: 225.38,132.26 224.88,132.76 224.88,136.16 225.85,137.13 225.85,142.58 225.68,142.75 225.47,142.75 225.33,142.61 225.33,139.67 225.17,139.51 224.95,139.51 224.81,139.65 224.81,142.99 225.37,143.56 225.68,143.56 225.94,143.3 226.31,143.3 226.93,143.92 226.93,145.12 228.64,146.82 228.64,148.76 228.04,149.36 228.04,157.19
M_MAA_A<7>: length 54.3
  TOP w0.088: 229.08,157.12 229.08,157.23 229.27,157.42 229.27,160.55 229.59,160.86 229.59,161.45 229.59,161.45 229.59,162.31 J3D1.AY27 ; J1F1.211 226.67,120.08 226.47,121.47 226.47,122.41 226.01,123.77 226.01,124.2 226.13,124.32 226.05,124.4 226.05,124.54 226.66,125.71 226.66,126.63 227,126.97 227,127.1 226.9,127.2 226.57,127.2 226.47,127.3 226.47,127.41 J1E5.211
  TOP w0.1: 226.13,124.32 226.25,124.44 226.31,124.44 226.5,124.63 226.95,125.49 226.95,125.93 226.87,126.13 226.87,126.53 227.22,126.87 227.22,127.48 227.32,127.58 227.32,128.16 226.74,128.74 226.74,129.46 226.67,129.52 226.67,130.74 226.02,131.39 226.02,131.93 226.47,132.37 226.87,132.37 227.22,132.72
  TOP w0.215: 227.22,132.72 227.22,136.22 227.97,136.98 227.97,140.3 227.82,140.45 227.08,140.45 226.93,140.6 226.93,142.44 227.08,142.59 227.3,142.59 227.45,142.44 227.45,141.39 227.58,141.26 227.8,141.26 227.97,141.44 227.97,144.69 229.68,146.39 229.68,149.19 229.08,149.79 229.08,157.12
M_MAA_A<8>: length 54.7
  TOP w0.088: J1F1.68 225.82,122.28 225.62,123.56 225.62,124.4 226.46,126.08 226.46,126.54 226.45,126.67 226.34,126.67 226.2,126.81 226.16,126.81 225.81,127.16 225.81,128.21 225.94,128.58 225.94,128.68 225.75,128.88 225.75,129.01 225.81,129.08 226.06,129.08 226.15,129.16 226.15,129.34 226.07,129.41 225.76,129.41 225.68,129.49 225.68,129.58 J1E5.68 ; 228.56,157.14 228.56,157.27 228.88,157.59 228.88,160.71 229.2,161.03 229.2,161.61 229.2,161.61 229.2,162.14 229.13,162.22 229.13,162.65 229.47,162.99 J3D1.AW27
  TOP w0.1: 226.45,126.67 226.45,126.96 226.17,127.23 226.17,127.4 226.02,127.7 226.02,128.13 226.36,128.47 226.36,129.67 226.47,129.77 226.47,130.34 225.82,130.98 225.82,132.08 225.83,132.08 225.83,132.23
  TOP w0.215: 228.56,157.14 228.56,149.57 229.16,148.97 229.16,146.6 227.45,144.9 227.45,143.7 226.41,142.66 226.41,137.7 226.56,137.55 226.78,137.55 226.93,137.7 226.93,139.75 227.07,139.89 227.29,139.89 227.45,139.73 227.45,137.26 225.4,135.21 225.4,134.52 225.83,134.1 225.83,132.23
M_MAA_A<9>: length 53.7
  TOP w0.088: J3D1.AY28 230.38,162.43 230.38,160.69 230.38,160.68 230.38,160.54 230.06,160.22 230.06,157.25 230.12,157.19 230.12,157.07 ; J1E5.66 227.89,129.69 227.89,129.51 227.79,129.41 227.5,129.41 227.41,129.32 227.41,129.14 227.5,129.05 227.8,129.05 227.9,128.95 227.9,128.29 227.73,128.12 227.73,127.59 228.19,127.12 228.19,126.87 228.38,126.68 228.38,125.66 227.71,124.03 227.71,122.83 227.52,122.28 J1F1.66
  TOP w0.1: 228.38,126.68 228.57,126.88 228.57,127.13 229.02,127.58 229.02,128.13 228.11,129.04 228.11,129.75 228.17,129.81 228.17,130.35 227.52,131 227.52,132.06 228.02,132.56 228.23,132.56 228.36,132.69 228.36,132.91
  TOP w0.215: 230.12,157.07 230.12,150.22 230.72,149.62 230.72,144.48 229.02,142.78 229.02,137.67 229.16,137.53 229.38,137.53 229.54,137.69 229.54,139.81 229.7,139.97 229.92,139.97 230.06,139.84 230.06,137.37 228.36,135.67 228.36,132.91
M_MAA_A<10>: length 60.1
  TOP w0.088: J3D1.AU17 220.32,164.97 220.7,164.59 220.7,164.11 220.35,163.76 220.2,163.76 219.99,163.55 219.99,162.99 219.74,162.74 219.74,162.28 219.69,162.23 219.69,161.38 219.93,161.14 219.93,161 220.01,160.92 220.01,158.24 219.01,157.24 219.01,156.27 ; J1E5.225 209.27,127.46 209.27,127.3 209.4,127.18 209.76,127.18 209.83,127.11 209.83,126.87 209.66,126.7 209.66,124.94 210.17,124.44 210.29,124.44 210.29,123.58 210.02,123.31 209.67,121.72 209.67,120.1 J1F1.225
  TOP w0.1: 210.82,132.6 210.52,132.3 210.52,130.98 209.87,130.34 209.87,129.77 210.32,129.33 210.32,128.86 210.2,128.74 210.2,128.5 210.32,128.39 210.32,126.97 209.87,126.53 209.87,125.99 210.02,125.85 210.02,125.2 210.4,124.82 210.4,124.53 210.31,124.44 210.29,124.44
  TOP w0.215: 210.82,132.6 210.82,133.2 211.06,133.44 211.06,136.57 211.49,137 211.49,145 211.65,145.16 211.87,145.16 212.01,145.02 212.01,143.15 212.16,143.01 212.37,143.01 212.53,143.16 212.53,145.33 212.33,145.53 212.33,145.83 219.01,152.52 219.01,156.27 219.01,156.27
M_MAA_A<11>: length 55.8
  TOP w0.088: J1E5.210 227.51,126.24 227.39,125.79 227.39,124.9 227.23,124.74 227.08,124.74 226.98,124.64 226.98,124.5 227.29,124.18 227.29,123.59 226.92,123.21 226.85,123.21 226.75,123.11 226.75,122.82 226.87,122.71 226.85,122.69 226.85,122.22 227.52,119.77 227.52,118.48 J1F1.210 ; 229.47,163.92 229.8,163.59 229.8,162.85 229.99,162.66 229.99,160.85 229.99,160.85 229.99,160.7 229.67,160.38 229.67,157.27 229.6,157.1
  TOP w0.089: 229.47,163.92 J3D1.AV27
  TOP w0.1: 227.77,132.79 227.77,132.7 227.23,132.16 227.23,132.02 227.32,131.93 227.32,131.38 227.12,131.19 227.12,130.58 226.87,130.33 226.87,129.79 227.09,129.57 227.09,128.92 227.53,128.49 227.53,127.37 227.63,127.26 227.63,127.07 228.17,126.54 228.17,126.01 227.5,124.27 227.5,123.35 227.18,122.89 227,122.71 226.87,122.71
  TOP w0.215: 227.77,132.79 227.77,136.03 228.49,136.76 228.49,143 229.52,144.02 229.52,144.24 229.37,144.39 229.15,144.39 228.98,144.22 228.77,144.22 228.61,144.37 228.61,144.59 229.15,145.13 229.37,145.13 229.89,144.61 230.1,144.61 230.2,144.7 230.2,149.41 229.6,150 229.6,157.1
M_MAA_A<12>: length 55
  TOP w0.088: 230.38,163.93 230.04,163.6 230.04,163.16 230.24,162.96 230.53,162.96 230.71,162.77 230.71,162.73 230.72,162.73 230.72,161.95 230.77,161.89 230.77,160.37 230.46,160.06 230.46,157.47 230.64,157.29 230.64,157.07 ; J1E5.65 228.28,131.24 228.28,131.11 228.38,131.01 228.72,131.01 228.86,130.88 228.86,130.6 228.58,130.32 228.58,129.79 228.96,129.41 229.18,129.41 229.34,129.25 229.34,128.36 229.22,128.24 229.22,127.47 228.58,126.46 228.58,126.06 228.7,125.88 228.7,125.73 228.37,123.88 J1F1.65
  TOP w0.089: 230.38,163.93 J3D1.AV28
  TOP w0.1: 229.23,128.24 229.06,128.41 229.06,128.7 228.38,129.38 228.38,130.62 227.97,131.02 227.97,131.14 227.72,131.39 227.72,131.97 228.09,132.34 228.69,132.34 228.9,132.54 228.9,132.81
  TOP w0.215: 228.9,132.81 228.9,135.16 230.64,136.9 230.64,142.11 230.49,142.26 230.27,142.26 230.12,142.11 230.12,141.3 229.97,141.14 229.75,141.14 229.6,141.3 229.6,142.63 229.75,142.78 230.49,142.78 230.64,142.93 230.64,143.14 230.8,143.31 231.02,143.31 231.49,142.84 231.7,142.84 231.85,142.99 231.85,143.21 231.39,143.67 231.39,143.89 232.44,144.94 232.44,148.64 230.64,150.43 230.64,157.07
M_MAA_A<13>: length 57
  TOP w0.088: 215,156.44 215,156.56 215.74,157.31 215.74,158.49 216.25,159 216.25,160.54 217.24,161.53 217.24,162.62 217.58,162.96 J3D1.AW14 ; J1E5.232 205.41,124.57 205.41,123.43 205.27,123.28 205.27,123.06 204.95,122.75 204.78,122.75 204.76,122.73 204.76,121.66 203.72,119.99 203.72,118.48 J1F1.232
  TOP w0.1: 204.78,122.75 204.78,123.16 205.2,123.59 205.2,124.18 204.83,124.55 204.14,124.9 203.07,125.96 203.07,126.63 203.52,127.54 203.52,128.25 204.37,129.87 204.37,130.31 203.92,131.39 203.92,132.17 203.99,132.23
  TOP w0.215: 215,156.44 215,154.68 204.9,144.59 204.9,141.37 204.36,140.83 204.36,136.08 204.18,135.9 204.18,132.42 203.99,132.23
M_MAA_A<14>: length 59.7
  TOP w0.088: 217.45,156.1 217.45,156.23 217.71,156.49 217.71,157.63 218.6,158.52 218.6,160.23 218.78,160.41 218.78,162.17 218.83,162.22 218.83,163.03 218.94,163.14 219.2,163.14 J3D1.AW16 ; J1F1.228 207.12,118.48 207.31,119.03 207.31,120.39 207.78,120.85 207.78,122.76 207.59,122.94 207.59,123.34 207.31,123.62 207.31,124.15 207.62,124.46 207.62,124.81 207.29,125.14 207.29,125.42 207.6,125.73 207.6,126.11 207.45,126.26 J1E5.228
  TOP w0.1: 207.78,122.76 208.09,123.01 208.5,122.97 208.63,123.07 208.63,124.46 208.53,124.56 208.2,124.56 208.04,124.71 208.04,125.05 207.87,125.22 207.87,125.38 207.98,125.49 207.98,125.64 207.87,125.75 207.87,126.51 206.92,127.46 206.92,128.9 207.77,129.75 207.77,130.51 208.62,131.36 208.62,132.15
  TOP w0.215: 217.45,156.1 217.45,153.17 210.14,145.86 209.65,145.86 208.4,144.61 208.4,140.81 208.58,140.62 208.58,140.17 208.4,139.99 208.4,139.68 208.55,139.52 208.73,139.52 208.88,139.37 208.88,139.16 208.73,139 208.55,139 208.4,138.85 208.4,138.64 208.55,138.48 208.73,138.48 208.88,138.33 208.88,138.11 208.73,137.96 208.55,137.96 208.4,137.81 208.4,137.59 208.55,137.44 208.73,137.44 208.88,137.29 208.88,136.69 209.24,136.34 209.31,136.34 209.46,136.19 209.46,135.98 209.31,135.82 209.24,135.82 209.08,135.67 209.08,135.45 209.24,135.3 209.31,135.3 209.46,135.15 209.46,134.93 209.31,134.78 209.24,134.78 209.08,134.63 209.08,132.76 208.62,132.29 208.62,132.15
M_MAA_A<15>: length 61.5
  TOP w0.088: J1E5.86 206,129.48 206,129.33 205.22,128.55 205.22,127.03 204.77,126.57 204.77,125.97 205.61,125.12 205.61,122.73 205.42,122.28 J1F1.86 ; 215.99,156.31 215.99,156.44 216.53,156.98 216.53,158.16 217.19,158.82 217.19,160.45 217.9,161.16 217.9,162.19 217.92,162.2 217.92,163.67 218.16,163.91 218.16,164.47 218.34,164.65 219.17,165 J3D1.AU16
  TOP w0.1: 204.77,126.46 204.47,126.46 203.92,127 203.92,128.13 204.77,128.98 204.77,130.21 205.26,131.35 205.26,132.23
  TOP w0.215: 205.26,132.23 205.26,135.34 205.5,135.78 205.89,136.17 205.89,140.16 206.05,140.32 206.26,140.32 206.42,140.16 206.42,137.16 206.56,137.02 206.78,137.02 206.94,137.18 206.94,145.22 215.99,154.27 215.99,156.31
M_MAA_A<16>: length 59.6
  TOP w0.088: J1F1.82 208.82,122.28 209.01,123.26 209.01,124.51 208.15,126.15 208.15,126.71 208.19,126.71 208.61,127.12 208.61,128.12 208.11,128.63 208.11,128.98 208.33,129.21 208.51,129.21 208.82,129.52 J1E5.82 ; 217.97,156.07 217.97,156.19 218.11,156.33 218.11,157.45 219.07,158.42 219.07,162.68 219.28,162.89 219.48,162.89 219.75,163.16 219.75,163.54 219.64,163.65 219.64,163.82 219.41,164.05 J3D1.AV16
  TOP w0.1: 209.6,132.84 209.6,132.56 209.02,131.98 209.02,131.19 208.17,130.34 208.17,129.59 207.58,129 207.58,128.39 207.32,128.13 207.32,127.59 207.97,126.94 207.97,126.81 208.07,126.71 208.15,126.71
  TOP w0.215: 209.6,132.84 209.6,133.45 210.02,133.87 210.02,136.37 209.41,136.98 209.41,140.96 209.25,141.11 209.07,141.11 208.92,141.26 208.92,141.48 209.07,141.63 209.25,141.63 209.41,141.78 209.41,142 209.25,142.15 209.07,142.15 208.92,142.3 208.92,142.52 209.07,142.67 209.25,142.67 209.41,142.82 209.41,143.04 209.25,143.19 209.07,143.19 208.92,143.34 208.92,143.56 209.07,143.71 209.25,143.71 209.41,143.87 209.41,144.88 209.57,145.05 209.78,145.05 209.93,144.91 209.93,142.82 210.08,142.66 210.29,142.66 210.45,142.82 210.45,145.43 217.97,152.95 217.97,156.07
M_MAA_B<0>: length 85.5
  TOP w0.088: v3(221.69,168.38) J3D1.AP19
  LAY3 w0.088: J1F3.79 211.63,104.57 212,104.94 212,105.43 212.12,105.54 212.12,106.19 211.93,106.38 211.69,106.38 211.52,106.55 211.52,108.44 211.84,108.76 211.84,108.99 212.06,109.21 212.06,110.2 211.81,110.44 211.2,110.44 211.1,110.54 211.1,110.79 211.37,111.06 J1F2.79 ; v3(221.69,168.38) 221.53,168.21 221.53,164.71 221.05,164.23 221.05,159.67 219.95,158.56 219.95,158.01
  LAY3 w0.1: 211.84,108.76 212.14,108.76 212.45,109.07 212.45,111.05 212.32,111.18 211.98,111.18 211.57,111.59 211.57,112.13 211.97,112.53 212.16,112.53 212.28,112.65 212.28,113.22
  LAY3 w0.165: 212.64,114.18 212.63,114.18 212.34,113.89 212.34,113.88 212.29,113.82 212.29,113.22 212.28,113.22
  LAY3 w0.2: 212.64,114.18 212.87,114.4 212.87,116.83 211.5,118.2 211.5,118.77 212.35,119.62 212.35,121.13 211.52,121.97 211.52,121.98 211.5,122 211.5,122.57 211.91,122.98 212.15,122.98 212.35,123.18 212.35,125.34 212.13,125.56 211.93,125.56 211.52,125.97 211.52,126.55 211.93,126.96 212.17,126.96 212.37,127.16 212.37,128.14 212.37,128.15 212.37,128.92 211.52,129.77 211.52,130.35 211.93,130.76 212.17,130.76 212.75,131.33 212.75,133.17 213.39,133.81 213.39,134.59 213.92,135.12 213.92,136.34 213.53,136.73 213.53,142.96 213.69,143.12 213.89,143.12 214.03,142.98 214.03,140.88 214.19,140.72 214.39,140.72 214.53,140.86 214.53,145.96 219.95,151.38 219.95,158.01
M_MAA_B<1>: length 88.6
  TOP w0.088: v3(222.61,168.38) J3D1.AP20
  LAY3 w0.088: J1F3.72 222.42,102.97 222.61,103.8 222.61,107.19 223.06,107.85 223.06,108.34 222.95,108.45 223.1,108.59 223.1,108.92 222.63,109.39 222.63,109.92 222.77,110.06 222.77,110.34 222.14,110.97 222.14,111.23 221.78,111.59 221.78,112.13 221.95,112.3 221.95,112.43 221.87,112.51 221.87,112.67 221.93,112.74 222.08,112.74 222.42,112.4 J1F2.72 ; v3(222.61,168.38) 222.61,168.12 223.03,167.7 223.03,165.3 223.33,165.01 223.33,163.31 223.92,162.17 224.13,161.67 224.24,161.19 225.71,159.43 225.71,158.81
  LAY3 w0.1: 221.16,114.04 220.92,113.8 220.92,113.13 221.58,112.47 221.58,110.96 222.43,110.11 222.43,108.98 222.95,108.45
  LAY3 w0.2: 225.71,158.81 225.71,148.27 224.52,147.09 224.52,146.24 224.38,146.09 223.51,146.09 223.37,145.95 223.37,145.74 223.52,145.59 224.32,145.59 224.52,145.39 224.52,145.01 224.37,144.86 224.02,144.86 223.88,144.72 223.88,144.51 224.03,144.36 224.32,144.36 224.52,144.16 224.52,139.62 223.69,138.79 223.69,135.13 223.66,135.09 223.19,135.09 223.19,137.37 223.05,137.51 222.84,137.51 222.69,137.36 222.69,134.81 221.06,133.18 221.06,132.7 221.22,132.53 221.22,132.39 220.87,132.04 220.87,131.37 220.96,131.28 220.96,131.04 220.67,130.76 220.43,130.76 220.02,130.35 220.02,129.77 221.09,128.7 221.09,128.36 220.87,128.15 220.87,127.16 220.67,126.96 220.43,126.96 220.02,126.55 220.02,125.97 220.43,125.56 220.63,125.56 220.85,125.34 220.85,123.18 220.65,122.98 220.41,122.98 220,122.57 220,122 220.02,121.98 220.02,121.97 220.85,121.13 220.85,119.62 220,118.77 220,118.2 220.18,118.02 220.18,115.96 221.23,114.91 221.23,114.11 221.16,114.04
M_MAA_B<2>: length 87.8
  TOP w0.088: v3(222.61,166.55) J3D1.AR20
  LAY3 w0.088: J1F3.216 222.42,99.17 222.43,99.18 222.43,101.35 222.27,101.5 221.52,101.5 221.41,101.6 221.41,101.78 221.52,101.88 222.1,101.88 222.2,101.99 222.2,102.19 222.1,102.28 221.8,102.28 221.65,102.43 221.65,103.33 221.9,103.57 221.9,103.97 222.21,104.28 222.21,106.93 222.13,107.01 221.92,107.01 221.83,107.1 221.83,107.26 221.92,107.35 222.11,107.35 222.19,107.44 222.19,107.63 J1F2.216 ; v3(222.61,166.55) 222.61,166.23 222.17,165.8 222.17,165.46 222.45,165.19 222.74,165.19 223.03,164.89 223.03,163.17 223.4,162.52 223.87,161.43 223.93,161.08 225.21,159.42 225.21,158.81
  LAY3 w0.1: 220.28,114.17 220.52,113.93 220.52,113.73 220.72,113.52 220.72,113.04 220.94,112.83 220.94,112.57 221.37,112.14 221.37,111.59 221.21,111.43 221.21,110.6 221.5,110.31 221.85,110.31 222.22,109.94 222.22,109.38 221.72,108.89 221.72,108.03 221.48,107.78 221.48,105.45 220.91,104.88 220.91,104.07 221.65,103.33
  LAY3 w0.2: 220.28,114.17 220.01,114.43 220.01,115.09 219.64,115.47 219.64,118.14 219.7,118.2 219.7,118.95 220.55,119.8 220.55,120.37 219.7,121.22 219.7,122.95 219.94,123.19 220.14,123.19 220.55,123.6 220.55,124.17 219.6,125.13 219.6,125.85 219.72,125.97 219.72,126.94 219.94,127.16 220.16,127.16 220.57,127.57 220.57,128.15 219.6,129.11 219.6,129.66 219.72,129.77 219.72,130.7 219.98,130.96 220.16,130.96 220.57,131.37 220.57,132.23 220.4,132.39 220.4,133.27 221.1,133.96 221.1,135.44 222.19,136.54 222.19,138.96 222.34,139.11 222.55,139.11 222.69,138.97 222.69,138.17 222.85,138.01 223.05,138.01 223.19,138.15 223.19,139.06 224.02,139.88 224.02,143.63 222.61,145.04 222.61,145.93 225.21,148.52 225.21,158.81
M_MAA_B<3>: length 90.3
  TOP w0.088: v3(222.61,170.2) J3D1.AM20
  LAY3 w0.088: v3(222.61,170.2) 222.61,169.9 223.05,169.46 223.05,168.25 223.35,167.95 223.35,165.36 223.62,165.09 223.62,163.41 224.13,162.43 224.22,162.27 224.41,161.81 224.61,161.25 226.21,159.37 226.21,158.81 ; J1F3.71 223.27,104.57 223.08,105.16 223.08,107.06 223.26,107.75 223.26,108.42 223.91,109.46 223.91,110.42 223.27,111.06 223.27,112.66 223.16,112.76 223.05,112.76 222.63,113.18 222.63,114.16 222.74,114.27 222.94,114.27 223.28,113.94 223.28,113.47 J1F2.71
  LAY3 w0.1: 222.22,114.43 222.22,113.12 222.8,112.54 222.8,112.4 223.07,112.13 223.07,111.59 222.83,111.36 222.83,110.78 223.3,110.31 223.55,110.31 223.72,110.13 223.91,110.13
  LAY3 w0.2: 226.21,158.81 226.21,149.04 226.53,148.71 226.53,147.36 226.02,146.86 226.02,142.34 225.88,142.2 225.68,142.2 225.52,142.36 225.52,146.81 225.38,146.95 225.17,146.95 225.02,146.8 225.02,139.27 224.34,138.59 224.34,135.01 222.03,132.69 222.03,132.19 222.27,131.95 222.27,131.37 221.86,130.96 221.68,130.96 221.42,130.7 221.42,129.77 221.3,129.66 221.3,129.11 222.27,128.15 222.27,127.57 221.86,127.16 221.64,127.16 221.42,126.94 221.42,125.97 221.3,125.85 221.3,125.13 222.25,124.17 222.25,123.6 221.84,123.19 221.64,123.19 221.4,122.95 221.4,121.22 222.25,120.37 222.25,119.8 221.4,118.95 221.4,118.2 221.03,117.83 221.03,117.39 221.15,117.27 221.15,115.74 222.22,114.67 222.22,114.43
