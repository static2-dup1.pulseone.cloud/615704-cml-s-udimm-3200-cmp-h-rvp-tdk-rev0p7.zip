# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M.2_SSD_P0_TX_DP: length 160.7
  TOP w0.088: 116.15,135.81 116.15,135.83 116.16,135.83 116.16,135.89 116.16,135.9 116.16,136.41 114.45,138.12 113.57,138.12 U6E1.B42
  TOP w0.1: v1(115.64,103.47) 115.94,103.17 116.48,103.17 122.35,109.05 122.35,116.25 121.33,117.26 121.33,119.59 124.03,122.28 124.03,127.07 123.61,127.48 121.27,127.48 118.16,130.6 118.16,132.38 116.15,134.39 116.15,135.81 ; v1(29.5,51.39) 29.8,51.68 29.8,51.97 29.7,52.07 C8H9.1
  BOTTOM w0.1: v1(29.5,51.39) 29.73,51.61 29.73,53.64 32.93,56.84 43.25,56.84 45.92,59.51 48.58,59.51 49.14,60.07 51.27,60.07 55.28,64.08 56.35,64.08 58.48,66.21 59.07,66.21 60.62,67.76 61.79,67.76 64.77,70.75 76.81,70.75 77.75,71.69 80.49,71.69 81.31,70.86 87.72,70.86 92.89,76.03 92.89,77.69 92.94,77.75 97.44,82.24 97.93,82.24 102.18,86.48 102.18,87.24 105.94,91 106.98,91 114.04,98.06 114.04,102.1 115.12,103.17 115.34,103.17 v1(115.64,103.47)
M.2_SSD_P1_RX_DN: length 162.6
  TOP w0.1: R8H18.1 35.21,53.85 35.11,53.75 35.11,53.09 35.21,52.99 v1(35.45,52.99) ; U6E1.P41 107.61,138.93 107.71,139.03 108,139.03 108.16,138.88 v1(108.16,138.78)
  BOTTOM w0.089: v1(108.16,138.78) 108.05,138.89 108.05,139.04 108.2,139.19 108.37,139.19 108.96,138.6 108.96,138.5 109.14,138.32 109.14,138.12 109.29,137.96 109.29,135.97 109,135.68
  BOTTOM w0.1: 109,135.68 108.96,135.64 108.96,135.63 108.33,135 108.33,131.79 108.86,131.26 108.86,128.92 117.27,120.52 117.27,111.45 117.77,110.95 117.77,108.56 119,107.34 119,97.29 108.26,86.56 107.98,86.56 104.62,83.2 104.62,82.43 103.09,80.9 102.32,80.9 100.63,79.21 100.63,74.63 92.5,66.49 82.16,66.49 81.15,65.48 76.83,65.48 75.61,66.7 66.89,66.7 66.52,66.32 66.52,65.28 65.45,64.22 65.45,63.05 63.62,61.21 60.16,61.21 57.2,58.25 57.2,57.1 54.83,54.74 52.8,54.74 48.86,50.8 43.02,50.8 41.7,49.47 36.88,49.47 35.12,51.23 35.12,52.89 35.22,52.99 v1(35.45,52.99)
M.2_SSD_P1_RX_DP: length 162.6
  TOP w0.1: R8H17.1 34.91,53.61 34.91,53.25 v1(34.65,52.99) ; U6E1.R40 v1(107.85,139.51)
  BOTTOM w0.089: 109.11,135.49 109.19,135.58 109.19,135.6 109.48,135.89 109.48,138.04 109.33,138.19 109.33,138.4 109.15,138.58 109.15,138.68 108.45,139.38 107.97,139.38 v1(107.85,139.51)
  BOTTOM w0.1: v1(34.65,52.99) 34.92,52.72 34.92,51.15 36.8,49.27 41.78,49.27 43.1,50.6 48.94,50.6 52.88,54.54 54.91,54.54 57.4,57.02 57.4,58.16 60.25,61.01 63.7,61.01 65.65,62.97 65.65,64.13 66.72,65.2 66.72,66.24 66.97,66.5 75.53,66.5 76.75,65.28 81.23,65.28 82.25,66.29 92.58,66.29 100.83,74.55 100.83,79.13 102.4,80.7 103.17,80.7 104.82,82.35 104.82,83.12 108.06,86.36 108.35,86.36 119.2,97.21 119.2,107.42 117.97,108.64 117.97,111.03 117.47,111.53 117.47,120.6 109.06,129.01 109.06,131.34 108.53,131.88 108.53,134.91 109.11,135.49
M.2_SSD_P1_RX_R_DN: length 2.6
  TOP w0.1: J8H1.29 35.52,56.17 35.37,56.02 35.37,55.75 35.15,55.53 35.15,55.01 R8H18.2
M.2_SSD_P1_RX_R_DP: length 2.6
  TOP w0.1: J8H1.31 35.02,56.17 35.17,56.02 35.17,55.83 34.95,55.61 34.95,55.02 R8H17.2
M.2_SSD_P1_TX_C_DN: length 1.3
  TOP w0.1: C8H12.2 33.46,53.28 33.46,53.76 R8H16.1
M.2_SSD_P1_TX_C_DP: length 1.3
  TOP w0.1: R8H10.2 33.26,53.86 33.26,53.33 C8H11.2
M.2_SSD_P1_TX_CMC_DN: length 2.8
  TOP w0.1: R8H16.2 33.5,54.79 33.5,55.51 33.87,55.88 33.87,56.02 34.02,56.17 J8H1.35
M.2_SSD_P1_TX_CMC_DP: length 2.8
  TOP w0.1: R8H10.1 33.3,54.76 33.3,55.59 33.67,55.96 33.67,56.02 33.52,56.17 J8H1.37
M.2_SSD_P1_TX_DN: length 161
  TOP w0.088: U6E1.C42 112.96,138.2 112.96,138.33 113.09,138.47 113.64,138.47 113.82,138.64 114.66,138.64 116.96,136.34 116.96,135.76
  TOP w0.1: 116.96,135.76 116.96,134.72 119.38,132.3 119.38,130.4 121.6,128.17 123.89,128.17 124.71,127.35 124.71,121.92 122.35,119.56 122.35,117.77 123.06,117.06 123.06,108.49 116.02,101.44 115.2,101.44 v1(114.9,101.74) ; v1(33.73,51.06) 33.57,51.06 33.32,51.3 33.32,51.97 33.42,52.07 C8H12.1
  BOTTOM w0.1: v1(33.73,51.06) 33.53,51.06 33.36,51.23 33.36,52.92 34.47,54.03 36.12,54.03 38.02,55.93 43.64,55.93 46.25,58.55 48.89,58.55 49.45,59.11 51.64,59.11 55.64,63.1 56.62,63.1 58.85,65.33 59.48,65.33 60.83,66.67 61.97,66.67 65.17,69.87 77.52,69.87 78.46,70.81 80.13,70.81 80.96,69.98 88.13,69.98 93.77,75.61 93.77,77.34 97.72,81.29 98.22,81.29 103.14,86.21 103.14,86.96 106.27,90.1 107.31,90.1 115.64,98.43 115.64,101.18 115.43,101.39 115.08,101.39 114.9,101.57 v1(114.9,101.74)
M.2_SSD_P1_TX_DP: length 161
  TOP w0.088: U6E1.D42 112.63,138.28 113.01,138.66 113.56,138.66 113.74,138.83 114.74,138.83 117.15,136.42 117.15,135.85 117.16,135.84 117.16,135.78 117.16,135.78 117.16,135.76
  TOP w0.1: v1(114.9,100.94) 115.2,101.24 116.1,101.24 123.26,108.4 123.26,117.15 122.55,117.85 122.55,119.48 124.91,121.84 124.91,127.44 123.97,128.37 121.69,128.37 119.58,130.48 119.58,132.38 117.16,134.8 117.16,135.76 ; v1(32.93,51.06) 33.12,51.24 33.12,51.84 C8H11.1
  BOTTOM w0.1: v1(32.93,51.06) 33.16,51.28 33.16,53 34.38,54.23 36.03,54.23 37.94,56.13 43.56,56.13 46.17,58.75 48.81,58.75 49.37,59.31 51.56,59.31 55.55,63.3 56.54,63.3 58.76,65.53 59.4,65.53 60.75,66.87 61.89,66.87 65.08,70.07 77.43,70.07 78.37,71.01 80.21,71.01 81.05,70.18 88.05,70.18 93.57,75.7 93.57,77.42 93.63,77.48 97.64,81.49 98.14,81.49 102.94,86.29 102.94,87.04 106.19,90.3 107.23,90.3 115.45,98.51 115.45,101.09 115.34,101.19 115.15,101.19 v1(114.9,100.94)
M.2_SSD_P2_RX_DN: length 155.3
  TOP w0.1: U6E1.M44 v1(108.85,137.39) ; R8H21.1 38.7,53.57 38.7,53.31 37.98,52.59 37.98,52.19 38.08,52.09 38.27,52.09 38.52,52.34 v1(38.52,52.39)
  BOTTOM w0.089: v1(108.85,137.39) 108.68,137.39 108.57,137.28 108.57,137.06 108.83,136.79 108.83,136.21 108.67,136.05 108.67,136.04 108.63,136 108.63,135.99 108.62,135.98
  BOTTOM w0.1: v1(38.52,52.39) 38.22,52.09 37.99,52.09 37.77,51.86 37.77,50.97 38.77,49.96 41.32,49.96 42.72,51.36 48.69,51.36 53.26,55.93 54.15,55.93 59.99,61.77 63.5,61.77 64.89,63.17 64.89,64.39 66.03,65.53 66.03,66.52 66.68,67.17 75.92,67.17 77.06,66.04 80.89,66.04 81.91,67.05 89.28,67.05 94.1,71.88 95.15,71.88 100.14,76.88 100.14,79.4 107.87,87.12 108.15,87.12 118.51,97.48 118.51,107.14 116.65,109 116.65,118.16 107.95,126.87 107.95,128.9 108.33,129.28 108.33,131.22 107.69,131.86 107.69,135.05 108.61,135.98 108.62,135.98
M.2_SSD_P2_RX_DP: length 155.3
  TOP w0.1: v1(38.52,51.59) 38.22,51.89 37.99,51.89 37.78,52.1 37.78,52.67 38.5,53.39 38.5,53.57 R8H20.1 ; U6E1.N42 v1(108.66,138.18)
  BOTTOM w0.089: v1(108.66,138.18) 108.38,137.9 108.38,136.98 108.65,136.71 108.65,136.29 108.48,136.12
  BOTTOM w0.1: v1(38.52,51.59) 38.22,51.89 38.08,51.89 37.97,51.78 37.97,51.05 38.86,50.16 41.24,50.16 42.64,51.56 48.61,51.56 53.18,56.13 54.07,56.13 59.91,61.97 63.41,61.97 64.69,63.25 64.69,64.47 65.83,65.61 65.83,66.6 66.6,67.37 76.01,67.37 77.14,66.24 80.81,66.24 81.83,67.25 89.19,67.25 94.02,72.08 95.06,72.08 99.94,76.96 99.94,79.48 107.79,87.32 108.07,87.32 118.31,97.56 118.31,107.06 116.45,108.91 116.45,118.08 107.75,126.79 107.75,128.99 108.13,129.37 108.13,131.14 107.49,131.77 107.49,135.13 108.48,136.12
M.2_SSD_P2_RX_R_DN: length 2.7
  TOP w0.1: J8H1.17 38.52,56.17 38.37,56.02 38.37,55.88 38.71,55.54 38.71,55.01 R8H21.2
M.2_SSD_P2_RX_R_DP: length 2.7
  TOP w0.1: J8H1.19 38.02,56.17 38.17,56.02 38.17,55.79 38.51,55.46 38.51,55.02 R8H20.2
M.2_SSD_P2_TX_C_DN: length 1.3
  TOP w0.1: R8H19.1 36.89,53.76 36.89,53.28 C8H14.2
M.2_SSD_P2_TX_C_DP: length 1.3
  TOP w0.1: R8H11.2 36.69,53.86 36.69,53.33 C8H13.2
M.2_SSD_P2_TX_CMC_DN: length 2.7
  TOP w0.1: R8H19.2 36.89,54.82 36.89,56.04 37.02,56.17 J8H1.23
M.2_SSD_P2_TX_CMC_DP: length 2.7
  TOP w0.1: J8H1.25 36.52,56.17 36.69,55.99 36.69,54.73 R8H11.1
M.2_SSD_P2_TX_DN: length 151.8
  TOP w0.088: U6E1.C44 113.11,137.71 114.14,137.71 115.35,136.5 115.35,135.96 115.35,135.96 115.35,135.9 115.34,135.89 115.34,135.88
  TOP w0.1: 115.34,135.88 115.34,134.05 117.09,132.3 117.09,127.87 116.05,126.83 116.05,122.07 120.57,117.55 120.57,108.36 117.01,104.8 115.94,104.8 v1(115.64,105.1) ; v1(37.16,51.39) 37,51.39 36.76,51.63 36.76,52.17 36.86,52.27 37,52.27 C8H14.1
  BOTTOM w0.1: v1(115.64,105.1) 115.94,104.8 116.16,104.8 116.45,104.51 116.45,98.28 107.5,89.33 107.22,89.33 96.26,78.38 96.26,76.14 94.07,73.95 93.13,73.95 88.39,69.21 81.02,69.21 80.06,68.25 78.14,68.25 77.2,69.2 65.76,69.2 62.1,65.53 61.39,65.53 59.99,64.13 59.3,64.13 57.36,62.18 55.68,62.18 51.33,57.84 47.83,57.84 44.73,54.74 38.55,54.74 36.84,53.03 36.84,51.51 36.96,51.39 v1(37.16,51.39)
M.2_SSD_P2_TX_DP: length 151.8
  TOP w0.088: U6E1.D43 112.64,137.9 114.22,137.9 115.54,136.57 115.54,135.88
  TOP w0.1: C8H13.1 36.43,52.07 36.56,51.94 36.56,51.58 v1(36.36,51.39) ; 115.54,135.88 115.54,134.14 117.29,132.39 117.29,127.78 116.25,126.74 116.25,122.15 120.77,117.63 120.77,108.28 117.1,104.6 115.94,104.6 v1(115.64,104.3)
  BOTTOM w0.1: v1(115.64,104.3) 115.94,104.6 116.08,104.6 116.25,104.43 116.25,98.37 107.42,89.53 107.14,89.53 96.06,78.46 96.06,76.23 93.99,74.15 93.04,74.15 88.3,69.41 80.94,69.41 79.98,68.45 78.23,68.45 77.28,69.4 65.68,69.4 62.02,65.73 61.31,65.73 59.91,64.33 59.22,64.33 57.27,62.38 55.6,62.38 51.25,58.04 47.75,58.04 44.65,54.94 38.46,54.94 36.64,53.11 36.64,51.66 v1(36.36,51.39)
M.2_SSD_P3_RX_DN: length 149.9
  TOP w0.1: U6E1.R35 v1(107.54,141.77) ; v1(42.41,53.08) 42.29,53.08 42.13,53.24 42.13,53.67 42.31,53.85 R8H24.1
  BOTTOM w0.089: v1(107.54,141.77) 107.54,141.6 107.3,141.36 107.14,141.36 106.92,141.14 106.92,139.9 107.15,139.67 107.15,139.19 107.27,139.06 107.27,138.63 107.88,138.02 107.88,137.19 107.72,137.03 107.72,137.03 107.67,136.98 107.67,136.98 107.66,136.97
  BOTTOM w0.1: v1(42.41,53.08) 42.13,52.8 42.13,52.6 42.41,52.32 48.38,52.32 53.97,57.91 54.83,57.91 55.68,58.76 55.68,60.03 56.24,60.59 57.51,60.59 59.78,62.86 60.42,62.86 61.76,64.21 62.47,64.21 66.31,68.05 76.29,68.05 77.34,67 80.51,67 81.46,67.94 88.9,67.94 93.71,72.76 94.78,72.76 99.24,77.21 99.24,79.73 107.59,88.08 107.88,88.08 117.63,97.83 117.63,106.77 115.26,109.14 115.26,118.03 106.98,126.31 106.98,129.37 107.34,129.72 107.34,130.88 106.67,131.55 106.67,135.12 107.44,135.89 107.44,136.75 107.66,136.97
M.2_SSD_P3_RX_DP: length 149.9
  TOP w0.1: R8H23.1 41.93,53.57 41.93,53.37 v1(41.65,53.08) ; U6E1.R37 v1(107.54,141.01)
  BOTTOM w0.089: 107.8,136.83 108.07,137.11 108.07,138.1 107.46,138.71 107.46,139.14 107.34,139.27 107.34,139.75 107.11,139.98 107.11,141.06 107.22,141.17 107.37,141.17 v1(107.54,141.01)
  BOTTOM w0.1: v1(41.65,53.08) 41.93,52.8 41.93,52.52 42.33,52.12 48.47,52.12 54.05,57.71 54.91,57.71 55.88,58.67 55.88,59.94 56.32,60.39 57.59,60.39 59.87,62.66 60.5,62.66 61.84,64.01 62.56,64.01 66.39,67.84 76.21,67.84 77.26,66.8 80.6,66.8 81.54,67.74 88.98,67.74 93.79,72.56 94.87,72.56 99.44,77.12 99.44,79.64 107.68,87.88 107.96,87.88 117.83,97.75 117.83,106.86 115.46,109.22 115.46,118.11 107.18,126.39 107.18,129.28 107.54,129.64 107.54,130.96 106.87,131.63 106.87,135.03 107.64,135.81 107.64,136.67 107.8,136.83
M.2_SSD_P3_RX_R_DN: length 3
  TOP w0.1: R8H24.2 42.13,55.01 42.13,55.4 41.78,55.75 41.49,55.75 41.37,55.88 41.37,56.02 41.52,56.17 J8H1.5
M.2_SSD_P3_RX_R_DP: length 3
  TOP w0.1: R8H23.2 41.93,55.02 41.93,55.31 41.7,55.55 41.41,55.55 41.17,55.79 41.17,56.02 41.02,56.17 J8H1.7
M.2_SSD_P3_TX_C_DN: length 1.3
  TOP w0.1: C8H16.2 40.38,53.34 40.38,53.82 R8H22.1
M.2_SSD_P3_TX_C_DP: length 1.3
  TOP w0.1: C8H15.2 40.18,53.27 40.18,53.79 R8H12.2
M.2_SSD_P3_TX_CMC_DN: length 2.9
  TOP w0.1: R8H22.2 40.36,54.79 40.36,55.39 39.87,55.88 39.87,56.02 40.02,56.17 J8H1.11
M.2_SSD_P3_TX_CMC_DP: length 2.9
  TOP w0.1: R8H12.1 40.16,54.76 40.16,55.31 39.67,55.79 39.67,56.02 39.52,56.17 J8H1.13
M.2_SSD_P3_TX_DN: length 146.1
  TOP w0.088: 114.75,135.88 114.75,135.89 114.75,135.9 114.75,135.96 114.74,135.96 114.74,136.64 114.09,137.29 U6E1.A44
  TOP w0.1: 114.75,135.88 114.75,133.91 116.58,132.08 116.58,128.27 115.57,127.25 115.57,121.79 120.08,117.27 120.08,108.78 118.54,107.24 117.14,107.24 116.71,106.81 116.71,106.3 v1(117.13,105.88) ; v1(40.76,51.31) 40.52,51.31 40.42,51.41 40.42,51.97 40.52,52.07 C8H16.1
  BOTTOM w0.1: v1(117.13,105.88) 116.84,105.58 116.84,105.13 117.14,104.82 117.14,98.02 107.77,88.64 107.48,88.64 97.02,78.18 97.02,75.95 94.35,73.28 93.5,73.28 88.67,68.45 81.22,68.45 80.33,67.56 77.82,67.56 76.86,68.52 66.1,68.52 62.28,64.7 61.52,64.7 60.18,63.36 59.55,63.36 57.45,61.26 55.95,61.26 51.77,57.08 48.2,57.08 45.03,53.9 41.45,53.9 40.42,52.87 40.42,51.41 40.52,51.31 v1(40.76,51.31)
M.2_SSD_P3_TX_DP: length 146.1
  TOP w0.088: U6E1.B44 113.57,137.29 113.83,137.03 114.08,137.03 114.55,136.56 114.55,135.88
  TOP w0.1: 114.55,135.88 114.55,133.82 116.38,132 116.38,128.35 115.37,127.34 115.37,121.71 119.88,117.19 119.88,108.87 118.46,107.44 117.06,107.44 116.51,106.89 116.51,106.05 v1(116.34,105.88) ; v1(39.87,51.31) 40.22,51.65 40.22,51.97 40.12,52.07 C8H15.1
  BOTTOM w0.1: v1(39.87,51.31) 40.12,51.31 40.22,51.41 40.22,52.95 41.37,54.1 44.94,54.1 48.12,57.28 51.68,57.28 55.87,61.46 57.37,61.46 59.47,63.56 60.1,63.56 61.43,64.9 62.2,64.9 66.02,68.72 76.94,68.72 77.9,67.76 80.25,67.76 81.13,68.65 88.59,68.65 93.41,73.48 94.27,73.48 96.82,76.03 96.82,78.27 107.4,88.84 107.69,88.84 116.94,98.1 116.94,104.74 116.64,105.05 116.64,105.58 v1(116.34,105.88)
M.2_SSD_PLN_IN_N: length 1.6
  TOP w0.1: R8H46.2 37.84,44.32 37.33,44.83 U8H5.2
M.2_SSD_PLN_N: length 29.9
  TOP w0.1: v1(40.13,61.47) 40.77,62.11 J8H1.8 ; 35.05,42.29 R8H52.2 R8H51.2 36.49,42.75 37.26,42.75 v1(37.71,42.29)
  LAY6 w0.125: v1(37.71,42.29) 38.22,42.8 38.22,45.72 44.19,51.69 44.19,53.44 40,57.63 40,61.34 v1(40.13,61.47)
M.2_SSD_PLN_R_N: length 1.8
  TOP w0.1: U8H5.7 35.41,44.43 35.05,44.07 R8H50.1
M.2_SSD_SATA_PCIE_DET_N: length 143.3
  TOP w0.1: R7F51.2 94.86,106.55 94.86,101.6 94.23,100.96 94.23,99.69 v1(93.72,99.19) ; v1(30.09,45.34) 30.62,45.86 30.62,49.64 30.4,49.86 29.08,49.86 27,51.94 R8H77.2 26.03,52.45 26.03,54.23 R8H8.2 25.52,54.74 J8H1.69
  LAY5 w0.125: v1(30.09,45.34) 31.26,45.34 32.28,44.32 35.71,44.32 36.97,45.58 42.39,45.58 43.29,46.48 44.06,46.48 44.32,46.22 54.86,46.22 55.74,47.11 57.9,47.11 58.67,47.88 61.21,47.88 61.84,48.51 72.26,48.51 73.4,49.66 77.21,49.66 78.49,50.93 82.04,50.93 84.28,53.17 86.01,53.17 86.55,52.63 90.19,52.63 90.92,53.36 92.86,53.36 93.53,54.04 95.64,54.04 96.98,55.37 v1(97.4,55.37)
  LAY6 w0.125: v1(97.4,55.37) 97.03,55.75 97.03,61.11 96.12,62.02 96.12,86.01 95.05,87.08 95.05,89.09 95.51,89.56 95.51,93.85 93.22,96.15 93.22,98.68 v1(93.72,99.19)
M.2_WIFI_RF_KILL_N: length 11.3
  TOP w0.1: Q7B7.3 84.32,245.43 82.16,243.27 82.16,242.7 R7B42.1 81.66,241.04 81.22,240.61 78.36,240.61 77.82,240.07 J7C1.56
M_ACT_A_N: length 53.1
  TOP w0.088: J3D1.AY30 232.21,161.71 232.3,161.62 232.3,160.89 231.96,160.54 231.96,159.88 231.65,159.57 231.65,157.84 232.2,157.29 232.2,157.07 ; J1E5.62 231.14,129.62 231.14,128.98 231.24,128.88 231.4,128.88 231.5,128.78 231.5,128.55 231.41,128.46 231.22,128.46 231.13,128.37 231.13,127.31 231.23,127.2 231.67,127.2 231.75,127.13 231.75,126.95 231.68,126.89 231.68,126.75 231.78,126.66 231.78,125.47 231.43,124.83 231.09,124.02 230.92,122.28 J1F1.62
  TOP w0.1: 231.28,133 231.28,132.51 231.12,132.35 231.12,131.39 231.29,131.22 231.29,130.62 231.59,130.33 231.59,129.2 232.42,128.16 232.42,127.3 231.78,126.66
  TOP w0.215: 232.2,157.07 232.2,151.08 234.49,148.79 234.49,148.54 234.66,148.36 234.83,148.36 235.05,148.15 235.05,148.05 234.83,147.84 234.72,147.84 234.49,147.61 234.49,144.8 234.08,144.4 234.08,138.05 232.21,136.18 232.21,135.55 232.06,135.4 231.41,135.4 231.26,135.25 231.26,135.03 231.41,134.88 232.06,134.88 232.21,134.73 232.21,133.92 231.87,133.58 231.65,133.58 230.87,134.36 230.68,134.36 230.53,134.2 230.53,133.97 231.28,133.21 231.28,133
M_ACT_B_N: length 87.5
  TOP w0.1: J3D1.AP25 v3(228.06,168.33)
  LAY3 w0.088: v3(228.06,168.33) 227.78,168.06 227.78,168.06 227.67,167.95 227.67,166.38 227.71,166.34 227.71,165.26 227.85,165.12 227.85,163.46 227.76,163.37 227.76,163.14 231.67,158.26 231.73,158.2 231.73,158.09 ; J1F3.62 230.92,102.97 230.93,102.97 230.93,103.8 231.41,106.02 231.41,106.86 231.89,107.34 231.89,108.63 231.98,108.72 231.98,108.95 232.41,109.38 232.41,109.94 232.04,110.31 231.42,110.31 231.3,110.43 231.3,110.55 231.42,110.66 231.76,110.66 231.89,110.79 231.89,110.9 231.77,111.02 231.33,111.02 231.24,111.11 231.24,111.24 231.58,111.58 231.58,112.13 231.46,112.25 231.32,112.25 J1F2.62
  LAY3 w0.1: 231.85,114.4 231.85,114.19 231.96,114.09 232.06,114.09 232.42,113.74 232.42,113.19 231.97,112.74 231.97,111.59 232.82,110.74 232.82,108.85 232.69,108.72 231.98,108.72
  LAY3 w0.2: 231.73,158.09 231.73,152.21 232.87,151.08 232.87,150.05 233.74,149.18 233.74,148.13 234.67,147.2 234.67,143.13 233.62,142.07 233.62,136.45 233.76,136.31 233.96,136.31 234.12,136.46 234.12,137.97 234.26,138.11 234.47,138.11 234.62,137.96 234.62,136.16 233.62,135.16 233.62,134.42 232.5,133.3 232.33,133.3 231.07,132.04 231.07,131.37 231.16,131.28 231.16,131.04 230.87,130.76 230.63,130.76 230.22,130.35 230.22,129.77 231.29,128.7 231.29,128.37 231.07,128.15 231.07,128.14 231.07,127.16 230.87,126.96 230.63,126.96 230.22,126.55 230.22,125.97 230.63,125.56 230.83,125.56 231.05,125.34 231.05,123.18 230.85,122.98 230.61,122.98 230.2,122.57 230.2,122 230.22,121.98 230.22,121.97 231.05,121.13 231.05,119.62 230.2,118.77 230.2,118.2 230.59,117.81 230.59,116.89 232.05,115.43 232.05,114.59 231.85,114.4
M_ALERT_A_N: length 80.4
  TOP w0.089: v3(231.56,161.28) 231.46,161.72 231.46,162.22 J3D1.AY29
  TOP w0.1: R3G3.2 v1(229.23,94.74)
  LAY3 w0.089: v3(231.56,161.28) 233.96,158 234.1,157.86 234.1,153.65 235.53,152.22 235.53,151.27 235.58,151.22 236.46,150.34 236.46,149.56 237.88,148.14 237.88,147.37 238.16,147.09 238.16,137.17 238.36,136.97 238.36,135.48 238.77,135.06 238.77,133.73 237.8,132.76 237.8,131.3 236.97,130.48 236.97,129.16 237.72,128.41 237.72,127.26 237,126.53 237,125.74 237.8,124.94 237.8,123.83 236.83,122.87 236.83,121.83 236.01,121.01 236.01,119.7 235.21,118.9 235.21,117.74 236.68,116.27 236.68,114.72 237.61,113.79 237.61,113.06 236.84,112.29 236.84,111.31 236,110.46 236,109.26 235.19,108.45 235.19,106.56 235.99,105.76 235.99,104.28 235.19,103.48 235.19,102.42 234.28,101.51 234.28,100.36 233.48,99.56 233.48,98.75 232.94,98.21 230.78,98.21 229.96,97.39 229.96,95.47 v1(229.23,94.74)
M_ALERT_A_N_R: length 38.2
  TOP w0.1: v1(231.64,93.72) R3G5.2 R3G3.1
  LAY8 w0.125: v1(231.64,93.72) 231.64,94.23 231.77,94.36 231.77,99.44 230.88,100.33 230.88,101.98 230.2,102.67 230.2,103.58 230.88,104.27 230.88,106.17 231.64,106.93 231.64,108.2 232.66,109.22 232.66,110.49 231.77,111.38 231.77,112.39 230.88,113.28 230.88,113.92 229.2,115.6 J1F1.208 229.31,118.59 229.31,120.83 228.47,121.66 228.47,122.55 229.27,123.36 229.27,126.21 J1E5.208
M_ALERT_B_N: length 95.5
  TOP w0.088: v3(227.18,168.33) J3D1.AP24
  TOP w0.1: R3G2.2 v1(226.56,94.74)
  LAY3 w0.089: v1(226.56,94.74) 227.04,94.26 229.97,94.26 230.54,94.83 230.54,97.18 230.99,97.62 234.01,97.62 235.11,98.71 235.11,99.42 235.98,100.29 235.98,101.16 236.89,102.07 236.89,103.2 237.59,103.9 237.59,105.72 236.96,106.35 236.96,108.58 237.67,109.28 237.67,110.54 238.42,111.29 238.42,112.2 237.92,112.71 237.92,113.89 238.41,114.39 238.41,116.27 236.94,117.74 236.94,118.87 237.75,119.68 237.75,120.65 238.52,121.42 238.52,122.61 239.19,123.28 239.19,124.29 238.61,124.88 238.61,126.35 239.21,126.96 239.21,128.36 238.59,128.99 238.59,130.51 239.3,131.22 239.3,133.35 238.98,133.67 238.98,135.17 238.64,135.51 238.64,137.12 238.38,137.38 238.38,147.14 238.08,147.45 238.08,148.21 236.65,149.63 236.65,150.41 235.72,151.35 235.72,152.33 234.31,153.74 234.31,157.82 234.29,157.88 234.29,157.94 234.15,158.08 232,161.06
  LAY3 w0.1: 232,161.06 232,161.41 231.7,161.71 231.01,161.71 230.37,162.35 230.37,168.66 230.22,168.81 227.8,168.81 227.32,168.33 v3(227.18,168.33)
M_ALERT_B_N_R: length 18.3
  TOP w0.1: v1(229.23,93.72) R3G4.2 R3G2.1
  LAY8 w0.089: 227.63,105.08 227.63,105.27 229.22,106.86 J1F2.208
  LAY8 w0.1: 227.63,105.08 227.63,104.21 228.21,103.63 228.21,102.49 229.2,101.5 J1F3.208
  LAY8 w0.125: v1(229.23,93.72) 229.99,94.49 229.99,96.26 229.2,97.05 J1F3.208
M_BA_A_0: length 58.2
  TOP w0.088: J3D1.AY16 219.38,162.4 219.38,161.25 219.54,161.09 219.54,158.33 218.5,157.29 218.5,156.22 218.49,156.21 218.49,156.08 ; J1E5.81 209.67,131.12 209.52,130.96 209.36,130.96 209.2,130.8 209.2,130.68 209.46,130.41 209.46,129.79 209.1,129.43 209.1,129.29 209.21,129.19 209.21,129.03 209.08,128.9 208.82,128.9 208.71,128.8 208.71,128.49 209.04,128.16 208.97,128.09 208.97,127.01 209.46,126.52 209.46,126.04 209.32,125.86 209.32,124.96 209.67,123.88 J1F1.81
  TOP w0.1: 209.04,128.16 209.66,128.78 209.66,130.7 210.32,131.36 210.32,132.15 210.19,132.46
  TOP w0.215: 218.49,156.08 218.49,152.74 210.97,145.21 210.97,137.6 210.8,137.43 210.58,137.43 210.45,137.57 210.45,141.99 210.29,142.14 210.07,142.14 209.93,142 209.93,137.19 210.54,136.58 210.54,133.65 210.19,133.3 210.19,132.46
M_BA_A_1: length 58.7
  TOP w0.088: 219.53,156.46 219.53,157.16 220.48,158.11 220.48,161.01 219.92,161.57 219.92,162.01 220,162.09 220,162.64 220.32,162.96 J3D1.AW17 ; J1E5.224 210.67,125.83 210.67,125.72 210.36,125.41 210.36,125.33 210.52,125.17 210.72,125.17 210.82,125.07 210.82,124.59 210.5,124.27 210.5,123.29 211.05,122.73 211.23,122.73 211.23,121.28 210.52,120.57 210.52,118.48 J1F1.224
  TOP w0.1: 211.37,132.5 211.17,132.3 211.08,132.3 210.72,131.93 210.72,131.39 210.93,131.18 210.93,130.58 211.17,130.34 211.17,129.79 210.72,129.34 210.72,127.18 211.17,126.73 211.17,124.61 210.71,124.15 210.71,123.62 211.33,122.99 211.33,122.84 211.23,122.73
  TOP w0.215: 211.37,132.5 211.64,132.76 211.64,136.41 212.01,136.78 212.01,142.35 212.14,142.48 212.36,142.48 212.53,142.31 212.53,141.03 212.67,140.88 212.89,140.88 213.05,141.05 213.05,145.82 219.53,152.3 219.53,156.46 219.53,156.46
M_BA_B_0: length 89.7
  TOP w0.088: v3(220.78,168.38) J3D1.AP18
  LAY3 w0.088: 209.32,108.63 209.15,108.63 208.83,108.96 208.83,110.42 209.2,110.79 209.2,111.3 209.46,111.57 209.46,112.14 209.2,112.41 209.2,112.66 209.43,112.89 209.43,113.07 J1F2.81 ; 218.45,158.22 218.45,158.51 219.79,159.86 219.79,160.72 219.31,161.2 219.31,162.31 220.06,163.06 220.06,164.31 220.29,164.54 220.29,164.89 220.11,165.08 220.11,166 220.35,166.24 220.35,166.78 220.52,166.94 220.52,167.09 220.35,167.26 220.35,167.64 220.78,168.06 v3(220.78,168.38)
  LAY3 w0.1: J1F3.81 209.67,104.57 209.46,105.1 209.46,105.24 209.64,105.42 209.64,105.57 209.56,105.66 209.4,105.66 209.21,105.47 209.09,105.47 208.93,105.63 208.93,107.25 209.47,107.78 209.47,108.34 209.32,108.48 209.32,108.63 209.45,108.76 209.45,108.96 209.02,109.39 209.02,109.93 209.42,110.33 209.83,110.33 209.92,110.42 209.92,110.6 209.66,110.86 209.66,112.54 210.32,113.19 210.32,113.73 209.95,114.09 209.95,114.36
  LAY3 w0.2: 218.45,158.22 218.45,152.26 211.95,145.76 211.95,138.19 211.81,138.04 211.61,138.04 211.45,138.2 211.45,141.9 211.31,142.05 211.1,142.05 210.95,141.89 210.95,133.55 210.17,132.76 210.17,132.15 210.37,131.95 210.37,131.37 209.96,130.96 209.78,130.96 209.52,130.7 209.52,129.77 209.4,129.66 209.4,129.11 210.37,128.15 210.37,127.57 209.96,127.16 209.74,127.16 209.52,126.94 209.52,125.97 209.4,125.85 209.4,125.13 210.35,124.17 210.35,123.6 209.94,123.19 209.74,123.19 209.5,122.95 209.5,121.22 210.35,120.37 210.35,119.8 209.5,118.95 209.5,118.2 209.3,118 209.3,117.85 209.5,117.65 209.5,116.75 209.99,116.26 209.99,115.81 209.79,115.61 209.79,114.52 209.95,114.36
M_BA_B_1: length 89.2
  TOP w0.088: v3(221.69,169.29) J3D1.AN19
  LAY3 w0.088: J1F2.224 210.52,107.52 210.85,107.19 210.85,106.45 210.71,106.31 210.71,105.27 210.5,105.05 210.5,104.06 211.33,103.23 211.33,102.3 211.43,102.2 211.82,102.2 211.91,102.11 211.91,101.88 211.82,101.79 210.96,101.79 210.52,101.35 210.52,99.17 J1F3.224 ; v3(221.69,169.29) 221.21,168.8 221.21,165.04 220.83,164.66 220.83,164.36 220.75,164.28 220.75,161.08 220.54,160.87 220.54,159.64 219.45,158.54 219.45,158.03
  LAY3 w0.1: 211.18,114.18 210.72,113.73 210.72,113.19 210.97,112.94 210.97,112.34 211.17,112.14 211.17,111.58 210.72,111.14 210.72,109.3 211.18,108.84 211.18,106.58 211.69,106.07 211.69,105.7 211.26,105.27 211.14,105.27 210.71,104.84 210.71,104.3 211.11,103.89 211.27,103.89 211.38,103.78 211.38,103.27 211.33,103.23
  LAY3 w0.2: 211.18,114.18 211.71,114.72 211.71,114.89 211.91,115.1 212.16,115.1 212.34,115.28 212.34,115.53 212.16,115.71 211.86,115.71 211.42,116.14 211.42,116.56 211.76,116.89 211.76,117.18 211.2,117.74 211.2,118.95 212.05,119.8 212.05,120.37 211.2,121.22 211.2,122.95 211.44,123.19 211.64,123.19 212.05,123.6 212.05,124.17 211.1,125.13 211.1,125.85 211.22,125.97 211.22,126.94 211.44,127.16 211.66,127.16 212.07,127.57 212.07,128.15 211.1,129.11 211.1,129.66 211.22,129.77 211.22,130.7 211.48,130.96 211.66,130.96 212.12,131.42 212.12,132.01 211.96,132.17 211.96,133.98 212.11,134.13 212.42,134.13 212.57,133.98 212.75,133.98 212.86,134.09 212.86,134.52 212.47,134.91 212.47,135.19 213.03,135.74 213.03,143.17 214.03,144.17 214.03,146.2 219.45,151.62 219.45,158.03
M_BG_A_0: length 56.5
  TOP w0.088: J3D1.AV29 231.3,163.89 231.63,163.55 231.63,162.69 231.76,162.56 231.76,161.69 231.98,161.46 231.98,161.11 231.56,160.69 231.56,160.04 231.26,159.73 231.26,157.69 231.68,157.26 231.68,157.07 ; J1E5.63 230.23,132.1 230.34,132.21 230.48,132.21 230.72,131.96 230.72,131.24 230.28,130.22 230.28,129.79 230.71,129.36 230.71,128.4 230.72,128.39 230.72,126.97 230.28,126.53 230.28,125.99 230.49,125.77 230.49,125.22 230.07,123.88 J1F1.63
  TOP w0.1: 230.01,132.86 230.01,132.59 229.42,132.01 229.42,131.39 230.08,130.73 230.08,129.51 230.22,129.37 230.22,128.61 230.43,128.4 230.71,128.4
  TOP w0.215: 230.01,132.86 230.01,134.73 232.52,137.24 232.52,141.11 232.66,141.25 232.88,141.25 233.04,141.08 233.04,138.28 233.2,138.12 233.42,138.12 233.56,138.27 233.56,144.79 233.97,145.19 233.97,148.58 231.68,150.86 231.68,157.07
M_BG_A_1: length 54.2
  TOP w0.088: J3D1.AW29 231.3,162.97 230.96,162.63 230.96,162.14 231.17,161.93 231.17,161.52 231.13,161.48 231.13,161.08 231.17,161.04 231.17,160.21 230.86,159.89 230.86,157.6 231.16,157.29 231.16,157.07 ; J1E5.207 230.43,127.5 230.43,127.28 230.35,127.19 229.99,127.19 229.87,127.07 229.87,126.95 230.08,126.75 230.08,125.25 229.43,124.6 229.43,124.18 229.41,124.16 229.41,123.35 230.08,122.67 230.08,120.09 230.07,120.08 J1F1.207
  TOP w0.1: 229.44,132.72 229.44,132.53 229.02,132.11 229.02,131.18 229.87,130.33 229.87,129.78 229.72,129.63 229.72,128.42 229.42,128.13 229.42,127.58 229.56,127.44 229.56,126.84 229.87,126.53 229.87,125.98 229.13,125.24 229.13,124.39 229.24,124.28 229.43,124.28
  TOP w0.215: 231.16,157.07 231.16,150.65 233.22,148.59 233.22,148.3 232.97,148.04 232.97,147.83 233.12,147.67 233.29,147.67 233.44,147.52 233.44,147.31 233.29,147.15 233.12,147.15 232.97,147 232.97,146.79 233.12,146.63 233.29,146.63 233.44,146.48 233.44,145.41 233.04,145 233.04,142.58 232,141.54 232,138.63 231.85,138.48 231.66,138.48 231.5,138.31 231.5,138.1 231.64,137.95 231.85,137.95 232,137.8 232,137.46 229.44,134.9 229.44,132.72
M_BG_B_0: length 89.3
  TOP w0.088: J3D1.AM23 v3(225.35,170.2)
  LAY3 w0.088: J1F2.63 230.49,113.87 230.62,113.87 230.72,113.77 230.72,113.19 230.34,112.81 230.23,112.81 230.07,112.65 230.07,111.39 230.29,111.17 230.29,110.35 230.72,109.93 230.72,108.77 230.28,108.33 230.28,107.8 230.61,107.46 230.61,107.05 230.85,106.82 230.85,106.59 230.61,106.35 230.61,105.48 230.07,104.57 J1F3.63 ; v3(225.35,170.2) 225.68,170.2 226.13,169.75 226.44,169.75 226.71,169.48 226.71,168.23 227.19,167.75 227.19,166.4 227.35,166.23 227.35,165.15 227.61,164.89 227.61,163.62 227.44,163.45 227.44,163.01 231.19,158.34 231.23,158.3 231.23,158.07
  LAY3 w0.1: 231.32,114.39 231.32,113.95 231.12,113.76 231.12,112.98 230.27,112.13 230.27,111.59 230.78,111.08 230.78,110.39 231.07,110.1 231.07,109.42 230.95,109.3 230.72,109.3
  LAY3 w0.2: 231.32,114.39 231.32,114.68 231.08,114.92 231.08,115.46 229.61,116.93 229.61,117.91 229.9,118.2 229.9,118.95 230.75,119.8 230.75,120.37 229.9,121.22 229.9,122.95 230.14,123.19 230.34,123.19 230.75,123.6 230.75,124.17 229.8,125.13 229.8,125.85 229.92,125.97 229.92,126.94 230.14,127.16 230.36,127.16 230.77,127.57 230.77,128.15 229.8,129.11 229.8,129.66 229.92,129.77 229.92,130.7 230.18,130.96 230.36,130.96 230.77,131.37 230.77,131.95 230.59,132.12 230.59,132.49 232.01,133.9 232.39,133.9 233.09,134.59 233.09,142.27 234.09,143.27 234.09,146.78 233.94,146.92 233.74,146.92 233.59,146.77 233.59,144.21 233.44,144.07 233.24,144.07 233.09,144.22 233.09,148.88 232.28,149.68 232.28,150.94 231.23,151.99 231.23,158.07
M_BG_B_1: length 89.1
  TOP w0.088: J3D1.AM22 v3(224.44,170.2)
  LAY3 w0.088: v3(224.44,170.2) J3D1.AM22 225.55,169.75 225.83,169.47 225.83,169.07 226.25,168.65 226.25,168.04 226.71,167.59 226.71,166.3 227,166 227,165.14 226.76,164.9 226.76,163.35 230.73,158.41 230.73,158.07 ; J1F3.207 230.07,100.77 230.07,101.48 230.18,101.59 230.23,101.59 230.32,101.67 230.32,101.9 230.23,101.99 230.18,101.99 230.08,102.09 230.08,103.64 229.41,104.3 229.41,104.87 229.73,105.19 229.73,105.38 229.98,105.38 230.08,105.48 230.08,106.9 229.99,106.99 229.88,106.99 229.79,107.08 229.79,107.25 229.88,107.34 229.99,107.34 230.08,107.42 230.08,109.65 J1F2.207
  LAY3 w0.1: 229.74,114.14 229.74,114.05 229.42,113.73 229.42,113.19 229.6,113.02 229.6,112.4 229.87,112.14 229.87,110.38 229.42,109.93 229.42,109.39 229.6,109.22 229.6,108.6 229.87,108.33 229.87,107.79 229.44,107.36 229.44,105.67 229.73,105.38
  LAY3 w0.2: 230.73,158.07 230.73,151.68 231.73,150.68 231.73,149.45 232.55,148.63 232.55,148.2 232.34,147.99 231.8,147.99 231.6,147.79 231.6,147.52 231.8,147.32 232.37,147.32 232.55,147.14 232.55,146.78 232.34,146.57 231.8,146.57 231.6,146.37 231.6,146.1 231.8,145.9 232.37,145.9 232.55,145.72 232.55,134.77 232.19,134.4 231.77,134.4 229.37,132 229.37,131.37 229.46,131.28 229.46,131.04 229.17,130.76 228.93,130.76 228.52,130.35 228.52,129.77 229.59,128.7 229.59,128.37 229.37,128.15 229.37,128.14 229.37,127.16 229.17,126.96 228.93,126.96 228.52,126.55 228.52,125.97 228.93,125.56 229.13,125.56 229.35,125.34 229.35,123.18 229.15,122.98 228.91,122.98 228.5,122.57 228.5,122 228.52,121.98 228.52,121.97 229.35,121.13 229.35,119.62 228.5,118.77 228.5,118.2 228.9,117.8 228.9,116.79 230.29,115.4 230.29,114.69 229.74,114.14
M_DATA_A<0>: length 88.3
  TOP w0.165: v3(241.96,176.22) J3D1.AE40
  LAY2 w0.089: J1F1.5 279.16,124.5 279.16,126.51 278.73,127.69 278.73,128.17 ; 278.73,128.17 278.73,128.23 278.61,128.41 278.61,129.24 279.16,129.79 279.16,130.32 278.85,130.64 278.85,131.27 278.73,131.39 278.73,131.94 279.38,132.59 279.38,135.92 278.9,136.4 278.9,136.6 279.38,137.08 279.38,137.81 277.28,139.91 277.15,139.91 276.83,139.59 276.83,139.46 278.69,137.6 278.69,137.46 278.38,137.16 278.24,137.16 276.26,139.13 276.26,139.96 276.46,140.15 276.46,140.73 274.74,142.45 274.18,142.45 274.05,142.58 274.05,147.14 261.29,159.9 261.29,167.65 252.64,176.3 242.47,176.3 242.4,176.22 v3(241.96,176.22) ; 278.73,128.17 279.08,128.52 279.32,128.52 279.39,128.59 279.39,128.71 279.3,128.79 279.11,128.79 279.02,128.88 279.02,129.01 279.11,129.11 279.38,129.11 279.47,129.19 279.47,129.32 279.37,129.43 J1E5.5
M_DATA_A<1>: length 89.4
  TOP w0.165: v3(241.96,175.24) J3D1.AF40
  LAY2 w0.089: 277.86,122.56 278.71,123.41 278.71,124.46 278.52,124.65 J1E5.150 ; 277.86,122.56 277.86,122.1 278.29,120.17 J1F1.150 ; 277.86,122.56 277.74,122.68 277.74,123.06 278.29,123.62 278.29,124.15 278.01,124.44 278.01,125.86 277.88,125.99 277.88,126.52 278.12,126.76 278.12,127.4 278.31,127.59 278.31,128.12 277.83,129.91 277.83,130.27 278.31,131.39 278.31,132.25 278.74,132.69 278.74,135.66 275.63,138.77 275.63,140.57 274.38,141.82 274.25,141.82 273.95,141.51 273.95,141.35 275,140.3 275,140.16 274.69,139.84 274.56,139.84 273.42,140.99 273.42,146.5 273.42,146.87 260.66,159.63 260.66,167.38 252.38,175.66 242.39,175.66 v3(241.96,175.24)
M_DATA_A<2>: length 88.6
  TOP w0.165: v3(241.96,173.34) J3D1.AH40
  LAY2 w0.089: J1E5.12 273.79,129.35 273.79,129.18 273.74,129.13 273.53,129.13 273.44,129.04 273.44,128.92 273.53,128.83 274.16,128.83 274.25,128.74 274.25,128.62 274.16,128.53 273.9,128.53 273.79,128.42 273.79,128.28 273.63,128.12 273.63,127.59 273.79,127.43 273.79,126.86 ; 273.79,126.86 273.71,126.86 273.5,126.94 273.43,127.01 273.43,128.53 272.91,129.05 272.91,129.66 272.78,129.79 272.78,130.32 273.63,131.17 273.63,132.01 273.89,132.27 273.89,132.61 270.59,135.9 270.59,145.71 270.44,145.85 270.04,145.85 269.95,145.76 269.95,142.17 269.88,142.09 269.4,142.09 269.32,142.18 269.32,143.5 269.32,146.97 269.23,147.06 268.8,147.06 268.69,146.95 268.69,145.26 268.57,145.14 268.2,145.14 268.05,145.29 268.05,147.3 268.46,147.71 268.46,147.83 257.83,158.46 257.83,166.21 251.31,172.73 244.66,172.73 244.13,173.26 242.03,173.26 v3(241.96,173.34) ; 273.79,126.86 274.06,126.53 274.06,125.98 273.61,123.98 273.61,123.5 273.55,123.1 J1F1.12
M_DATA_A<3>: length 88
  TOP w0.165: v3(239.98,173) J3D1.AH38
  LAY2 w0.089: J1F1.157 272.77,122.54 273.21,123.64 273.21,124.15 273.23,124.17 ; J1E5.157 272.57,126.98 272.36,126.77 272.36,124.95 272.68,124.63 272.78,124.63 273.23,124.17 ; 273.23,124.17 273.28,124.22 273.28,124.73 273.14,124.88 273.14,125.63 272.78,125.99 272.78,126.52 272.97,126.71 272.97,127.35 273.21,127.59 273.21,128.12 272.83,128.5 272.66,128.5 272.36,128.8 272.36,130.54 273.21,131.39 273.21,132.37 272.83,132.75 272.39,132.75 272.18,132.96 272.18,133.42 269.95,135.64 269.95,141.37 269.87,141.46 269.41,141.46 269.32,141.37 269.32,137.33 269.23,137.23 268.81,137.23 268.69,137.36 268.69,143.76 267.42,145.03 267.42,147.98 257.2,158.2 257.2,165.95 251.06,172.08 244.64,172.08 244,172.73 242.29,172.73 242.11,172.91 241.44,172.91 241.36,173 v3(239.98,173)
M_DATA_A<4>: length 94.4
  TOP w0.165: v3(239.98,176.62) J3D1.AE38
  LAY2 w0.089: J1E5.3 281.07,129.43 281.17,129.33 281.17,129.19 281.08,129.11 280.81,129.11 280.72,129.01 280.72,128.88 280.81,128.79 281,128.79 281.09,128.71 281.09,128.6 281,128.52 280.77,128.52 280.43,128.17 ; 280.43,128.17 280.43,128.23 280.27,128.43 280.27,129.2 280.87,129.79 280.87,130.38 280.7,130.54 280.55,130.7 280.55,131.27 280.43,131.39 280.43,131.96 280.77,132.31 281.71,132.31 281.92,132.51 281.92,136.68 281.83,136.77 281.37,136.77 281.28,136.68 281.28,132.97 281.18,132.88 280.75,132.88 280.65,132.97 280.65,138.34 275.32,143.67 275.32,147.66 273.38,149.6 262.6,160.38 262.6,168.13 253.16,177.57 241.89,177.57 241.35,177.03 240.52,177.03 240.11,176.62 v3(239.98,176.62) ; 280.43,128.17 280.43,127.75 280.86,126.52 280.86,124.52 J1F1.3
M_DATA_A<5>: length 87.9
  TOP w0.165: v3(240.9,176.62) J3D1.AE39
  LAY2 w0.089: J1F1.148 279.99,120.17 279.56,122.1 279.56,122.56 ; v3(240.9,176.62) 240.93,176.66 242.11,176.66 242.39,176.93 252.9,176.93 261.92,167.91 261.92,160.16 269.94,152.14 274.68,147.4 274.68,143.4 280.01,138.08 280.01,132.56 280.01,131.39 279.91,131.29 279.91,130.66 279.58,130.32 279.58,129.79 279.89,129.48 279.89,128.3 280.01,128.17 280.01,127.59 279.9,127.48 279.9,126.84 279.58,126.52 279.58,125.99 279.73,125.84 279.73,124.41 279.99,124.15 279.99,123.57 279.25,122.83 279.25,122.69 279.38,122.56 279.56,122.56 ; 279.56,122.56 280.41,123.41 280.41,124.5 280.22,124.69 J1E5.148
M_DATA_A<6>: length 88.3
  TOP w0.165: v3(241.96,174.25) J3D1.AG40
  LAY2 w0.089: J1E5.10 275.12,129.51 275.21,129.42 275.47,129.42 275.54,129.35 275.54,129.2 275.45,129.11 275.45,128.91 275.52,128.83 275.92,128.83 275.99,128.76 275.99,128.59 275.9,128.5 275.7,128.5 275.33,128.12 275.33,127.59 275.77,127.15 275.77,126.83 275.76,126.83 ; 275.76,126.83 275.76,126.06 275.31,124.02 275.31,123.58 J1F1.10 ; 275.76,126.83 275.45,126.83 275.28,126.9 275.13,127.06 275.13,129 274.81,129.31 274.81,129.46 274.48,129.79 274.48,130.32 274.85,130.7 275.07,130.7 275.33,130.96 275.33,132.15 275.83,132.65 275.83,134.25 275.36,134.72 275.36,135.08 275.83,135.55 275.83,136.04 272.92,138.96 272.79,138.96 272.47,138.63 272.47,138.51 274.91,136.06 274.91,135.94 274.6,135.63 274.44,135.63 272.69,137.39 272.03,137.39 271.86,137.57 271.86,139.11 272.3,139.56 272.3,139.88 271.86,140.32 271.86,146.23 259.1,158.99 259.1,166.74 251.84,174 244.76,174 244.52,174.25 v3(241.96,174.25)
M_DATA_A<7>: length 88
  TOP w0.165: v3(240.9,173.81) J3D1.AH39
  LAY2 w0.089: 274.93,124.17 274.91,124.15 274.91,123.64 274.47,122.54 J1F1.155 ; 274.93,124.17 274.98,124.22 274.98,125.49 274.48,125.99 274.48,126.52 274.71,126.76 274.71,127.39 274.91,127.59 274.91,128.12 274.6,128.43 274.6,128.94 274.06,129.48 274.06,130.54 274.91,131.39 274.91,134.27 272.42,136.76 272.29,136.76 271.97,136.44 271.97,136.31 274.2,134.09 274.2,133.96 273.89,133.66 273.73,133.66 271.22,136.16 271.22,145.97 258.47,158.73 258.47,166.48 251.58,173.37 244.69,173.37 244.31,173.74 242.3,173.74 242.24,173.81 v3(240.9,173.81) ; 274.93,124.17 274.52,124.59 274.34,124.59 274.23,124.7 274.23,124.99 274.43,125.19 274.43,125.44 274.26,125.93 274.26,127.85 J1E5.155
M_DATA_A<8>: length 76.2
  TOP w0.165: v3(240.9,171.12) J3D1.AK39
  LAY2 w0.089: J1F1.16 269.79,123.69 269.79,124.24 269.38,126.16 269.38,126.53 269.59,126.74 ; J1E5.16 270.02,130.06 270.3,129.53 270.3,129.32 270.21,129.22 269.74,129.22 269.65,129.13 269.65,128.93 269.75,128.83 269.95,128.83 270.02,128.76 270.02,127.31 270.11,127.22 270.11,127.02 270.02,126.93 269.77,126.93 269.59,126.74 ; 269.59,126.74 269.49,126.85 269.49,127.22 269.82,127.55 269.82,128.12 269.34,128.59 269.34,129.51 269.38,129.55 269.38,130.38 269.52,130.53 269.52,131.1 269.81,131.39 269.81,132.35 269.59,132.58 269.59,133.32 266.62,136.29 266.62,141.08 266.52,141.18 266.07,141.18 265.98,141.09 265.98,139.31 265.88,139.21 265.44,139.21 265.35,139.31 265.35,147.36 255.3,157.41 255.3,165.16 250.74,169.72 244.88,169.72 243.42,171.18 240.96,171.18 v3(240.9,171.12)
M_DATA_A<9>: length 74.7
  TOP w0.165: v3(241.96,170.73) J3D1.AL40
  LAY2 w0.089: 268.6,124.34 268.81,124.55 269.17,124.55 269.26,124.64 269.26,124.77 269.17,124.86 269.02,124.86 268.9,124.98 268.9,125.11 269.18,125.39 269.18,127.85 J1E5.161 ; 268.6,124.34 268.51,124.25 268.51,123.77 268.94,122.43 J1F1.161 ; 268.6,124.34 268.5,124.44 268.5,125.53 268.96,125.99 268.96,126.52 268.68,126.81 268.68,127.44 268.53,127.59 268.53,128.12 268.75,128.34 268.75,129.58 268.96,129.79 268.96,130.32 268.72,130.56 268.72,131.19 268.53,131.39 268.53,132.51 268.2,132.84 268.2,133.81 265.98,136.03 265.98,138.46 265.89,138.55 265.45,138.55 265.35,138.45 265.35,137.32 265.23,137.21 264.83,137.21 264.71,137.33 264.71,147.1 254.66,157.15 254.66,164.9 250.47,169.09 244.83,169.09 243.19,170.73 v3(241.96,170.73)
M_DATA_A<10>: length 75.2
  TOP w0.165: v3(240.9,168.47) J3D1.AN39
  LAY2 w0.089: J1F1.23 263.86,124.5 263.86,126.51 263.42,127.72 263.42,128.16 263.49,128.23 ; J1E5.23 264.07,129.43 264.19,129.31 264.19,129.2 264.1,129.11 263.81,129.11 263.72,129.01 263.72,128.88 263.81,128.79 264,128.79 264.09,128.71 264.09,128.59 264.02,128.52 263.78,128.52 263.49,128.23 ; 263.49,128.23 263.34,128.38 263.34,129.27 263.86,129.79 263.86,130.32 263.55,130.64 263.55,131.27 263.43,131.39 263.43,131.93 263.99,132.5 263.99,134.02 261.89,136.13 261.89,137.82 259.64,140.07 257.95,140.07 256.2,141.81 256.2,150.11 256.29,150.2 256.71,150.2 256.84,150.07 256.84,145.88 256.96,145.76 257.38,145.76 257.47,145.84 257.47,150.34 256.9,150.91 256.68,150.91 256.32,151.27 256.32,151.5 251.84,155.98 251.84,163.73 249.31,166.26 244.61,166.26 242.8,168.08 242.36,168.08 242.12,168.32 241.33,168.32 241.18,168.47 v3(240.9,168.47)
M_DATA_A<11>: length 76.1
  TOP w0.165: v3(239.98,168.47) J3D1.AN38
  LAY2 w0.089: 262.56,122.56 263.41,123.41 263.41,124.45 263.22,124.64 J1E5.168 ; 262.56,122.56 262.39,122.73 262.39,123.02 262.99,123.62 262.99,124.15 262.78,124.37 262.78,125.79 262.58,125.99 262.58,126.52 262.72,126.66 262.72,127.3 263.01,127.59 263.01,128.12 262.81,128.32 262.81,129.55 262.58,129.79 262.58,130.32 262.9,130.64 262.9,131.28 263.01,131.39 263.01,132.25 263.35,132.59 263.35,133.66 258.68,138.34 258.68,138.46 259,138.79 259.13,138.79 260.79,137.12 260.95,137.12 261.25,137.43 261.25,137.55 259.41,139.4 258.46,139.4 258.24,139.18 257.84,139.18 255.57,141.45 255.57,151.35 251.2,155.71 251.2,163.47 249.04,165.63 244.56,165.63 242.67,167.51 241.68,167.51 241.2,167.99 240.69,167.99 240.21,168.47 v3(239.98,168.47) ; 262.56,122.56 262.56,122.1 262.99,120.17 J1F1.168
M_DATA_A<12>: length 75.8
  TOP w0.165: v3(239.98,171.14) J3D1.AK38
  LAY2 w0.089: v3(239.98,171.14) 239.98,171.75 240.61,172.38 241.13,172.38 241.42,172.09 242.48,172.09 243.87,172.09 244.97,170.99 251.26,170.99 256.56,165.69 256.56,157.94 266.62,147.89 266.62,144.93 267.88,143.67 267.88,136.82 271.52,133.18 271.52,132.72 271.44,132.64 271.44,132.22 271.52,132.14 271.52,131.3 271.31,131.09 271.31,130.56 271.08,130.32 271.08,129.79 271.12,129.75 271.12,128.51 271.51,128.12 271.51,127.59 271.19,127.27 271.19,126.85 271.29,126.74 ; 271.29,126.74 271.48,126.93 271.94,126.93 272.04,127.03 272.04,127.4 271.93,127.51 271.93,128.44 271.72,128.65 271.72,128.91 271.66,128.98 271.52,128.98 271.43,129.07 271.43,129.21 271.53,129.31 271.79,129.31 271.89,129.41 271.89,129.54 J1E5.14 ; 271.29,126.74 271.08,126.52 271.08,126.16 271.49,124.24 271.49,123.69 J1F1.14
M_DATA_A<13>: length 76.5
  TOP w0.165: v3(241.96,171.65) J3D1.AK40
  LAY2 w0.089: J1F1.159 270.64,122.43 270.21,123.77 270.21,124.25 270.3,124.34 ; v3(241.96,171.65) 243.64,171.65 244.93,170.36 251,170.36 255.93,165.42 255.93,157.67 265.98,147.62 265.98,142.44 266.08,142.33 266.52,142.33 266.62,142.43 266.62,143.41 266.71,143.51 267.15,143.51 267.25,143.4 267.25,136.55 270.23,133.57 270.23,132.84 270.23,132.84 270.23,131.39 270.38,131.24 270.38,130.6 270.66,130.32 270.66,129.69 270.64,129.66 270.64,128.53 270.23,128.12 270.23,127.58 270.44,127.37 270.44,126.74 270.67,126.52 270.67,125.98 270.2,125.51 270.2,124.44 270.3,124.34 ; 270.3,124.34 270.51,124.55 270.87,124.55 270.96,124.64 270.96,124.77 270.87,124.86 270.72,124.86 270.6,124.98 270.6,125.11 270.88,125.39 270.88,127.85 J1E5.159
M_DATA_A<14>: length 72
  TOP w0.165: v3(241.96,169.74) J3D1.AM40
  LAY2 w0.089: J1F1.21 265.56,124.52 265.56,126.6 265.13,127.73 265.13,128.07 265.18,128.12 265.18,128.22 ; 265.18,128.22 265.09,128.22 264.97,128.34 264.97,129.2 265.56,129.79 265.56,130.32 265.28,130.6 265.28,131.24 265.13,131.39 265.13,131.95 265.77,132.59 265.77,134.04 263.16,136.65 263.16,144.77 262.54,145.38 262.54,146.87 262.44,146.97 262.01,146.97 261.91,146.87 261.91,146.66 261.82,146.57 261.36,146.57 261.28,146.66 261.28,148.15 261.18,148.24 260.74,148.24 260.64,148.14 260.64,147.4 260.54,147.31 260.11,147.31 260.01,147.41 260.01,149.32 259.9,149.43 259.46,149.43 259.37,149.34 259.37,148.14 259.29,148.05 258.84,148.05 258.74,148.15 258.74,150.87 253.11,156.5 253.11,164.25 249.83,167.53 244.71,167.53 242.84,169.41 242.29,169.41 v3(241.96,169.74) ; 265.18,128.22 265.22,128.22 265.63,128.63 265.87,128.63 265.96,128.72 265.96,128.87 265.88,128.95 265.69,128.95 265.6,129.04 265.6,129.18 265.69,129.27 265.85,129.27 265.97,129.39 265.97,131.07 J1E5.21
M_DATA_A<15>: length 71.7
  TOP w0.165: v3(241.96,168.75) J3D1.AN40
  LAY2 w0.089: 264.26,122.56 264.89,123.19 265.11,123.41 265.11,124.47 264.92,124.66 J1E5.166 ; 264.26,122.56 264.26,122.1 264.69,120.17 J1F1.166 ; 264.26,122.56 264.15,122.56 263.99,122.71 263.99,122.92 264.69,123.62 264.69,124.15 264.43,124.41 264.43,125.84 264.28,125.99 264.28,126.52 264.47,126.72 264.47,127.35 264.71,127.59 264.71,128.11 264.59,128.24 264.59,129.48 264.28,129.79 264.28,130.32 264.61,130.66 264.61,131.29 264.71,131.39 264.71,132.44 264.87,132.59 264.87,134.04 262.52,136.39 262.52,144.49 260.61,146.4 259.49,146.4 259.37,146.51 259.37,147.2 259.2,147.37 258.92,147.37 258.74,147.2 258.74,146.72 258.65,146.63 258.21,146.63 258.11,146.73 258.11,150.6 252.47,156.24 252.47,163.99 249.57,166.9 244.66,166.9 242.8,168.76 v3(241.96,168.75)
M_DATA_A<16>: length 63.3
  TOP w0.165: v3(241.96,166.09) J3D1.AT40
  LAY2 w0.089: v3(241.96,166.09) 241.96,165.82 242.39,165.39 242.39,165.15 243.41,164.13 243.58,164.13 244.28,163.43 244.28,161.97 245.57,158.56 253.54,150.59 253.54,138.7 255.82,136.42 255.95,136.42 256.23,136.71 256.23,136.84 254.07,139 254.07,139.21 254.38,139.52 254.51,139.52 259.68,134.35 259.68,132.84 260.03,132.49 260.03,131.39 260.14,131.27 260.14,130.64 260.46,130.32 260.46,129.79 259.91,129.24 259.91,128.41 260.03,128.23 ; 260.03,128.23 260.09,128.23 260.38,128.52 260.62,128.52 260.69,128.59 260.69,128.71 260.6,128.79 260.41,128.79 260.32,128.88 260.32,129.01 260.41,129.11 260.68,129.11 260.77,129.19 260.77,129.32 260.67,129.43 J1E5.27 ; 260.03,128.23 260.03,127.69 260.46,126.51 260.46,124.5 J1F1.27
M_DATA_A<17>: length 62.9
  TOP w0.165: v3(241.96,165.18) J3D1.AU40
  LAY2 w0.089: J1F1.172 259.59,120.17 259.16,122.1 259.16,122.56 ; J1E5.172 259.82,124.65 260.01,124.46 260.01,123.41 259.16,122.56 ; 259.16,122.56 259.04,122.68 259.04,123.06 259.59,123.62 259.59,124.15 259.31,124.44 259.31,125.86 259.18,125.99 259.18,126.52 259.42,126.76 259.42,127.4 259.61,127.59 259.61,128.12 259.13,129.91 259.13,130.27 259.61,131.39 259.61,132.02 259.05,132.58 259.05,134.09 257.06,136.07 256.94,136.07 256.63,135.77 256.63,135.61 257.24,135 257.24,134.88 256.97,134.61 256.73,134.61 252.9,138.44 252.9,150.33 245.03,158.21 243.65,161.86 243.65,163.17 241.96,164.86 v3(241.96,165.18)
M_DATA_A<18>: length 63.7
  TOP w0.165: v3(239.98,162.79) J3D1.AW38
  LAY2 w0.089: v3(239.98,162.79) 240.76,162.02 240.76,161.36 242.58,156.52 247.54,151.56 247.54,146.65 247.63,146.56 248.07,146.56 248.18,146.67 248.18,150.38 248.27,150.47 248.63,150.47 248.81,150.3 248.81,138.52 249.03,138.3 249.31,138.3 249.44,138.44 249.44,139.32 249.53,139.41 249.99,139.41 250.08,139.32 250.08,137.26 254.93,132.41 254.93,131.17 254.08,130.32 254.08,129.79 254.21,129.66 254.21,129.05 254.73,128.53 254.73,127.01 254.8,126.94 255.01,126.86 255.09,126.86 ; 255.09,126.86 255.09,127.43 254.93,127.59 254.93,128.12 255.09,128.28 255.09,128.42 255.2,128.53 255.46,128.53 255.55,128.62 255.55,128.74 255.46,128.83 254.83,128.83 254.74,128.92 254.74,129.04 254.83,129.13 255.04,129.13 255.09,129.18 255.09,129.35 J1E5.34 ; 255.09,126.86 255.36,126.53 255.36,125.98 254.91,123.98 254.91,123.5 254.85,123.1 J1F1.34
M_DATA_A<19>: length 63.2
  TOP w0.165: v3(239.98,166.64) J3D1.AR38
  LAY2 w0.089: 254.53,124.17 254.08,124.63 253.98,124.63 253.66,124.95 253.66,126.77 253.87,126.98 J1E5.179 ; 254.53,124.17 254.51,124.15 254.51,123.64 254.07,122.54 J1F1.179 ; 254.53,124.17 254.58,124.22 254.58,124.73 254.44,124.88 254.44,125.63 254.08,125.99 254.08,126.52 254.27,126.71 254.27,127.35 254.51,127.59 254.51,128.12 254.13,128.5 253.96,128.5 253.66,128.8 253.66,130.54 254.51,131.39 254.51,131.92 248.18,138.26 248.18,145.76 248.09,145.85 247.63,145.85 247.54,145.76 247.54,144.5 247.42,144.38 247,144.38 246.91,144.47 246.91,151.29 241.99,156.21 240.12,161.16 240.12,161.95 239.37,162.71 239.37,162.93 239.13,163.16 239.08,163.16 238.64,163.6 238.64,163.93 238.67,163.96 238.67,165.9 239,166.24 239.23,166.24 239.63,166.64 v3(239.98,166.64)
M_DATA_A<20>: length 65.5
  TOP w0.165: v3(241.96,167) J3D1.AR40
  LAY2 w0.089: v3(241.96,167) 242.31,167 244.09,165.23 244.28,165.23 245.55,163.96 245.55,162.2 246.64,159.33 249.17,156.8 249.29,156.8 249.62,157.12 249.62,157.24 247.54,159.32 247.54,159.52 247.82,159.81 247.95,159.81 250.38,157.38 250.38,155.59 254.8,151.16 254.8,141.02 262.34,133.49 262.34,132.57 261.73,131.95 261.73,131.39 261.84,131.27 261.84,130.7 262,130.54 262.17,130.38 262.17,129.79 261.57,129.2 261.57,128.43 261.73,128.23 ; 261.73,128.23 261.73,127.75 262.16,126.52 262.16,124.52 J1F1.25 ; 261.73,128.23 261.78,128.23 262.07,128.52 262.3,128.52 262.39,128.6 262.39,128.71 262.3,128.79 262.11,128.79 262.02,128.88 262.02,129.01 262.11,129.11 262.38,129.11 262.47,129.19 262.47,129.33 262.37,129.43 J1E5.25
M_DATA_A<21>: length 63.2
  TOP w0.165: v3(240.9,166.64) J3D1.AR39
  LAY2 w0.089: v3(240.9,166.64) 240.96,166.57 242.06,166.57 242.49,166.15 242.49,166 243.77,164.72 243.9,164.72 244.92,163.7 244.92,162.09 246.11,158.94 254.17,150.87 254.17,140.76 261.31,133.62 261.31,133.27 261.21,133.17 261.21,132.72 261.31,132.62 261.31,131.39 261.21,131.29 261.21,130.66 260.88,130.32 260.88,129.79 261.19,129.48 261.19,128.3 261.31,128.17 261.31,127.59 261.2,127.48 261.2,126.84 260.88,126.52 260.88,125.99 261.03,125.84 261.03,124.41 261.29,124.15 261.29,123.57 260.55,122.83 260.55,122.69 260.68,122.56 260.86,122.56 ; 260.86,122.56 260.86,122.1 261.29,120.17 J1F1.170 ; 260.86,122.56 261.71,123.41 261.71,124.5 261.52,124.69 J1E5.170
M_DATA_A<22>: length 63.6
  TOP w0.165: v3(240.9,163.8) J3D1.AV39
  LAY2 w0.089: v3(240.9,163.8) 242.02,162.68 242.02,161.66 243.71,157.19 250.08,150.82 250.08,144.48 250.18,144.38 250.61,144.38 250.71,144.48 250.71,148.73 250.8,148.82 251.26,148.82 251.35,148.73 251.35,137.8 256.63,132.52 256.63,130.96 256.37,130.7 256.15,130.7 255.78,130.32 255.78,129.79 256.11,129.46 256.11,129.31 256.43,129 256.43,127.06 256.58,126.9 256.75,126.83 257.06,126.83 ; 257.06,126.83 257.07,126.83 257.07,127.15 256.63,127.59 256.63,128.12 257,128.5 257.2,128.5 257.29,128.59 257.29,128.76 257.22,128.83 256.82,128.83 256.75,128.91 256.75,129.11 256.84,129.2 256.84,129.35 256.77,129.42 256.51,129.42 256.42,129.51 J1E5.32 ; 257.06,126.83 257.06,126.06 256.61,124.02 256.61,123.58 J1F1.32
M_DATA_A<23>: length 63.2
  TOP w0.165: J3D1.AV38 240.02,163.8 240.03,163.79 v3(240.04,163.79)
  LAY2 w0.089: v3(240.04,163.79) 240.04,163.74 241.39,162.4 241.39,161.52 243.16,156.85 249.44,150.56 249.44,140.42 249.55,140.32 249.98,140.32 250.08,140.41 250.08,143.5 250.17,143.59 250.62,143.59 250.71,143.5 250.71,137.53 256.21,132.04 256.21,131.39 255.36,130.54 255.36,129.48 255.9,128.94 255.9,128.43 256.21,128.12 256.21,127.59 256.01,127.39 256.01,126.76 255.78,126.52 255.78,125.99 256.28,125.49 256.28,124.22 256.23,124.17 ; 256.23,124.17 256.21,124.15 256.21,123.64 255.77,122.54 J1F1.177 ; 256.23,124.17 255.82,124.59 255.64,124.59 255.53,124.7 255.53,124.99 255.73,125.19 255.73,125.44 255.56,125.93 255.56,127.85 J1E5.177
