# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TP_VCCGT_PH1_CSP: length 186.2
  TOP w0.1: R1E7.1 v1(286.25,158.88)
  LAY3 w0.1: 286.25,159.24 286.15,159.34 286.01,159.34 285.75,159.08 285.75,158.49 286.76,157.48 288.96,157.48 290.7,155.74 290.7,141.73 290.32,141.35 290.32,138.17 291.21,137.29 291.21,111.12 291.97,110.36 291.97,106.55 291.21,105.79 291.21,98.3 290.7,97.79 290.7,88.31 290.07,87.68 288.27,87.68 288.13,87.54 288.13,87.4 v1(288.41,87.12) ; 286.25,159.24 v1(286.25,158.88) ; 286.25,159.24 286.35,159.34 286.63,159.34 287.09,159.81 287.09,160.74 286.47,161.37 284.78,161.37 284.35,161.8 284.35,164.59 287.02,167.26 287.02,175 286.51,175.51 286.51,178.43 285.62,179.32 285.62,182.5 286.38,183.26 286.38,188.97 283.97,191.39 272.95,191.39 271.94,192.4 269.07,192.4 268.6,191.93 268.6,188.94 270.25,187.29 270.25,184.71 269.98,184.44 269.84,184.44 269.74,184.54 R2P3.3
  LAY8 w0.1: v1(272.79,52.96) 272.36,52.96 272.26,53.06 272.26,53.57 273.55,54.86 273.55,58.76 275.16,60.37 275.16,61.89 282.52,69.26 282.52,73.32 283.29,74.09 284.56,74.09 286.08,75.61 286.08,85.26 287.22,86.4 287.91,86.4 288.13,86.62 288.13,86.84 v1(288.41,87.12)
TP_VCCGT_PH1_EAC_CSN: length 3.1
  TOP w0.1: U1E1.C1 289.61,160.82 289.45,160.82 289.05,160.42 289.05,159.85 288.74,159.55 288.38,159.55 R1E5.2
TP_VCCGT_PH1_EAC_CSP: length 3
  TOP w0.1: U1E1.D1 289.74,160.62 289.53,160.62 289.25,160.34 289.25,159.77 288.83,159.35 288.37,159.35 R1E7.2
TP_VCCGT_PH2_CSN: length 147.2
  TOP w0.1: R1E13.1 v1(290.95,157.22)
  LAY3 w0.1: v1(285.24,162.81) 285.54,163.12 286.59,163.12 291.42,158.28 291.42,157.69 v1(290.95,157.22) 291.42,156.76 291.42,138.81 292.78,137.45 292.78,122.34 293.16,121.96 293.16,121.37 292.91,121.11 292.91,116.5 293.54,115.86 293.54,114.21 294.18,113.58 294.18,104.6 293.67,104.1 293.67,101.13 294.18,100.62 294.18,99.91 293.72,99.45 293.72,88.02 292.31,86.61 288.19,86.61 287.93,86.36 287.93,86.13 v1(287.65,85.85)
  LAY8 w0.1: R2P5.4 269.62,174.23 269.72,174.33 269.86,174.33 270.38,173.81 270.38,166.88 271.39,165.86 281.3,165.86 284.05,163.12 284.93,163.12 v1(285.24,162.81) ; v1(278.51,61.09) 278.07,61.09 277.97,60.99 277.97,60.68 277.62,60.32 276.73,60.32 276.35,60.7 276.35,62.26 285.16,71.08 285.16,73.74 286.68,75.27 286.68,84.79 287.18,85.29 287.79,85.29 287.93,85.43 287.93,85.57 v1(287.65,85.85)
TP_VCCGT_PH2_CSP: length 146.9
  TOP w0.1: R1E14.1 v1(292.1,157.22)
  LAY3 w0.1: v1(288.41,85.85) 288.13,86.13 288.13,86.27 288.27,86.41 292.4,86.41 293.92,87.93 293.92,99.36 294.38,99.82 294.38,100.71 293.87,101.22 293.87,104.01 294.38,104.52 294.38,113.66 293.75,114.3 293.75,115.95 293.11,116.58 293.11,121.03 293.37,121.28 293.37,122.05 292.98,122.43 292.98,137.54 291.63,138.9 291.63,156.76 v1(292.1,157.22) 291.63,157.69 291.63,158.36 286.67,163.32 285.54,163.32 v1(285.24,163.62)
  LAY8 w0.1: v1(285.24,163.62) 284.93,163.32 284.13,163.32 281.39,166.07 271.48,166.07 270.58,166.96 270.58,173.9 269.94,174.54 269.72,174.54 269.62,174.64 R2P5.3 ; v1(277.24,61.09) 277.67,61.09 277.77,60.99 277.77,60.77 277.53,60.53 276.81,60.53 276.55,60.79 276.55,62.18 285.36,70.99 285.36,73.66 286.89,75.18 286.89,84.71 287.27,85.09 287.88,85.09 288.13,85.35 288.13,85.57 v1(288.41,85.85)
TP_VCCGT_PH2_EAC_CSN: length 2.6
  TOP w0.1: R1E13.2 291.49,159.41 291.49,159.55 291.25,159.79 290.77,159.79 290.5,160.07 290.5,160.36 U1E1.D2
TP_VCCGT_PH2_EAC_CSP: length 2.6
  TOP w0.1: R1E14.2 291.69,159.29 291.69,159.64 291.33,159.99 290.85,159.99 290.69,160.15 290.69,160.41 U1E1.D3
TP_VCCGT_VIN_CSN: length 223.4
  TOP w0.1: R3H26.1 v1(224.91,53.72)
  LAY6 w0.115: v1(224.91,53.72) 224.91,53.38 225.03,53.26 226.54,53.26 232.44,59.16 246.53,59.16 250.72,63.34 250.72,64.36 254.28,67.92 263.11,67.92 263.49,67.54 282.79,67.54 283.43,66.9 284.18,66.9 v1(284.48,67.2)
  LAY8 w0.1: R2C32.4 272.41,202.17 272.31,202.27 271.99,202.27 271.39,201.67 271.39,201.04 271.9,200.53 278.51,200.53 282.32,196.72 283.75,196.72 290.27,190.2 290.27,169.62 287.95,167.31 287.95,163.7 288.34,163.32 288.34,148 287.04,146.71 287.04,142.62 287.98,141.69 287.98,139.4 287.04,138.47 287.04,93.06 289.17,90.93 289.17,76.45 286.13,73.4 286.13,70.02 283.92,67.82 283.92,66.99 284.02,66.89 284.16,66.89 v1(284.48,67.2)
TP_VCCGT_VIN_CSP: length 224.1
  TOP w0.1: R3H34.1 v1(224.91,52.58)
  LAY6 w0.115: v1(284.48,66.37) 284.18,66.67 283.33,66.67 282.7,67.31 263.39,67.31 263.01,67.69 254.38,67.69 250.95,64.26 250.95,63.24 246.63,58.93 232.53,58.93 226.64,53.03 225.03,53.03 224.91,52.92 v1(224.91,52.58)
  LAY8 w0.1: v1(284.48,66.37) 284.16,66.69 283.94,66.69 283.71,66.91 283.71,67.9 285.92,70.11 285.92,73.49 288.97,76.54 288.97,90.85 286.84,92.98 286.84,138.55 287.77,139.49 287.77,141.6 286.84,142.54 286.84,146.8 288.13,148.09 288.13,163.24 287.75,163.62 287.75,167.39 290.06,169.71 290.06,190.12 283.66,196.52 282.23,196.52 278.42,200.33 271.82,200.33 271.19,200.95 271.19,201.76 271.91,202.48 272.31,202.48 272.41,202.58 R2C32.3
TP_VCCGT_VIN_EAC_CSN: length 2.4
  TOP w0.1: U3H2.C1 228.35,53.72 227.88,53.72 227.32,53.16 227.13,53.16 R3H26.2
TP_VCCGT_VIN_EAC_CSP: length 2.4
  TOP w0.1: U3H2.D1 228.31,53.52 227.96,53.52 227.4,52.96 226.94,52.96 R3H34.2
TP_VCCIO_0_EAC_NEG: length 2.8
  TOP w0.1: R3H11.2 229.6,56.66 229.6,56.27 229.23,55.91 229.23,55.1 U3H2.A2
TP_VCCIO_0_EAC_POS: length 2.7
  TOP w0.1: R3H12.2 229.8,56.7 229.8,56.19 229.43,55.82 229.43,54.9 U3H2.A3
TP_VCCIO_0_NEG: length 456.7
  TOP w0.1: R3H11.1 v1(229.1,58.8)
  LAY3 w0.1: v1(234.62,71.5) 234.51,71.5 234.26,71.75 234.26,71.97 234.01,72.21 218.99,72.21 218.41,72.79 198.99,72.79 198.41,72.21 178.9,72.21 173.82,77.29 170.64,77.29 169.63,78.31 169.31,78.31 168.98,78.64 168.65,78.97 168.65,79.12 166.62,81.15 166.62,81.54 165.88,82.27 159.86,82.27 157.98,80.39 135.16,80.39 124.84,90.71 124.84,115.06 134.74,124.97 134.74,131.06 150.36,146.68 150.36,154.52 153.41,157.57 153.41,159.98 156.16,162.73 156.67,162.73 157.17,163.24 157.17,166.37 159,168.2 159,168.75 160.75,170.5 164.15,170.5 170.83,177.18 170.83,181.32 172.16,182.65 174.3,182.65 176.02,184.37 176.02,190.92 176.32,191.22 176.4,191.22 176.53,191.09 R4D1.4
  LAY8 w0.1: v1(90.17,9.65) 90.44,9.37 90.67,9.37 90.89,9.15 90.89,7.66 93.77,4.78 97.45,4.78 98.8,3.43 101.85,3.43 103.93,5.51 115.01,5.51 118.28,2.24 145.77,2.24 149.25,5.71 150.49,5.71 161.13,16.35 161.13,41.91 166.49,47.27 181.98,47.27 185.51,50.8 195.32,50.8 198.16,47.96 204.71,47.96 206.16,49.4 223.64,49.4 229.57,55.33 229.57,58.7 229.47,58.8 v1(229.1,58.8)
  BOTTOM w0.1: v1(229.1,58.8) 229.47,58.8 229.57,58.7 229.57,58.48 229.96,58.09 232.11,58.09 235.07,61.06 235.07,64.77 232.28,67.56 232.28,69.85 233.04,70.61 234.06,70.61 234.31,70.86 234.31,71.19 v1(234.62,71.5)
TP_VCCIO_0_POS: length 456.1
  TOP w0.1: R3H12.1 v1(230.25,58.8)
  LAY3 w0.1: v1(233.8,71.5) 234.06,71.75 234.06,71.88 233.93,72.01 218.91,72.01 218.33,72.59 199.08,72.59 198.5,72.01 178.81,72.01 173.73,77.09 170.56,77.09 169.54,78.1 169.23,78.1 168.45,78.88 168.45,79.03 166.41,81.07 166.41,81.45 165.8,82.07 159.95,82.07 158.06,80.18 135.07,80.18 129.85,85.41 124.63,90.63 124.63,115.15 134.54,125.05 134.54,131.15 150.16,146.77 150.16,154.61 153.21,157.65 153.21,160.07 156.08,162.94 156.59,162.94 156.97,163.32 156.97,166.45 158.79,168.28 158.79,168.83 160.67,170.7 164.06,170.7 170.62,177.27 170.62,181.41 172.07,182.86 174.22,182.86 175.81,184.45 175.81,191 176.24,191.43 176.4,191.43 176.53,191.55 R4D1.3
  LAY8 w0.1: v1(230.25,58.8) 229.88,58.8 229.78,58.7 229.78,55.25 223.73,49.2 206.24,49.2 204.8,47.75 198.08,47.75 195.24,50.59 185.59,50.59 182.06,47.07 166.58,47.07 161.33,41.82 161.33,16.27 150.58,5.51 149.33,5.51 145.86,2.03 118.2,2.03 114.92,5.3 104.02,5.3 101.93,3.22 98.72,3.22 97.37,4.57 93.69,4.57 90.69,7.57 90.69,9.07 90.59,9.17 90.44,9.17 v1(90.17,8.89)
  BOTTOM w0.1: v1(233.8,71.5) 234.11,71.19 234.11,70.95 233.97,70.81 232.96,70.81 232.08,69.93 232.08,67.48 234.87,64.69 234.87,61.14 233.45,59.72 232.02,58.29 230.04,58.29 229.77,58.56 229.77,58.7 229.87,58.8 v1(230.25,58.8)
TP_VCCIO_1_2_EAC_NEG: length 2.3
  TOP w0.1: R3H24.2 226.82,55.12 227.2,55.12 227.83,54.48 228.35,54.48 U3H2.B1
TP_VCCIO_1_2_EAC_POS: length 2.6
  TOP w0.1: U3H2.A1 228.31,54.68 227.92,54.68 227.28,55.32 227.13,55.32 226.56,55.89 R3H20.2
TP_VCCIO_1_2_NEG: length 355.6
  TOP w0.1: R3H24.1 v1(224.91,54.86)
  LAY8 w0.1: v1(91.44,9.65) 91.71,9.37 92.03,9.37 92.25,9.15 92.25,7.57 94.36,5.46 98.08,5.46 99.47,4.06 101.47,4.06 103.5,6.1 115.44,6.1 118.71,2.82 139.22,2.82 140.08,3.68 140.08,4.19 141.22,5.33 142.62,5.33 145.57,8.29 152.05,8.29 160.27,16.51 160.27,42.54 166.44,48.72 181.56,48.72 183.26,50.42 184.36,50.42 185.51,51.56 195.99,51.56 198.93,48.62 204.37,48.62 205.86,50.11 209.59,50.11 210.35,50.88 224.19,50.88 226.1,52.79 226.1,54.94 225.75,55.29 225.34,55.29 v1(224.91,54.86) 224.91,55.23 224.81,55.33 210.1,55.33 206.63,58.8 199.1,58.8 192.62,65.28 179.54,65.28 175.55,69.26 171.87,69.26 166.03,75.1 166.03,77.38 165.27,78.15 165.27,80.05 159.47,85.85 156.21,85.85 149.27,92.79 149.27,107.69 148.25,108.71 148.25,130.48 148.71,130.94 148.71,134.91 147.44,136.18 147.44,142.11 157.73,152.4 157.73,154.18 159.13,155.57 159.13,159.26 161.29,161.42 162.5,161.42 162.72,161.2 162.72,160.75 162.82,160.65 R5E1.4
TP_VCCIO_1_2_POS: length 355.3
  TOP w0.1: R3H20.1 v1(224.91,56.01)
  LAY8 w0.1: R5E1.3 162.42,160.65 162.52,160.75 162.52,161.11 162.42,161.21 161.37,161.21 159.33,159.17 159.33,155.49 157.93,154.09 157.93,152.31 147.65,142.03 147.65,136.27 148.92,135 148.92,130.85 148.46,130.39 148.46,108.8 149.47,107.78 149.47,92.87 156.29,86.06 159.56,86.06 165.48,80.14 165.48,78.23 166.24,77.47 166.24,75.18 171.95,69.47 175.64,69.47 179.62,65.48 192.7,65.48 199.18,59 206.71,59 210.18,55.54 224.81,55.54 224.91,55.64 v1(224.91,56.01) 225.42,55.5 225.84,55.5 226.31,55.03 226.31,52.7 224.28,50.67 210.43,50.67 209.67,49.91 205.95,49.91 204.45,48.41 198.84,48.41 197.31,49.94 195.9,51.36 185.59,51.36 184.45,50.21 183.34,50.21 181.64,48.51 166.53,48.51 160.47,42.46 160.47,16.42 152.13,8.08 145.66,8.08 142.7,5.13 141.3,5.13 140.28,4.1 140.28,3.6 139.3,2.62 118.63,2.62 115.35,5.89 103.59,5.89 101.55,3.86 99.39,3.86 97.99,5.25 94.27,5.25 92.04,7.48 92.04,9.07 91.94,9.17 91.71,9.17 v1(91.44,8.89)
TP_VCCSA_CSN: length 286.2
  TOP w0.1: R2E2.1 v1(280.03,159.26)
  LAY3 w0.1: v1(287.65,88.39) 287.93,88.67 287.93,88.9 288.19,89.15 289.3,89.15 289.43,89.28 289.43,140.56 288.41,141.58 288.41,142.82 288.72,143.13 288.72,155.23 287.89,156.06 286.65,156.06 284.6,158.11 281.05,158.11 280.5,158.66 280.5,159.16 280.4,159.26 v1(280.03,159.26)
  LAY8 w0.1: R4B41.4 178.18,243.32 178.28,243.42 178.85,243.42 179.37,242.9 179.37,229.4 180.13,228.64 180.13,227.24 182.16,225.22 183.33,225.22 189.35,219.2 249.93,219.2 255.52,213.61 259.58,213.61 261.82,211.38 261.82,195.72 262.5,195.04 262.5,190.4 261.82,189.72 261.82,178.12 265.98,173.95 265.98,171.49 266.74,170.73 266.74,167.46 268.6,165.61 269.62,165.61 275.46,159.76 280.23,159.76 280.5,159.5 280.5,159.36 280.4,159.26 v1(280.03,159.26) ; v1(271.52,62.61) 271.95,62.61 272.05,62.71 272.05,62.94 272.44,63.32 275.03,63.32 278.51,66.8 278.51,68.96 281.55,72.01 281.55,75.39 285.16,79 285.16,86.66 286.33,87.83 287.79,87.83 287.93,87.97 287.93,88.11 v1(287.65,88.39)
TP_VCCSA_CSP: length 286.5
  TOP w0.1: R1E9.1 v1(281.17,159.26)
  LAY3 w0.1: v1(288.41,88.39) 288.13,88.67 288.13,88.81 288.27,88.95 289.39,88.95 289.63,89.19 289.63,140.65 288.62,141.66 288.62,142.74 288.92,143.04 288.92,155.32 287.97,156.27 286.74,156.27 284.69,158.32 281.13,158.32 280.7,158.75 280.7,159.16 280.8,159.26 v1(281.17,159.26)
  LAY8 w0.1: v1(272.79,62.61) 272.36,62.61 272.26,62.71 272.26,62.85 272.53,63.12 275.11,63.12 278.71,66.72 278.71,68.87 281.76,71.92 281.76,75.31 285.36,78.91 285.36,86.58 286.42,87.63 287.88,87.63 288.13,87.89 288.13,88.11 v1(288.41,88.39) ; R4B41.3 178.18,243.72 178.28,243.62 178.94,243.62 179.57,242.99 179.57,229.49 180.34,228.73 180.34,227.33 182.24,225.42 183.42,225.42 189.44,219.41 250.02,219.41 255.6,213.82 259.67,213.82 262.02,211.46 262.02,195.8 262.71,195.12 262.71,190.32 262.02,189.64 262.02,178.2 266.19,174.04 266.19,171.58 266.95,170.81 266.95,167.55 268.69,165.81 269.7,165.81 275.54,159.97 280.32,159.97 280.7,159.58 280.7,159.36 280.8,159.26 v1(281.17,159.26)
TP_VCCSA_EAC_CSN: length 3.8
  TOP w0.1: R2E2.2 280.26,157.61 280.48,157.39 280.48,156.95 280.72,156.72 281.27,156.72 282.39,155.6 282.39,155.5 U1E2.B1
TP_VCCSA_EAC_CSP: length 3.3
  TOP w0.1: U1E2.A1 282.46,155.82 281.35,156.92 280.8,156.92 280.68,157.04 280.68,157.37 280.92,157.61 R1E9.2
TP_VDDQ_CSN: length 135.5
  TOP w0.1: R4H17.1 v1(199.26,57.4)
  LAY3 w0.1: v1(287.65,82.04) 287.93,82.32 287.93,82.46 287.83,82.56 285.29,82.56 283.88,81.15 277.87,81.15 274.06,77.34 267.97,77.34 266.7,78.61 262.12,78.61 258.44,82.29 256.41,82.29 249.67,89.04 249.43,89.04 249,89.46 249,89.69 248.9,89.79 R2G2.4
  BOTTOM w0.1: v1(199.26,57.4) 199.63,57.4 199.73,57.5 199.73,57.73 200.37,58.36 204.9,58.36 212.34,50.93 215.39,50.93 221.23,56.77 233.68,56.77 235.96,59.05 235.96,65.53 233.17,68.32 233.17,69.12 233.59,69.54 240.35,69.54 245.99,75.18 245.99,83.85 249.01,86.86 249.01,89.69 248.91,89.79 R2G2.4
TP_VDDQ_CSP: length 135.5
  TOP w0.1: v1(200.4,57.4) R4H18.1
  LAY3 w0.1: v1(288.41,82.04) 288.13,82.32 288.13,82.55 287.91,82.77 285.2,82.77 283.79,81.36 277.79,81.36 273.98,77.55 268.05,77.55 266.84,78.76 266.78,78.82 262.21,78.82 258.53,82.5 256.49,82.5 249.75,89.24 249.51,89.24 249.21,89.55 249.21,89.69 249.31,89.79 R2G2.3
  BOTTOM w0.1: R2G2.3 249.31,89.79 249.21,89.69 249.21,86.78 246.19,83.76 246.19,75.1 240.44,69.34 233.68,69.34 233.37,69.03 233.37,68.41 236.16,65.61 236.16,58.97 233.76,56.57 221.31,56.57 215.47,50.73 212.26,50.73 204.82,58.16 200.45,58.16 199.93,57.64 199.93,57.5 200.03,57.4 v1(200.4,57.4)
TP_VDDQ_EAC_CSN: length 3.8
  TOP w0.1: U4H2.B1 200.41,54.86 199.94,54.86 199.71,55.1 199.71,55.53 199.49,55.75 R4H17.2
TP_VDDQ_EAC_CSP: length 3.3
  TOP w0.1: R4H18.2 200.15,55.75 199.91,55.51 199.91,55.18 200.03,55.06 200.49,55.06 201.59,53.96 U4H2.A1
TP_VPP_CSN: length 92.6
  TOP w0.1: v1(202.94,49.1) R4H45.1
  LAY8 w0.1: R5F13.4 146.17,106.03 146.27,106.13 146.5,106.13 146.68,105.95 146.68,93.82 156.3,84.2 158.84,84.2 160.78,82.26 160.78,77.85 173.6,65.02 177.41,65.02 178.68,63.75 185.8,63.75 189.92,59.63 193.48,59.63 203.41,49.69 203.41,49.2 203.31,49.1 v1(202.94,49.1)
TP_VPP_CSP: length 93
  TOP w0.1: v1(204.08,49.1) R4H46.1
  LAY8 w0.1: v1(204.08,49.1) 203.72,49.1 203.62,49.2 203.62,49.78 193.56,59.83 190.01,59.83 185.88,63.96 178.77,63.96 177.5,65.23 173.69,65.23 160.98,77.93 160.98,82.34 158.92,84.4 156.38,84.4 146.89,93.9 146.89,106.03 146.58,106.34 146.27,106.34 146.17,106.44 R5F13.3
TP_VPP_EAC_CSN: length 2.7
  TOP w0.1: U4H2.D2 202.49,52.28 202.49,51.99 202.76,51.72 203.13,51.72 203.48,51.38 203.48,51.21 203.07,50.8 R4H45.2
TP_VPP_EAC_CSP: length 2.5
  TOP w0.1: R4H46.2 203.68,51.21 203.68,51.46 203.22,51.92 202.84,51.92 202.69,52.08 202.69,52.34 U4H2.D3
TPEV_A_XTAL_RTC1_TPOUT: length 15.4
  TOP w0.1: U8J1.6 59.56,29.46 58.29,30.73 U8J1.2 54.73,30.73 53.08,32.38 51.3,32.38 48.64,35.05 J8H4.2
TPEV_A_XTAL_RTC2_TPOUT: length 14.7
  TOP w0.1: U8H6.6 60.7,35.05 59.43,36.32 U8H6.2 56,36.32 54.73,37.59 54.05,37.59 53.21,38.43 49.35,38.43 J8H4.1
TPEV_CML_PCUSTB_0_DN: length 75
  TOP w0.089: J3D1.J36 v1(237.24,191.17)
  TOP w0.1: v1(279.53,206.24) 279.3,206.01 279.3,205.11 278.94,204.74 278.94,199.41 281.81,196.54 283.5,196.54 285.87,198.91 285.87,199.42 286.09,199.64 286.41,199.64 286.51,199.74 J1C1.6
  BOTTOM w0.1: v1(237.24,191.17) 237.4,191.17 238.19,191.97 240.32,191.97 241.1,192.74 241.1,193.53 244.27,196.7 244.27,199.34 246.9,201.97 250.02,201.97 254.13,197.86 259.76,197.86 260.35,198.45 260.35,199.34 263.47,202.46 267.99,202.46 272.79,207.26 278.96,207.26 279.35,206.88 279.35,206.42 v1(279.53,206.24)
TPEV_CML_PCUSTB_0_DP: length 74.9
  TOP w0.1: J1C1.4 286.51,199.24 286.31,199.44 286.17,199.44 286.07,199.34 286.07,198.83 283.59,196.34 281.73,196.34 278.74,199.33 278.74,204.83 279.1,205.19 279.1,205.97 v1(278.83,206.24) ; J3D1.J37 238.61,190.69 238.54,190.62 238.25,190.62 238.15,190.72 v1(238.15,191.24)
  BOTTOM w0.1: v1(238.15,191.24) 238.04,191.35 238.04,191.54 238.28,191.77 240.41,191.77 241.3,192.66 241.3,193.45 244.47,196.62 244.47,199.26 246.98,201.77 249.93,201.77 254.04,197.66 259.84,197.66 260.55,198.37 260.55,199.25 263.55,202.26 268.07,202.26 272.87,207.06 278.88,207.06 279.15,206.8 279.15,206.49 278.99,206.34 278.93,206.34 v1(278.83,206.24)
TPEV_CML_PCUSTB_1_DN: length 61.2
  TOP w0.1: J1C1.24 v1(286.02,204.24) ; J3D1.R34 v1(235.41,185.75)
  BOTTOM w0.089: 241.06,188.54 240.61,188.54 240.18,188.12 238.75,188.12 238.27,187.64 237.71,187.64 237.52,187.45 237.08,187.45 236.76,187.13 236.14,187.13 235.88,186.88 235.88,186.36 235.65,186.12 235.65,185.86 235.53,185.75 v1(235.41,185.75)
  BOTTOM w0.1: v1(286.02,204.24) 285.69,203.91 285.15,203.91 283.88,202.64 283.12,202.64 281.73,201.24 280.33,201.24 279.52,200.43 270.25,200.43 269.28,199.46 268.52,199.46 263.95,194.89 254.4,194.89 252.7,193.19 246.65,193.19 242,188.54 241.06,188.54
TPEV_CML_PCUSTB_1_DP: length 61.2
  TOP w0.1: J3D1.R35 236.78,185.29 236.78,185.36 236.39,185.75 v1(236.32,185.75) ; J1C1.22 286.29,203.74 v1(286,203.45)
  BOTTOM w0.089: 240.99,188.34 240.98,188.35 240.68,188.35 240.26,187.93 238.82,187.93 238.35,187.45 237.79,187.45 237.6,187.26 237.15,187.26 236.79,186.9 236.79,186.5 236.47,186.18 235.97,186.18 235.83,186.04 235.83,185.85 235.94,185.75 v1(236.32,185.75)
  BOTTOM w0.1: 240.99,188.34 242.09,188.34 246.74,192.99 252.78,192.99 254.48,194.69 264.03,194.69 268.6,199.26 269.37,199.26 270.33,200.23 279.6,200.23 280.41,201.04 281.81,201.04 283.21,202.44 283.97,202.44 285.24,203.71 285.75,203.71 v1(286,203.45)
TPEV_GPP_G0_R: length 172.1
  LAY3 w0.1: v1(78.23,153.8) 78.23,155 71.52,161.7 71.52,165.26 70,166.78 70,171.68 66.29,175.39 66.29,183.13 63.75,185.67 53.08,185.67 51.3,183.89 51.3,179.83 49.02,177.54 49.02,169.54 45.72,166.24 45.72,163.57 45.21,163.07 45.21,150.11 42.92,147.83 42.92,146.56 42.29,145.92 34.92,145.92 31.36,142.37 30.22,142.37 24.76,136.9 24.76,132.33 26.16,130.94 26.16,114.93 24.76,113.54 24.76,109.85 23.11,108.2 21.59,108.2 18.16,104.77 18.16,95.25 15.84,92.94 15.84,88.75 v1(13.46,86.36)
  BOTTOM w0.1: v1(78.23,153.8) 77.72,154.3 R7R13.2
TPEV_GPP_G1_R: length 172.6
  LAY3 w0.1: v1(78.94,153.8) 78.94,154.61 71.75,161.8 71.75,165.35 70.23,166.88 70.23,171.77 66.52,175.48 66.52,183.23 63.84,185.9 52.99,185.9 51.08,183.99 51.08,179.92 48.79,177.64 48.79,169.64 45.49,166.34 45.49,163.67 44.98,163.16 44.98,150.21 42.7,147.92 42.7,146.65 42.19,146.15 34.83,146.15 31.27,142.59 30.13,142.59 29.81,142.27 29.81,142.27 24.53,137 24.53,132.24 25.93,130.84 25.93,115.03 24.53,113.63 24.53,109.95 23.02,108.43 21.49,108.43 17.93,104.87 17.93,95.34 15.62,93.03 15.62,89.53 v1(13.46,87.37)
  BOTTOM w0.1: v1(78.94,153.8) 78.38,153.24 R7R18.2
TPEV_LAN_JTCK: length 42.3
  TOP w0.1: J5B1.1 151.25,249.43 156.08,249.43 156.55,249.9 156.55,252.94 156.87,253.26 161.23,253.26 162.4,252.09 168.11,252.09 168.66,251.54 178.64,251.54 180.84,253.74 R4B12.2 181.3,254.18 181.3,254.96 183.68,257.34 EU4B1.35
TPEV_LAN_JTDI: length 38.5
  TOP w0.1: J5B1.4 153.57,250.82 156.69,253.94 161.51,253.94 162.68,252.77 168.39,252.77 168.94,252.22 178.3,252.22 180.62,254.53 180.62,255.3 181.02,255.7 181.02,258.36 181.22,258.57 181.86,258.57 R4B2.2 182.85,258.54 EU4B1.32
TPEV_LAN_JTDO: length 41.5
  TOP w0.1: EU4B1.34 183.7,257.74 181.07,255.11 181.07,254.35 178.49,251.77 168.76,251.77 168.21,252.32 162.49,252.32 161.32,253.49 156.81,253.49 156.33,253.01 156.33,249.97 155.99,249.63 151.3,249.63 J5B1.2
TPEV_LAN_JTMS: length 34.9
  TOP w0.1: J5B1.6 155.19,252.16 156.75,253.71 161.42,253.71 162.59,252.54 168.3,252.54 168.85,251.99 178.4,251.99 180.84,254.44 180.84,255.21 182.04,256.41 182.04,256.97 R4B4.2 182.62,257.3 183.46,258.14 EU4B1.33
TPEV_PEG_VIEW_0: length 103.6
  TOP w0.089: v2(205.78,190.32) J3D1.L4
  TOP w0.1: TP5J8.1 v1(136.88,231.39)
  LAY8 w0.1: v1(136.88,231.39) 136.65,231.39 135.63,232.41 135.63,233.68 138.41,236.46 138.41,238.11 138.68,238.38 139.77,238.38 140.78,239.39 144.14,239.39 145.16,238.38 146.17,238.38 146.55,238 146.55,235.27 149.04,232.79 149.45,232.79 150.79,231.45 150.79,229.06 160.27,219.58 173.99,219.58 185.67,207.9 186.43,207.9 188.84,205.48 188.84,204.21 194.31,198.75 194.31,195.89 195.1,195.1 197.89,195.1 198.4,194.59 199.74,194.59 201.8,192.54 201.8,192.53 202.94,191.39 204.71,191.39 v2(205.78,190.32)
TPEV_PEG_VIEW_1: length 111
  TOP w0.089: v2(205.78,192.15) J3D1.J4
  TOP w0.1: TP5J7.1 v1(136.87,224.41)
  LAY8 w0.1: v2(205.78,192.15) 205.27,191.64 203.05,191.64 199.87,194.82 198.5,194.82 197.99,195.32 195.19,195.32 194.56,195.96 194.56,198.92 189.11,204.37 189.11,205.59 186.56,208.14 185.84,208.14 173.26,220.72 159.45,220.72 151.02,229.16 151.02,231.55 149.54,233.02 149.13,233.02 146.78,235.37 146.78,238.09 146.27,238.6 145.25,238.6 144.23,239.62 140.69,239.62 139.67,238.6 138.59,238.6 138.18,238.2 138.18,236.55 135.38,233.75 135.38,225.52 136.49,224.41 v1(136.87,224.41)
TPEV_PEG_VIEW_2: length 165.4
  TOP w0.089: v1(232.91,186.31) 233.3,185.93 233.5,185.93 233.66,185.76 234.49,185.76 234.5,185.75
  TOP w0.1: TP5J6.1 v1(117.6,231.52) ; 234.5,185.75 J3D1.R33
  LAY8 w0.1: v1(232.91,186.31) 232.69,186.31 231.01,187.99 231.01,199.64 230.56,200.09 217.48,200.09 215.64,201.93 203.32,201.93 197.86,207.39 191.26,207.39 190.62,208.02 189.23,208.02 187.07,210.18 186.3,210.18 171.7,224.79 162.17,224.79 157.86,229.11 157.86,230.53 152.78,235.61 152.78,236.85 151.51,238.12 151.51,240.79 150.81,241.48 149.54,241.48 147.9,243.12 147.9,245.52 145.41,248.02 139.61,248.02 135.42,243.82 135.42,242.49 134.11,241.18 134.11,237.11 131.92,234.92 122.78,234.92 120.9,233.04 119.12,233.04 v1(117.6,231.52)
TPEV_PEG_VIEW_3: length 230.5
  TOP w0.089: J3D1.P33 v1(234.5,186.66)
  TOP w0.1: TP5J5.1 v1(75.69,202.06)
  LAY8 w0.1: v1(75.69,202.06) 75.81,202.06 76.58,202.82 76.58,206.12 74.54,208.15 74.54,217.17 75.44,218.07 93.93,218.07 98.02,222.16 98.02,224.08 107.5,233.56 120.78,233.56 122.55,235.33 131.57,235.33 133.71,237.47 133.71,241.35 135.02,242.66 135.02,243.99 139.45,248.42 145.58,248.42 149.78,244.22 151.12,244.22 151.58,243.76 151.58,241.29 158.24,234.64 158.24,233.48 158.88,232.84 158.88,231.51 160.27,230.12 160.27,228.98 164.06,225.19 171.86,225.19 186.39,210.66 195.22,210.66 203.47,202.42 216.3,202.42 216.91,201.8 228.85,201.8 229.99,200.66 230.56,200.66 231.52,199.7 231.52,188.59 232.99,187.12 234.04,187.12 v1(234.5,186.66)
TPEV_PWRGD_PS_JUMPER: length 2.6
  TOP w0.1: R9G25.1 32.38,38.23 J9G8.2
TPEV_XTAL_RTC1_TST: length 2.3
  TOP w0.1: U8J1.3 R8J1.2
TPEV_XTAL_RTC2_TST: length 9.1
  TOP w0.1: v1(57.78,34.92) 57.65,35.05 U8H6.3 ; R8J1.1 v1(52.83,30.35)
  BOTTOM w0.1: v1(57.78,34.92) 53.21,30.35 v1(52.83,30.35)
TR_SNK2_HPD: length 4.3
  TOP w0.1: v2(162.17,263.51) 162.17,263.47 U5A2.Y4
  BOTTOM w0.1: v2(162.17,263.51) 161.91,263.51 160.52,262.13 R5L20.1
TX_OUT: length 15.9
  TOP w0.1: v1(9.01,228.09) 14.98,228.09 15.31,228.42 U9C1.11
  BOTTOM w0.1: J9B5.2 6.22,233.93 6.22,231.54 9.01,228.75 v1(9.01,228.09)
TYPEC_COMP: length 1.4
  TOP w0.2: R6A79.1 113.9,261.76 EU6A2.8
TYPEC_HV_BP_VSEL: length 2.6
  TOP w0.26: EU5A1.23 142.96,262.67 143.17,262.46 143.17,261.67 R5A52.1
TYPEC_HV_COMP_R_BP: length 0.9
  TOP w0.2: C6A50.1 R6A79.2
TYPEC_HV_EN: length 4.3
  TOP w0.1: Q6A1.6 121.66,267.74 121.41,268 120.11,268 119.88,268.22 119.88,268.35 119.63,268.6 119.38,268.6 R6A68.2
TYPEC_HV_EN_R: length 8.9
  TOP w0.1: R6A68.1 118.82,267.39 v1(118.82,266.83) ; EU6A2.10 115.3,263.66 115.69,263.27 v1(115.69,263.14)
  LAY6 w0.125: v1(115.69,263.14) 115.57,263.27 115.57,265.56 115.69,265.68 118.49,265.68 118.82,266.01 v1(118.82,266.83)
TYPEC_HV_RT_BP: length 1.5
  TOP w0.3: EU6A2.1 112.4,266.56 112.01,266.95 R6A71.2
TYPEC_HV_SS_BP: length 2.1
  TOP w0.2: C6A48.1 115.18,262.89 114.91,263.16 EU6A2.9
TYPEC_MODE_BIT0: length 6.2
  TOP w0.1: U8F6.83 26.42,89.25 27.3,88.37 R8G19.1 27.55,88.01 27.81,87.76 27.81,86.74 27.64,86.57 27.64,85.94 R8G29.2
TYPEC_MODE_BIT1: length 244.9
  TOP w0.1: v1(138.17,7.62) 138.3,7.75 R5J22.1 ; v1(21.84,102.61) 21.71,102.49 20.13,102.49 19.53,103.09 U8F6.37 17.05,103.09 16.12,104.01 R9F29.2 R9F26.1
  LAY3 w0.1: v1(138.17,7.62) 138.17,3.94 140.13,1.98 145.47,1.98 149.05,5.56 151.54,5.56 155.57,9.59 155.57,21.51 154.06,23.03 154.06,28.15 147.17,35.04 124.88,35.04 124.16,35.76 124.16,36.29 122.35,38.1 115.49,38.1 114.73,38.86 109.5,38.86 108.78,39.58 104.97,39.58 103.83,40.72 98.23,40.72 97.34,39.83 96.26,39.83 95.37,40.72 90.29,40.72 89.7,40.12 89.06,40.12 88.11,39.17 81.3,39.17 80.53,38.4 76.4,38.4 76.07,38.73 v1(76.07,38.86)
  LAY8 w0.1: v1(21.84,102.61) 24.63,105.41 25.78,105.41 29.03,108.66 33.85,108.66 37.01,105.51 37.49,105.51 37.81,105.18 37.81,96.36 40.86,93.31 40.86,85.29 42.64,83.51 42.64,81.15 45.59,78.2 45.59,69.53 46.07,69.05 46.07,64.86 48.35,62.58 51.16,62.58 52.16,61.58 52.16,58.77 57.87,53.06 58.15,53.06 62.34,48.87 64.82,48.87 71.07,42.62 71.67,42.62 75.43,38.86 v1(76.07,38.86)
TYPEC_SPI_CLK: length 55.2
  TOP w0.1: R6B4.1 128.16,257.17 v1(127.91,257.43) ; v1(147.07,268.6) 146.7,268.6 146.43,268.33 EU5A1.38 ; U5A2.Y16 168.28,263.18 v2(167.98,263.48)
  LAY5 w0.125: v1(127.91,257.43) 127.91,258.34 130.99,261.43 137.22,261.43 137.92,262.13 138.68,262.13 139.48,262.93 139.48,263.28 140.15,263.95 144.22,263.95 144.52,263.64 145.79,263.64 147.07,264.92 v1(147.07,268.6) 147.19,268.6 147.82,269.24 148.39,269.24 151.01,266.62 151.01,266.1 152.19,264.93 153.24,264.93 153.92,265.61 157.68,265.61 158.68,264.61 158.68,263.97 159.51,263.14 161.29,263.14 161.79,262.63 167.15,262.63 167.98,263.46 v2(167.98,263.48)
TYPEC_SPI_CLK_R: length 18.5
  TOP w0.1: U5B1.6 129.89,256.82 R6B4.2 129.54,256.79 129.41,256.67 127.63,256.67 127,256.03 125.98,256.03 125.73,255.78 125.73,255.01 125.09,254.38 116.07,254.38 J6B1.7
TYPEC_SPI_CS_N: length 45.8
  TOP w0.1: EU5A1.39 146.12,268.73 146.49,269.11 147.7,269.11 v1(148.08,268.73) ; U5A2.W18 v2(168.64,264.15) ; R5B5.1 140.08,259.24 139.4,259.92 139.4,261.36 v1(139.09,261.67)
  LAY5 w0.088: 168.27,263.14 168.27,263.3 168.31,263.34 168.31,263.83 v2(168.64,264.15)
  LAY5 w0.125: 168.27,263.14 167.51,262.38 161.55,262.38 161.29,262.64 159.3,262.64 158.29,263.65 154.05,263.65 153.27,264.43 151.91,264.43 150.51,265.82 150.51,266.41 148.19,268.73 v1(148.08,268.73) 147.57,268.22 147.57,264.71 146,263.14 144.32,263.14 144.01,263.45 140.71,263.45 140.46,263.19 140.46,262.39 139.74,261.67 v1(139.09,261.67)
TYPEC_SPI_CS_R_N: length 37.5
  TOP w0.1: J6B1.2 112.26,257.17 117.5,257.17 117.72,257.4 126.59,257.4 127.94,258.75 132.01,258.75 133.1,259.84 133.47,259.84 134.36,258.95 134.36,255.65 135.73,254.28 U5B1.1 138.96,254.28 140.08,255.4 139.64,255.83 139.64,257.38 R5B5.2
TYPEC_SPI_HOLD_N: length 12.1
  TOP w0.1: R6B7.1 127.88,256.16 127.25,255.52 v1(126.23,255.52)
  BOTTOM w0.1: J6B1.11 118.65,254.35 120.87,254.35 121.09,254.13 124.96,254.13 126.23,255.4 v1(126.23,255.52)
TYPEC_SPI_HOLD_R_N: length 3.4
  TOP w0.1: R6B8.2 128.77,255.4 R6B7.2 130.14,255.55 U5B1.7
TYPEC_SPI_MISO: length 50.3
  TOP w0.1: v1(147.96,269.86) 148.59,269.24 148.59,267.71 148.28,267.41 147.06,267.41 146.93,267.53 EU5A1.36 ; R5B4.1 139.17,258.72 139.17,261.11 139.07,261.21 138.83,261.21 138.63,261.42 138.63,262.43 v1(138.43,262.63) ; U5A2.W16 167.99,264.15 v2(167.99,264.18)
  LAY5 w0.125: v2(167.99,264.18) 166.71,262.9 161.9,262.9 160.67,264.14 160.67,265.11 158.84,266.93 157.38,266.93 156.56,266.11 153.72,266.11 153.03,265.43 152.4,265.43 151.51,266.31 151.51,266.82 148.48,269.86 v1(147.96,269.86) 147.45,269.86 146.57,268.98 146.57,265.95 145.07,264.45 139.94,264.45 138.43,262.93 v1(138.43,262.63)
TYPEC_SPI_MISO_R: length 31.2
  TOP w0.1: v1(116.96,257.68) 126.55,257.68 127.84,258.98 131.92,258.98 133,260.07 133.57,260.07 134.59,259.05 134.59,256.57 135.61,255.55 U5B1.2 137.13,255.55 137.79,254.89 138.68,254.89 139.19,255.4 138.73,255.85 138.73,257.35 R5B4.2
  BOTTOM w0.1: v1(116.96,257.68) 116.58,257.3 J6B1.10
TYPEC_SPI_MOSI: length 58.2
  TOP w0.089: U5A2.Y18 168.67,263.48 v2(168.67,263.5)
  TOP w0.1: EU5A1.37 148.04,267.93 v1(148.08,267.97) ; R6B3.1 127.89,258.06 127.22,257.4 v1(127.22,257.05)
  LAY5 w0.125: v2(168.67,263.5) 168.64,263.48 168.64,263.13 167.64,262.13 159.7,262.13 159.43,262.39 159.2,262.39 158.94,262.65 156.1,262.65 155.35,263.4 153.94,263.4 153.16,264.18 151.8,264.18 150.26,265.72 150.26,266.31 148.6,267.97 v1(148.08,267.97) 147.82,267.71 147.82,262.25 147.35,261.78 140.27,261.78 139.41,260.93 131.2,260.93 128.64,258.37 128.64,257.44 128.12,256.92 127.35,256.92 v1(127.22,257.05)
TYPEC_SPI_MOSI_R: length 14.9
  TOP w0.1: U5B1.5 129.56,258.09 R6B3.2 129.54,258.4 129.41,258.52 128.03,258.52 126.68,257.17 118.61,257.17 J6B1.12
TYPEC_SPI_WP_N: length 78.5
  TOP w0.1: v2(162.15,264.12) 162.44,263.83 162.47,263.83 U5A2.W4 ; R5B3.1 135.26,258.7 133.66,260.29 132.91,260.29 131.82,259.21 127.75,259.21 126.71,258.16 v1(125.73,258.16)
  LAY5 w0.125: v2(162.15,264.12) 161.67,264.6 161.67,266.57 160.65,267.59 157.71,267.59 157.55,267.44 151.62,267.44 149.26,269.79 149.26,270.38 146.68,272.96 144.49,272.96 141.47,275.98 139.47,275.98 138.17,274.67 138.17,273.81 137.79,273.43 137.13,273.43 136.12,272.42 136.12,271.3 135.88,271.06 135.88,266.47 135.38,265.96 135.38,264.54 135.12,264.29 133.04,264.29 126.92,258.16 v1(125.73,258.16)
  BOTTOM w0.1: v1(125.73,258.16) 125.73,255.21 124.9,254.38 121.15,254.38 J6B1.15
TYPEC_SPI_WP_R_N: length 4
  TOP w0.1: 137.56,256.82 137.79,257.05 137.79,257.3 R5B3.2 ; 137.56,256.82 137.56,256.01 138.17,255.4 138.3,255.4 ; 137.56,256.82 U5B1.3
U2_CLKREQ_R_9: length 14.8
  TOP w0.1: R5G22.2 153.03,72.52 v1(156.59,68.96)
  BOTTOM w0.1: J5H1.B2 158.09,65.05 156.59,66.55 v1(156.59,68.96)
U2_DRV_ACT_LED: length 170.4
  TOP w0.1: R9G38.1 v1(21.97,68.83)
  LAY5 w0.125: v1(24.13,50.16) 24.13,49.91 26.39,47.65 34.98,47.65 35.77,48.43 40.17,48.43 41.14,47.46 41.7,47.46 43.1,48.86 46.24,48.86 48.92,51.55 50,51.55 51.64,53.19 53.95,53.19 54.69,52.45 55.52,52.45 56.19,53.11 58.13,53.11 58.39,52.85 68.98,52.85 69.47,53.34 73.88,53.34 74.9,52.32 80.77,52.32 81.66,53.21 82.9,53.21 83.87,54.18 86.43,54.18 86.97,53.64 89.77,53.64 91.69,55.56 91.69,55.96 101.64,65.91 102.61,65.91 106.04,69.34 132.2,69.34 134.23,67.31 142.74,67.31 143.51,68.07 146.3,68.07 147.32,69.09 155.19,69.09 156.35,70.25 J5H1.C1
  LAY6 w0.125: v1(21.97,68.83) 22.73,68.07 22.73,64.14 24.53,62.33 24.53,61.24 23.21,59.92 23.21,51.08 v1(24.13,50.16)
U2LH_PIN4: length 1.7
  TOP w0.1: R8C39.1 43.18,208.02 43.18,207 43.42,206.75
U6LH_PIN2: length 4.9
  TOP w0.1: R8C62.1 R8C68.2 30.35,199.01 29.97,198.63 29.97,196.98 30.16,196.79 U8C4.2
U31RD_1_EN_AB: length 3.7
  TOP w0.1: R4B19.2 198.62,253.74 198.62,254.13 198.88,254.38 199.77,254.38 199.89,254.25 200.4,254.25 200.56,254.41 EU4B5.2
U31RD_1_EN_CD: length 1.5
  TOP w0.1: R3B9.2 209.17,256.67 v1(209.16,256.66) EU4B5.20
U31RD_1_EQA: length 2.6
  TOP w0.1: R4B5.1 R4B9.2 198.64,255.9 v1(198.88,255.66) EU4B5.42
U31RD_1_EQB: length 2.6
  TOP w0.1: v1(204.47,258.82) 204.47,258.7 204.56,258.6 EU4B5.29
  BOTTOM w0.1: R4M2.1 204.47,258.19 v1(204.47,258.82) R4M4.2
U31RD_1_EQC: length 2.4
  TOP w0.1: EU4B5.11 205.06,254.17 v1(205.23,254)
  BOTTOM w0.1: R4M5.1 v1(205.23,254) R4M7.2
U31RD_1_EQD: length 3.2
  TOP w0.1: R3B23.1 R3B20.2 209.16,255.01 209.16,255.52 209.03,255.66 EU4B5.18
U31RD_1_FGA: length 3.2
  TOP w0.1: R4B11.2 R4B14.1 198.6,254.63 199.96,254.63 200.06,254.73 EU4B5.1
U31RD_1_FGB: length 2.6
  TOP w0.1: EU4B5.28 205.06,258.7 v1(205.19,258.82)
  BOTTOM w0.1: R4M1.1 205.19,258.23 v1(205.19,258.82) R4M3.2
U31RD_1_FGC: length 2.5
  TOP w0.1: EU4B5.10 204.56,254.22 204.47,254.13 v1(204.47,254)
  BOTTOM w0.1: R4M6.1 204.47,254.63 v1(204.47,254) 204.47,253.36 R4M8.2
U31RD_1_FGD: length 2.5
  TOP w0.1: R3B17.2 R3B13.1 209.54,256.16 EU4B5.19
U31RD_2_EN_AB: length 3.7
  TOP w0.1: EU3B4.2 216.56,254.41 216.45,254.3 215.77,254.3 215.56,254.51 215.13,254.51 214.63,254 214.63,253.74 R3B25.2
U31RD_2_EN_CD: length 1.5
  TOP w0.1: EU3B4.20 v1(225.17,256.66) 225.17,256.67 R3B10.2
U31RD_2_EQA: length 2.6
  TOP w0.1: EU3B4.42 v1(214.88,255.66) 214.64,255.9 R3B12.2 R3B8.1
U31RD_2_EQB: length 2.5
  TOP w0.1: v1(220.47,258.82) 220.56,258.73 EU3B4.29
  BOTTOM w0.1: R3M2.2 220.34,258.95 v1(220.47,258.82) 220.34,258.7 R3M4.1
U31RD_2_EQC: length 2.4
  TOP w0.1: EU3B4.11 221.06,254.17 v1(221.23,254)
  BOTTOM w0.1: R3M7.2 v1(221.23,254) R3M5.1
U31RD_2_EQD: length 3.3
  TOP w0.1: EU3B4.18 225.03,255.66 225.29,255.4 225.29,254.63 225.67,254.25 R3B21.2 R3B24.1
U31RD_2_FGA: length 3.1
  TOP w0.1: R3B18.2 R3B22.1 214.79,254.83 EU3B4.1
U31RD_2_FGB: length 2.4
  TOP w0.1: v1(221.19,258.82) 221.06,258.7 EU3B4.28
  BOTTOM w0.1: R3M3.1 221.19,258.1 v1(221.19,258.82) 221.23,258.87 R3M1.2
U31RD_2_FGC: length 2.5
  TOP w0.1: v1(220.47,254) 220.47,254.13 220.56,254.22 EU3B4.10
  BOTTOM w0.1: R3M8.2 220.47,253.36 v1(220.47,254) 220.47,254.63 R3M6.1
U31RD_2_FGD: length 2.5
  TOP w0.1: EU3B4.19 225.54,256.16 R3B14.1 R3B19.2
UART1_DIR1: length 2.1
  TOP w0.1: EU7H1.1 79.1,54.62 R7H45.2 R7H46.1
UART1_DIR2: length 2.7
  TOP w0.1: R7H39.1 81.66,55.62 80.54,55.62 EU7H1.2
UART1_DIR3: length 2.7
  TOP w0.1: 81.66,58.29 R7H28.1 80.54,59.18 EU7H1.7
UART1_DIR4: length 2.4
  TOP w0.1: R7H22.1 R7H23.2 79.12,60.07 79.1,60.06 EU7H1.8
UART1_OE_N: length 3.9
  TOP w0.1: 74.8,60.7 R7H24.1 76.32,59.82 76.82,59.32 EU7H1.9
UART1_VREF: length 5.3
  TOP w0.1: J6J2.134 131.31,13.33 131.31,10.67 131.69,10.29 R6J23.2
UART2_VREF: length 5.6
  TOP w0.1: J6J2.163 137.66,18.41 137.66,21.46 138.04,21.84 R5J5.2
UART_1V8_P56: length 101.9
  TOP w0.1: v1(94.11,224.47) 94.09,224.49 U7C1.4 ; v1(165.35,223.26) 165.53,223.08 J5B3.56
  LAY5 w0.125: v1(94.11,224.47) 95.44,223.14 101.62,223.14 108.55,216.21 115.16,216.21 116.45,217.5 116.45,224.41 117.22,225.17 122,225.17 123.47,226.64 134.18,226.64 137.6,230.06 137.6,234.89 140.61,237.89 144.59,237.89 144.9,237.58 144.9,236.07 148.53,232.44 149.55,232.44 150.49,231.5 150.49,228.47 155.44,223.52 165.09,223.52 v1(165.35,223.26)
UART_1V8_P58: length 112.2
  TOP w0.1: v1(166.11,223.26) 166.03,223.19 J5B3.58 ; v1(88.51,224.41) 88.6,224.49 U7C1.5
  LAY5 w0.125: v1(166.11,223.26) 165.6,223.77 155.54,223.77 150.74,228.58 150.74,231.6 149.65,232.69 148.64,232.69 147.44,233.88 147.44,237.11 146.15,238.4 145.13,238.4 144.14,239.39 140.97,239.39 139.97,238.4 138.7,238.4 138.49,238.19 138.49,236.13 136.51,234.16 136.51,233.26 130.15,226.9 123.36,226.9 121.89,225.43 119.38,225.43 118.49,226.31 116.71,226.31 116.2,225.8 116.2,217.6 115.06,216.46 108.66,216.46 101.15,223.96 98.1,223.96 95.75,226.31 92.45,226.31 90.55,224.41 v1(88.51,224.41)
UART_BT_WAKE_N: length 14.6
  TOP w0.089: 82.17,141.6 83.07,141.6 84.31,142.85 84.76,142.85 85.44,143.53 89.12,143.53 89.21,143.62 89.37,143.62 89.37,143.62 90.42,143.62 90.58,143.62 91.72,143.62 91.8,143.53 92.11,143.53 92.34,143.3 U6E1.BE32
  TOP w0.1: 82.17,141.6 80.77,141.6 R7E38.2
UART_IN: length 3.1
  TOP w0.1: U7C1.1 93.1,221.85 CR7C3.1 J7C3.1
UART_IN_LP: length 4
  TOP w0.1: U7C1.8 88.56,222.54 88.13,222.12 CR7C2.1 J7C2.1
UART_OE: length 7.7
  TOP w0.1: 89.52,223.84 90.24,223.84 90.8,224.41 90.8,225.68 91.94,226.82 R7C2.1 92.96,227.33 94.36,227.33 R7C3.2
UART_VCCA: length 2.7
  TOP w0.1: R7C5.2 C7C5.2 94.23,223.65 94.03,223.84 93.1,223.84
UART_VCCB: length 7.6
  TOP w0.1: R7C4.2 94.36,225.3 92.96,225.3 C7C2.1 91.69,225.8 91.03,225.14 91.03,223.87 90.35,223.19 U7C1.7
UNNAMED_100_PCIEX42X372M_I433_GND: length 7.8
  TOP w0.1: R8H7.2 45.46,56.01 44.83,56.64 44.83,58.55 44.32,59.05 42.79,59.05 42.52,58.78 J8H1.1
UNNAMED_115_RES_I229_A: length 5.7
  TOP w0.1: R8A13.1 SW8A2.5 SW8A2.6 SW8A2.7 SW8A2.8
UNNAMED_115_RES_I230_A: length 5.7
  TOP w0.1: R8A12.1 SW8A1.5 SW8A1.6 SW8A1.7 SW8A1.8
UNNAMED_118_RES_I121_A: length 59.5
  TOP w0.1: 39.62,283.9 v1(34.92,283.9) ; R9B11.1 v1(13.58,249.55)
  LAY5 w0.125: v1(13.58,249.55) 13.08,250.06 13.08,253.74 13.33,254 13.33,256.89 10.45,259.77 10.45,273.1 13.3,275.95 20.37,275.95 23.76,279.34 24.77,279.34 26.61,281.18 32.2,281.18 v1(34.92,283.9)
UNNAMED_118_RES_I124_A: length 61.5
  TOP w0.1: v1(42.09,283.9) 46.73,283.9 ; R9B7.1 13.58,254.89 13.84,255.14 v1(14.47,255.14)
  LAY5 w0.125: v1(14.47,255.14) 14.47,256.16 10.7,259.93 10.7,273 13.4,275.7 20.48,275.7 23.87,279.09 24.88,279.09 26.71,280.92 39.11,280.92 v1(42.09,283.9)
UNNAMED_131_HDR1X22_I246_IO2: length 5
  TOP w0.1: J9F4.2 8.25,113.54 R9F13.1
UNNAMED_160_FET_I184_D: length 11.2
  TOP w0.508: Q3G2.2 221.53,79.31 Q3G3.3 223.64,80.01 222.88,80.77 218.18,80.77 217.55,80.14 R3G33.2 R3G32.2
UNNAMED_161_CAP_I30_A: length 4.2
  TOP w0.508: R4G16.2 C4G20.1 Q4G4.1 180.97,76.68 181.58,76.06
UNNAMED_161_CAP_I178_A: length 1.7
  TOP w0.25: U8D2.7 28.19,181.23 C8D16.1
UNNAMED_161_RES_I234_B: length 0.9
  TOP w0.25: R8G15.2 R8G13.1
UNNAMED_161_RES_I236_A: length 1.8
  TOP w0.3: R8F48.1 46.22,101.85 R8F46.2
UNNAMED_162_RES_I410_B: length 4.9
  TOP w0.2: R5G2.2 167.89,95.88 169.16,95.88 169.16,96.26 169.54,96.65 R4G1.1
UNNAMED_163_RES_I203_A: length 0.9
  TOP w0.3: R2G36.1 R2G33.2
UNNAMED_163_RES_I230_B: length 2.8
  TOP w0.1: R2G35.2 R2G40.2 267.97,74.17 267.22,73.42 U2G3.2
UNNAMED_164_RES_I139_B: length 2
  TOP w0.3: R5F22.2 R5F19.2 R5F21.1
UNNAMED_164_RES_I186_A: length 119.3
  TOP w0.1: R8D98.2 R8D97.2 51.18,169.42 54.86,169.42 55.78,168.49 55.78,165.7 55.22,165.14 55.22,162.9 58.28,159.85 58.28,151.98 v1(59.3,150.95) ; U7G5.1 66.04,78.99 v1(65.78,79.25) ; R7G25.1 67.69,76.71 68.7,77.72 68.7,78.86 v1(68.71,78.87)
  LAY6 w0.125: v1(59.3,150.95) 59.3,150.87 58.42,149.99 58.42,146.71 61.99,143.13 63.27,143.13 64.39,142.02 64.39,136.96 63.69,136.27 63.51,136.27 62,134.75 60.6,134.75 59.94,134.09 59.94,133.48 61.59,131.83 64.76,131.83 65.53,131.06 65.53,130.05 66.29,129.28 66.29,101.51 67.47,100.33 67.74,100.33 68.32,99.75 68.32,95.53 67.42,94.63 67.42,93.92 66.95,93.45 66.95,92.94 65.9,91.9 65.9,82.71 65.63,82.44 65.63,80.93 66.05,80.52 66.05,79.51 v1(65.78,79.25)
  BOTTOM w0.1: v1(65.78,79.25) 68.33,79.25 v1(68.71,78.87)
UNNAMED_165_RES_I52_A: length 1
  TOP w0.1: U5D1.4 152.67,192.01 152.78,191.9 R5D3.1
UNNAMED_165_RES_I83_B: length 6.7
  TOP w0.1: U8D12.2 45.2,168.01 45.97,168.78 45.97,172.34 R8D94.2 R8D95.2
UNNAMED_165_RES_I86_B: length 10.6
  TOP w0.1: R8D99.2 48.26,166.5 43.17,166.5 42.92,166.75 42.92,167.38 43.18,167.64 43.37,167.64 43.79,168.06 43.79,168.42 44.33,168.96 U8D12.1 44.64,169.09 44.19,169.54 R8D93.2
UNNAMED_166_CAP_I131_B: length 2.8
  TOP w0.1: R8G44.2 C8G11.2 47.24,79.37 Q8G7.1
UNNAMED_166_RES_I162_A: length 0.9
  TOP w0.25: R5C29.2 R5C24.1
UNNAMED_168_MOSFETNDUAL_I416_D: length 6.8
  TOP w0.1: Q5E1.5 152.38,159.51 152.51,159.38 152.93,159.38 153.03,159.48 Q5E1.6 153.03,160.53 153.21,160.7 153.92,160.7 154.17,160.96 Q5E2.6 154.17,162.43 154.38,162.63 155.27,162.63 155.44,162.81 R5D40.2
UNNAMED_168_MOSFETNDUAL_I418_G: length 4.2
  TOP w0.1: R5D38.2 155.44,165.48 Q5D1.6 153.16,165.48 153.03,165.35 153.03,164.97 153.17,164.83 Q5D1.5
UNNAMED_169_BAT54C_I156_A1: length 7.6
  TOP w0.5: U1B1.1 291.91,256.79 292.41,256.29 292.41,255.59 292.22,255.4 C1B2.1 ; C1B2.1 R1B2.2 ; C1B2.1 291.59,255.01 291.46,255.14 CR1B1.2 CR1B1.1
UNNAMED_169_CAP_I154_A: length 3.9
  TOP w0.2: C1B16.1 286.9,235.96 v1(286.64,235.7) 285.75,234.81 EU1B1.59
  TOP w0.5: R1B29.1 287.4,237.11 C1B16.1
UNNAMED_169_CAP_I234_A: length 1.5
  TOP w0.2: R2B55.2 C2B22.1
UNNAMED_169_CAP_I283_A: length 1
  TOP w0.2: R1B21.2 C1B9.1
UNNAMED_169_CAP_I299_A: length 1.1
  TOP w0.2: R1C6.2 283.71,224.53 C1C7.1
UNNAMED_169_CAP_I369_B: length 2.2
  TOP w0.2: Q1B1.4 281.04,243.45 C1B6.2 R1B17.2
UNNAMED_169_CAP_I371_B: length 1.6
  TOP w0.2: R1C10.1 R1C7.2 282.95,223.78 C1C6.2
UNNAMED_169_MOSFETN1D2S_I353_G: length 17.1
  TOP w0.2: R1B3.2 286.41,249.59 286.41,251.81 J1B1.2 ; Q1B1.1 281.07,242.67 v1(282.19,242.67)
  LAY5 w0.2: v1(282.19,242.67) 286.25,246.73 286.25,251.97 J1B1.2
UNNAMED_169_RES_I214_A: length 1.3
  TOP w0.2: R2C17.1 278.13,222.12 278.13,222.38 277.62,222.88 R2C15.1
UNNAMED_169_RES_I236_A: length 1.8
  TOP w0.2: R2B49.2 R2B53.2 R2B54.1
UNNAMED_169_RES_I242_A: length 7.7
  TOP w0.2: v1(270.73,227.96) 270.76,227.96 271.01,227.71 R2C1.2 270.89,226.44 R2C9.2 ; R2B56.1 274.82,228.47 273.05,228.47 272.79,228.73 v1(271.9,228.73)
  LAY6 w0.2: v1(271.9,228.73) 271.27,228.73 270.73,228.19 v1(270.73,227.96)
UNNAMED_169_RES_I272_A: length 3.7
  TOP w0.2: Q1B1.3 Q1B1.2 280.16,242.95 279.65,242.44 R1B19.2 C1B10.2 279.65,240.92 279.78,240.79 R2B25.1
UNNAMED_169_RES_I309_B: length 3.5
  TOP w0.2: EU1B1.58 285.84,234.41 286.51,235.08 287.41,235.08 287.41,234.68 R1B36.1
UNNAMED_170_CAP_I174_A: length 0.9
  BOTTOM w0.2: R3M25.2 239.12,241.43 C3M24.1
UNNAMED_170_RES_I265_B: length 1.5
  BOTTOM w0.2: R3M35.2 239.14,239.01 R3M31.1
UNNAMED_170_RES_I267_A: length 1.4
  BOTTOM w0.2: R3M32.1 R3M39.2
UNNAMED_170_SIC634CD_I115_GL1: length 3
  TOP w0.1: TP2B2.1 247.92,242.04 247.11,242.04 246.83,242.32 EU2B3.27 245.59,242.32 EU2B3.33
UNNAMED_170_SIC634CD_I131_GL1: length 3
  TOP w0.1: TP3B3.1 234.56,242.06 233.8,242.06 233.52,242.34 EU3B2.27 232.28,242.34 EU3B2.33
UNNAMED_171_CAP_I203_A: length 0.9
  BOTTOM w0.2: C3M23.1 215.5,241.55 R3M24.2
UNNAMED_171_RES_I227_B: length 1.5
  BOTTOM w0.2: R3M30.1 215.77,239.39 R3M34.2
UNNAMED_171_RES_I229_B: length 1.1
  BOTTOM w0.2: R3M33.1 R3M38.2
UNNAMED_171_SIC634CD_I113_GL1: length 3
  TOP w0.1: EU3B3.33 222.22,242.32 EU3B3.27 223.46,242.32 223.74,242.04 224.56,242.04 TP3B2.1
UNNAMED_171_SIC634CD_I128_GL1: length 3
  TOP w0.1: TP3B1.1 211.2,242.06 210.43,242.06 210.15,242.34 EU3B1.27 208.91,242.34 EU3B1.33
UNNAMED_172_CAP_I189_A: length 0.9
  BOTTOM w0.2: R2M9.2 262.49,241.43 C2M7.1
UNNAMED_172_RES_I236_B: length 1.5
  BOTTOM w0.2: R2M12.1 262.5,238.76 R2M14.2
UNNAMED_172_RES_I238_B: length 1.1
  BOTTOM w0.2: R2M15.2 R2M13.1
UNNAMED_172_SIC634CD_I110_GL1: length 3
  TOP w0.1: EU2B4.33 268.83,242.32 EU2B4.27 270.07,242.32 270.23,242.16 271.04,242.16 TP2B4.1
UNNAMED_172_SIC634CD_I125_GL1: length 3
  TOP w0.1: TP2B3.1 257.81,242.06 257.04,242.06 256.76,242.34 EU2B2.27 255.52,242.34 EU2B2.33
UNNAMED_173_CAP_I153_A: length 0.9
  BOTTOM w0.2: C4M18.1 192.54,241.55 R4M17.2
UNNAMED_173_RES_I197_B: length 1.6
  BOTTOM w0.2: R4M20.1 R4M22.2
UNNAMED_173_RES_I199_B: length 1.1
  BOTTOM w0.2: R4M21.1 R4M26.2
UNNAMED_173_SIC634CD_I22_GL1: length 3
  TOP w0.1: EU4B3.33 185.92,242.34 EU4B3.27 187.16,242.34 187.45,242.06 188.21,242.06 TP4B1.1
UNNAMED_173_SIC634CD_I99_GL1: length 3
  TOP w0.1: TP4B2.1 201.57,242.04 200.76,242.04 200.47,242.32 EU4B4.27 199.23,242.32 EU4B4.33
UNNAMED_174_RES_I292_A: length 4.5
  TOP w0.2: EU1B1.1 285.42,235.77 286,236.35 R1B31.1 285.36,236.35 284.55,236.35 284.34,236.13 EU1B1.2
UNNAMED_174_RES_I293_A: length 9
  TOP w0.2: EU1B1.12 280.34,236.27 280.41,236.35 ; 280.41,236.35 280.61,236.35 280.74,236.22 EU1B1.11 ; 280.41,236.35 280.41,238 280.72,238.3 280.72,238.87 281.94,240.09 281.94,240.66 282.19,240.92 282.95,240.92 283.84,241.81 R1B20.1
UNNAMED_174_RES_I302_B: length 1.8
  TOP w0.2: R1C11.1 287.27,221.23 R1C20.2
UNNAMED_174_RES_I304_B: length 1.5
  TOP w0.2: R1C17.2 285.87,221.97 R1C8.1
UNNAMED_174_SIC634CD_I99_GL1: length 3
  TOP w0.1: EU1D1.33 281.46,183.13 EU1D1.27 281.46,181.89 281.17,181.61 281.17,180.85 TP1D1.1
UNNAMED_174_SIC634CD_I263_GL1: length 3
  TOP w0.1: TP1D2.1 281.17,167.36 281.17,168.17 281.46,168.46 EU1D2.27 281.46,169.7 EU1D2.33
UNNAMED_177_CAP_I51_A: length 1.4
  TOP w0.2: U6A2.7 113.02,282.44 C6A10.1
UNNAMED_177_DIODETVSUNI_I16_C: length 1.4
  TOP w0.5: R6A4.2 114.88,284.94 CR6A1.1
UNNAMED_178_CAP_I24_A: length 1.7
  TOP w0.1: EU4B2.7 175.89,256.28 C4B4.1
UNNAMED_178_RES_I136_B: length 1.7
  TOP w0.5: R8B30.1 34.54,231.52 R8B34.2
UNNAMED_179_FET_I188_G: length 7.6
  BOTTOM w0.1: R7A9.1 68.45,259.97 70.61,257.81 70.61,256.92 69.97,256.28 Q7B2.1
UNNAMED_179_MOSFETN1G1D3S2_I217_S3: length 3.5
  TOP w0.38: C7A11.1 72.89,261.11 R7A14.1 73.53,259.34 EU7B1.1
UNNAMED_181_CAP_I2_A: length 2.6
  TOP w0.1: Q8D11.1 31.62,180.08 31.36,180.34 R8D45.2 30.6,180.34 30.35,180.08 C8D19.1
UNNAMED_181_NPN_I176_C: length 2.7
  TOP w0.508: Q4H5.3 180.08,50.54 179.45,49.91 R4H49.2
UNNAMED_181_NPNDUAL_I179_B: length 2
  TOP w0.1: Q4H3.5 180.83,55.99 R4H22.2
UNNAMED_181_PNP_I134_B: length 1.6
  TOP w0.508: Q4H4.1 174.11,53.34 R4H29.2
UNNAMED_182_RES_I34_B: length 5.1
  TOP w0.1: R8E4.2 R8E3.2 R8E2.2 R8E1.2 39.37,163.07 39.93,163.64 U8D14.2
UNNAMED_182_RES_I83_B: length 1.2
  TOP w0.1: U8D8.1 37.59,171.83 37.97,172.21 R8D68.2
UNNAMED_182_RES_I192_B: length 2.8
  TOP w0.1: U8D10.3 33.59,170.49 33.9,170.18 R8D80.2 33.65,169.54 32.76,169.54 R8D69.1
UNNAMED_182_RES_I193_B: length 1.8
  TOP w0.1: U8D10.1 32.51,170.81 R8D79.2
UNNAMED_182_RES_I194_B: length 1
  TOP w0.1: U8D10.6 32.42,171.49 32.38,171.45 R8D71.2
UNNAMED_182_RES_I201_A: length 3.2
  TOP w0.1: R8D65.1 34.67,173.86 33.59,172.78 U8D10.4
UNNAMED_183_BAT54C_I184_C: length 345.4
  TOP w0.1: v1(34.89,187.83) 35.43,188.37 R8D11.2 ; CR5E1.3 149.09,146.18 147.06,144.14 v1(147.06,134.49)
  LAY5 w0.125: v1(134.87,90.8) 129.03,90.8 122.06,83.84 115.2,83.84 112.67,86.37 107.96,86.37 106.43,84.84 103.36,84.84 95.92,77.41 93.78,77.41 93.17,76.79 93.17,75.28 89.89,72.01 89.03,72.01 82.82,65.79 77.96,65.79 73.38,61.21 72.41,61.21 71.63,61.99 69.95,61.99 69.7,61.74 68.06,61.74 65.13,58.81 62.44,58.81 62.35,58.72 53.97,58.72 52.84,57.59 49.21,57.59 48.27,56.65 48.27,55.52 46.53,53.78 46.53,53.52 46.1,53.09 45.23,53.09 44.72,53.6 34.41,53.6 33.02,52.2 33.02,51.94 v1(31.49,50.42)
  LAY6 w0.125: v1(31.49,50.42) 31.49,50.93 30.86,51.56 30.86,52.7 31.75,53.6 31.75,59.24 32.04,59.53 32.04,63.33 30.86,64.51 30.86,66.15 30.59,66.42 30.59,69.99 29.88,70.7 29.88,80.25 29.07,81.05 29.07,82.98 28.98,83.08 28.98,88.24 30.23,89.49 30.23,93.54 29.72,94.05 29.72,102.32 30.35,102.95 30.35,105.62 29.64,106.33 29.64,108.52 27.68,110.49 27.68,111.38 28.06,111.76 28.06,113.54 27.05,114.55 27.05,121.87 27.85,122.68 28.89,122.68 29.41,123.19 29.41,124.15 28.55,125.01 28.55,126.82 29.46,127.74 29.46,131.11 27.39,133.18 27.39,136.61 27.89,137.1 27.89,145.3 28.69,146.1 28.69,165.83 29.21,166.34 29.21,172.47 28.76,172.91 28.76,179.9 34.89,186.03 v1(34.89,187.83)
  BOTTOM w0.1: v1(147.06,134.49) 148.33,134.49 148.84,133.98 148.84,101.34 148.46,100.96 145.16,100.96 143.89,99.69 138.68,99.69 136.01,97.03 136.01,91.95 v1(134.87,90.8)
UNNAMED_184_RES_I135_B: length 2.5
  BOTTOM w0.1: 29.97,209.68 30.6,209.68 30.98,209.29 31.75,209.29 32,209.04 U8N1.1
UNNAMED_185_MOSFETNDUAL_I78_D: length 2.8
  TOP w0.5: Q4G1.6 183.38,92.58 183,92.2 R4G8.2 R4G7.1
UNNAMED_187_CAP_I6_A: length 1.9
  TOP w0.25: C8G21.1 49.01,65.79 U8G3.7
UNNAMED_187_CAP_I52_B: length 2.5
  TOP w0.38: R5C69.2 C5C42.2 157.48,217.93 156.84,217.29 EU5C5.1
UNNAMED_187_MOSFETNDUAL_I21_D: length 9.2
  TOP w0.1: v1(152.52,209.04) 152.2,209.04 150.87,207.71 Q5C3.6 ; Q5C4.1 153.34,204.27 v1(153.16,204.09)
  LAY6 w0.125: v1(152.52,209.04) 152.85,208.71 152.85,204.39 v1(153.16,204.09)
UNNAMED_187_MOSFETNDUAL_I28_D: length 15.2
  TOP w0.38: R5C18.2 157.35,209.17 157.35,210.03 R5C19.1 157.4,210.06 157.91,210.56 158.24,210.56 158.87,211.2 158.87,211.94 v1(158.9,211.96) 158.9,212.37 159.51,212.98 CR5C1.1 ; Q5C4.6 v1(153.34,208.02)
  LAY5 w0.38: v1(158.9,211.96) 158.64,211.71 157.86,211.71 157.35,212.22 155.57,212.22 154.43,211.07 154.43,209.12 v1(153.34,208.02)
UNNAMED_189_RES_I148_A: length 0.9
  TOP w0.3: R8E66.1 50.16,130.68 R8E63.2
UNNAMED_189_RES_I169_A: length 1
  TOP w0.3: R8E43.1 49.14,139.83 R8E41.2
UNNAMED_189_RES_I191_A: length 0.8
  TOP w0.3: R8E8.1 R8E6.2
UNNAMED_190_RES_I101_B: length 0.9
  TOP w0.3: R8E26.1 50.54,149.1 R8E22.2
UNNAMED_192_CAP_I10_A: length 1.6
  TOP w0.2: C6A24.1 104.9,276.86 U6A3.7
UNNAMED_194_CAP_I97_A: length 16.2
  TOP w0.508: R6A70.1 117.72,266.95 v1(117.72,266.55)
  BOTTOM w0.508: v1(117.72,266.55) 117.72,266.83 118.61,267.71 119.88,267.71 120.77,266.83 123.95,266.83 125.34,265.43 126.69,265.43 128.09,264.03 129.92,264.03 v1(130.55,264.67)
UNNAMED_194_CAP_I97_B: length 8.8
  TOP w0.3: R6A74.1 128.14,265.3 v1(128.14,264.92) 128.39,264.67 R6A76.2 C6A40.2 128.9,263.73 Q6A4.4 ; Q6A3.4 v1(131.74,264.79)
  BOTTOM w0.3: v1(131.74,264.79) 131.31,265.23 130.09,265.23 129.79,264.92 v1(128.14,264.92)
UNNAMED_194_MOSFETNDUAL_I94_D: length 1.7
  TOP w0.3: Q6A2.6 127.38,266.19 127.76,266.57 R6A74.2
UNNAMED_194_RES_I30_B: length 1.5
  TOP w0.38: R6D58.2 134.87,172.72 R5D27.1
UNNAMED_202_LED_I439_A: length 1.9
  TOP w0.38: 52.19,40.51 52.19,40.89 51.56,41.53 DS8H3.1
UNNAMED_202_LED_I440_A: length 1.7
  TOP w0.38: DS8H5.1 54.86,40.51
UNNAMED_202_LED_I441_A: length 1.7
  TOP w0.38: DS8H4.1 53.21,40.51
UNNAMED_202_LED_I442_A: length 1.7
  TOP w0.38: DS8H6.1 56.51,40.51
UNNAMED_202_LED_I443_A: length 2.1
  TOP w0.38: 51.05,40.51 49.91,41.65 DS8H2.1
UNNAMED_218_CAP_I149_A: length 7
  TOP w0.089: 203.58,53.72 203.57,53.71 203.06,53.71 U4H2.B3
  TOP w0.1: C4H11.1 204.57,54.13 203.98,54.13 203.58,53.72 ; C4H11.1 R4H28.2 ; C4H11.1 205.99,52.7 R3H33.1
UNNAMED_222_CAP_I325_A: length 0.8
  TOP w0.2: C5B37.1 R5B66.2
UNNAMED_222_MOSFETN_I372_DRN: length 1.7
  BOTTOM w0.2: Q5M2.3 149.21,237.22 149.6,237.62 150.24,237.62 R5M8.2
UNNAMED_222_MOSFETN_I373_DRN: length 2.8
  TOP w0.2: R5B79.2 v1(149.83,236.35)
  BOTTOM w0.2: v1(149.83,236.35) 149.73,236.35 149.29,235.9 149.29,235.45 149.87,234.86 Q5M3.3
UNNAMED_222_MOSFETN_I397_DRN: length 9.8
  TOP w0.2: R5B69.2 v1(148.84,243.26)
  LAY6 w0.2: v1(150.67,240.56) 150.67,243.41 150.11,243.97 149.54,243.97 v1(148.84,243.26)
  BOTTOM w0.2: Q5M1.3 153.78,239.03 152.14,240.66 150.77,240.66 v1(150.67,240.56)
UNNAMED_222_RES_I140_B: length 13.1
  TOP w0.2: v1(169.92,238.42) 170.05,238.54 170.05,239.14
  BOTTOM w0.2: 159.38,241.93 160.14,241.93 160.4,241.68 160.95,241.68 162.01,240.62 163.64,240.62 166.19,238.07 169.57,238.07 v1(169.92,238.42)
UNNAMED_222_RES_I369_B: length 1.6
  BOTTOM w0.2: R5M3.1 158.36,242.19 R5M1.2
