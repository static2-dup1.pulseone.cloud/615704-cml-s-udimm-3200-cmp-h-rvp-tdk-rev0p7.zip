# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB31_P3_RX_ESD_DN: length 27.3
  TOP w0.115: C3A33.2 223.64,260.87 223.64,261.24 221.69,263.19 221.69,264.69 R3A34.1 221.69,265.66 221.69,266.37 221.46,266.6 U3A6.4 U3A6.7 221.46,267.82 221.69,268.04 221.69,268.43 v1(221.39,268.73)
  BOTTOM w0.115: J3A1.25 211.43,276.9 211.53,276.8 211.53,276.24 212.14,275.63 212.14,271.78 213.26,270.66 220.44,270.66 221.69,269.42 221.69,269.03 v1(221.39,268.73)
USB31_P3_RX_ESD_DP: length 27.3
  TOP w0.115: v1(222.22,268.73) 221.92,268.43 221.92,267.64 U3A6.6 U3A6.5 221.92,266.78 221.92,265.66 R3A35.1 221.92,264.69 221.92,263.32 223.9,261.34 223.9,260.94 C3A34.2
  BOTTOM w0.115: v1(222.22,268.73) 221.92,269.03 221.92,269.51 220.54,270.89 213.36,270.89 212.37,271.88 212.37,275.73 211.76,276.34 211.76,276.82 211.83,276.9 J3A1.26
USB31_P3_RX_RD_DN: length 1.9
  TOP w0.115: C3A33.1 223.69,259.39 223.69,258.49 223.56,258.36 EU3B4.23
USB31_P3_RX_RD_DP: length 1.9
  TOP w0.115: C3A34.1 223.92,259.38 223.92,258.49 224.06,258.35 EU3B4.22
USB31_P3_TX_C_DN: length 2
  TOP w0.115: C3B17.2 221.9,253.42 221.9,253.77 221.71,253.96 221.71,254.31 221.56,254.46 EU3B4.12
USB31_P3_TX_C_DP: length 2
  TOP w0.115: EU3B4.13 222.06,254.45 221.94,254.33 221.94,254.05 222.13,253.86 222.13,253.46 C3B18.2
USB31_P3_TX_CMC_DN: length 4.8
  TOP w0.115: C3A31.2 221.74,260.88 221.74,261.29 219.83,263.2 219.83,264.29 R3A43.1
USB31_P3_TX_CMC_DP: length 4.9
  TOP w0.115: R3A33.2 220.06,264.24 220.06,263.29 221.96,261.39 221.96,260.99 C3A32.2
USB31_P3_TX_DN: length 214.3
  TOP w0.1: U6E1.F11 111.31,153.68 111.31,153.9 v1(111.62,154.21)
  TOP w0.115: C3B17.1 221.58,252.29 221.71,252.41 221.88,252.41 222.02,252.27 222.02,251.59 221.89,251.46 v1(221.58,251.46)
  BOTTOM w0.089: 113.03,154.25 112.77,153.99 111.85,153.99 111.63,154.21 v1(111.62,154.21)
  BOTTOM w0.115: v1(221.58,251.46) 221.8,251.46 221.91,251.34 221.91,251.08 221.76,250.93 220.62,250.93 219.81,251.74 212.39,251.74 211.97,252.15 211.97,253.3 210.82,254.45 210.82,258.21 208.58,260.45 200.2,260.45 199.11,259.36 199.11,258.62 198.17,257.68 195.56,257.68 194.85,256.98 192.8,256.98 192.39,257.39 182.99,257.39 178.81,253.21 171.29,253.21 170.12,252.04 149.63,252.04 148.8,251.22 134.5,251.22 131.31,248.03 131.31,245.95 126.13,240.77 126.13,238.35 125.62,237.84 125.62,235.43 127.12,233.93 127.12,227.74 128.43,226.43 128.43,220.78 129.25,219.96 129.25,205.07 128.29,204.11 128.29,198.78 126.77,197.25 126.77,188.88 127.27,188.37 127.27,182.21 126.74,181.68 126.74,179.58 124.79,177.62 124.79,167.78 122.05,165.04 122.05,162.7 121.53,162.17 120.79,162.17 119.32,160.71 118.72,160.71 117.75,159.73 117.75,158.19 114.85,155.3 114.07,155.3 113.03,154.25
USB31_P3_TX_DP: length 214.3
  TOP w0.1: U6E1.G12 v1(110.78,153.72)
  TOP w0.115: v1(222.47,251.46) 222.25,251.69 222.25,251.99 C3B18.1
  BOTTOM w0.089: 113.19,154.09 113.19,154.08 113.17,154.08 113.12,154.04 113.1,154.04 112.85,153.79 110.84,153.79 v1(110.78,153.72)
  BOTTOM w0.115: v1(222.47,251.46) 222.26,251.46 222.14,251.34 222.14,250.98 221.86,250.7 220.52,250.7 219.71,251.51 212.29,251.51 211.74,252.06 211.74,253.2 210.59,254.36 210.59,258.11 208.48,260.22 200.29,260.22 199.34,259.27 199.34,258.53 198.27,257.45 195.65,257.45 194.95,256.75 192.71,256.75 192.3,257.16 183.09,257.16 178.91,252.98 171.39,252.98 170.22,251.81 149.72,251.81 148.9,250.99 134.6,250.99 131.54,247.93 131.54,245.86 126.36,240.67 126.36,238.25 125.85,237.74 125.85,235.53 127.35,234.03 127.35,227.84 128.66,226.53 128.66,220.87 129.48,220.06 129.48,204.97 128.52,204.02 128.52,198.68 127,197.16 127,188.97 127.5,188.47 127.5,182.12 126.97,181.58 126.97,179.48 125.02,177.53 125.02,167.68 122.28,164.95 122.28,162.6 121.62,161.94 120.88,161.94 119.42,160.48 118.82,160.48 117.98,159.64 117.98,158.09 114.95,155.07 114.17,155.07 113.19,154.09
USB31_P3_TX_ESD_DN: length 18.5
  TOP w0.115: R3A43.2 219.83,265.17 219.83,265.91 220.11,266.19 220.11,266.67 U3A6.1 U3A6.10 220.11,267.75 220.11,268 219.93,268.18 219.93,269.03 221.07,270.16 222.18,270.16 222.75,270.74 222.75,271.35 v1(222.45,271.65)
  BOTTOM w0.115: v1(222.45,271.65) 222.75,271.95 222.75,273.3 220.14,275.92 218.16,275.92 217.55,276.53 217.55,276.83 217.48,276.9 J3A1.28
USB31_P3_TX_ESD_DP: length 18.5
  TOP w0.115: v1(223.28,271.65) 222.98,271.35 222.98,270.65 222.27,269.93 221.16,269.93 220.16,268.93 220.16,268.27 220.34,268.1 220.34,267.72 U3A6.9 U3A6.2 220.34,266.71 220.34,266.1 220.06,265.82 220.06,265.22 R3A33.1
  BOTTOM w0.115: J3A1.29 217.88,276.9 217.78,276.8 217.78,276.62 218.26,276.15 220.23,276.15 222.98,273.4 222.98,271.95 v1(223.28,271.65)
USB31_P3_TX_RD_DN: length 1.9
  TOP w0.115: EU3B4.27 221.56,258.39 221.74,258.57 221.74,259.43 C3A31.1
USB31_P3_TX_RD_DP: length 1.9
  TOP w0.115: EU3B4.26 222.06,258.5 221.97,258.59 221.97,259.34 C3A32.1
USB31_P4_RX_C_DN: length 2
  TOP w0.115: C4B14.1 203.76,253.44 203.76,253.73 203.92,253.9 203.92,254.27 204.06,254.4 EU4B5.9
USB31_P4_RX_C_DP: length 2
  TOP w0.115: C4B13.1 203.53,253.44 203.53,253.82 203.69,253.99 203.69,254.29 203.56,254.42 EU4B5.8
USB31_P4_RX_DN: length 195.5
  TOP w0.1: U6E1.K16 v1(109.36,151.89)
  TOP w0.115: C4B14.2 203.69,251.82 203.69,251.62 203.42,251.36 197.38,251.36 197.04,251.7 197.04,251.88 v1(196.7,252.22)
  BOTTOM w0.089: 112.81,151.75 112.8,151.74 112.78,151.74 112.6,151.55 112,151.57 111.66,151.91 111.17,151.91 110.95,151.69 110.7,151.69 110.49,151.48 109.82,151.48 109.4,151.89 v1(109.36,151.89)
  BOTTOM w0.115: 112.81,151.75 112.95,151.89 115.45,151.89 116.75,153.18 120.22,153.18 123.11,156.08 124.1,156.08 125.54,157.52 126.89,157.52 129.43,160.05 129.43,162.08 134.18,166.84 134.18,184.33 131.31,187.2 131.31,194.09 132.59,195.36 132.59,202.05 132.13,202.51 132.13,221.06 131.25,221.93 131.25,235.07 133.07,236.89 133.07,243.18 133.85,243.97 134.49,243.97 138.92,248.4 145.28,248.4 148.37,245.31 153.62,245.31 154.45,246.14 155.99,246.14 158.13,248.28 166.62,248.28 167.57,249.23 172.9,249.23 173.73,250.06 175.06,250.06 176.24,248.88 180.04,248.88 182.24,251.07 182.24,252.2 182.81,252.77 183.94,252.77 184.85,253.68 192.13,253.68 192.43,253.38 195.23,253.38 195.62,253.77 196.75,253.77 197.12,253.4 197.12,252.51 197.01,252.39 196.87,252.39 v1(196.7,252.22)
USB31_P4_RX_DP: length 195.6
  TOP w0.1: U6E1.J15 109.95,151.44 109.82,151.44 109.75,151.51 109.75,151.68 110.1,152.03 v1(110.1,152.13)
  TOP w0.115: v1(197.53,252.22) 197.27,251.96 197.27,251.8 197.48,251.59 203.32,251.59 203.46,251.72 203.46,251.96 C4B13.2
  BOTTOM w0.089: 112.66,151.91 112.63,151.88 112.51,151.76 112.09,151.77 111.75,152.11 111.09,152.11 110.87,151.89 110.61,151.89 110.4,151.68 109.9,151.68 109.8,151.78 109.8,152.04 109.89,152.13 v1(110.1,152.13)
  BOTTOM w0.115: v1(197.53,252.22) 197.35,252.39 197.35,253.49 196.85,254 195.53,254 195.14,253.61 192.52,253.61 192.22,253.91 184.75,253.91 183.84,253 182.71,253 182.01,252.29 182.01,251.17 179.95,249.11 176.33,249.11 175.15,250.29 173.64,250.29 172.8,249.46 167.47,249.46 166.52,248.51 158.03,248.51 155.89,246.37 154.36,246.37 153.53,245.54 148.47,245.54 145.38,248.63 138.83,248.63 134.39,244.2 133.76,244.2 132.84,243.27 132.84,236.98 131.02,235.17 131.02,221.84 131.9,220.97 131.9,202.41 132.36,201.95 132.36,195.45 131.08,194.18 131.08,187.1 133.95,184.23 133.95,166.93 129.2,162.17 129.2,160.15 126.8,157.75 125.45,157.75 124.01,156.31 123.02,156.31 120.12,153.41 116.65,153.41 115.36,152.12 112.86,152.12 112.66,151.92 112.66,151.91
USB31_P4_RX_ESD_DN: length 39.2
  TOP w0.115: C4A40.2 203.98,260.92 203.98,261.22 203.58,261.62 203.07,261.62 201.34,263.34 201.34,264.69 R4A14.1 201.29,265.71 201.29,266.02 201.05,266.26 201.05,266.52 U4A1.10 U4A1.1 201.22,267.71 201.05,267.88 201.05,268.78 200,269.84 200,270.72 v1(200.3,271.02)
  BOTTOM w0.115: v1(200.3,271.02) 200.15,271.17 200.15,272.92 199,274.06 199,277.06 195.42,280.64 194.53,280.64 192.11,283.06 186.21,283.06 185.31,282.16 185.31,281.27 184.14,280.1 J4A2.5
USB31_P4_RX_ESD_DP: length 39.2
  TOP w0.115: C4A39.2 203.75,260.92 203.75,261.12 203.49,261.39 202.97,261.39 201.11,263.25 201.11,264.69 R4A13.1 201.06,265.61 201.06,265.93 200.82,266.17 200.82,266.58 U4A1.9 U4A1.2 200.72,267.85 200.82,267.95 200.82,268.69 199.77,269.75 199.77,270.72 v1(199.47,271.02)
  BOTTOM w0.115: v1(199.47,271.02) 199.92,271.47 199.92,272.83 198.77,273.97 198.77,276.96 195.32,280.41 194.43,280.41 192.02,282.83 186.3,282.83 185.54,282.07 185.54,281.18 184.69,280.32 184.69,280.07 184.86,279.91 185.58,279.91 J4A2.6
USB31_P4_RX_RD_DN: length 1.9
  TOP w0.115: C4A40.1 203.95,259.36 203.95,258.57 204.06,258.47 EU4B5.30
USB31_P4_RX_RD_DP: length 1.9
  TOP w0.115: EU4B5.31 203.56,258.4 203.72,258.57 203.72,259.41 C4A39.1
USB31_P4_TX_C_DN: length 3.6
  TOP w0.115: EU4B5.5 202.06,254.51 201.93,254.38 201.93,254.13 202.43,253.62 202.43,252.6 202.18,252.35 201.8,252.35 C4B18.2
USB31_P4_TX_C_DP: length 3.6
  TOP w0.115: EU4B5.4 201.56,254.52 201.7,254.38 201.7,254.03 202.02,253.71 202.2,253.52 202.2,252.7 202.08,252.58 201.56,252.58 201.43,252.71 201.43,252.87 C4B15.2
USB31_P4_TX_CMC_DN: length 4.8
  TOP w0.115: R4A12.2 199.6,264.09 199.6,263.71 199.88,263.43 199.88,263.13 201.77,261.23 201.77,260.98 C4A38.2
USB31_P4_TX_CMC_DP: length 4.9
  TOP w0.115: C4A37.2 201.54,260.88 201.54,261.14 199.65,263.03 199.65,263.33 199.37,263.61 199.37,263.9 R4A20.1
USB31_P4_TX_DN: length 188.8
  TOP w0.089: 114.42,152.27 114.4,152.25 113.36,152.25 U6E1.B14
  TOP w0.115: 114.42,152.27 116.54,152.27 117.71,153.45 118.98,153.45 119.43,153.9 119.43,153.9 119.96,154.43 119.96,155.97 v1(120.48,156.48) ; v1(198.98,253.24) 199.11,253.24 199.28,253.06 199.28,252.68 199.54,252.42 200.33,252.42 C4B18.1
  BOTTOM w0.115: v1(120.48,156.48) 120.75,156.21 121.7,156.21 122.67,157.17 123.65,157.17 125.09,158.61 126.44,158.61 128.32,160.48 128.32,162.51 132.73,166.93 132.73,176 130.07,178.66 130.07,203.04 131.02,203.99 131.02,220.62 130.16,221.48 130.16,233.75 127.91,236 127.91,240.02 132.97,245.08 134.01,245.08 138.41,249.48 146.06,249.48 147.58,247.97 148.41,247.97 149.14,247.24 155.54,247.24 158.62,250.32 171.07,250.32 172.19,251.43 179.64,251.43 182.13,253.92 183.49,253.92 184.49,254.92 195.23,254.92 196.19,255.88 197.25,255.88 198.24,254.89 198.24,253.24 198.82,252.66 199.17,252.66 199.28,252.77 199.28,252.94 v1(198.98,253.24)
USB31_P4_TX_DP: length 188.8
  TOP w0.089: 114.48,152.04 113.06,152.04 U6E1.C14
  TOP w0.115: 114.48,152.04 114.48,152.04 116.64,152.04 117.81,153.22 119.07,153.22 119.66,153.8 120.19,154.33 120.19,155.37 v1(120.48,155.65) ; v1(199.81,253.24) 199.51,252.94 199.51,252.77 199.63,252.65 200.33,252.65 C4B15.1
  BOTTOM w0.115: v1(120.48,155.65) 120.8,155.98 121.8,155.98 122.76,156.94 123.75,156.94 125.19,158.38 126.54,158.38 128.55,160.38 128.55,162.42 132.96,166.84 132.96,176.09 130.3,178.76 130.3,202.94 131.25,203.89 131.25,220.72 130.39,221.57 130.39,233.84 128.14,236.09 128.14,239.92 133.07,244.85 134.11,244.85 138.51,249.25 145.96,249.25 147.48,247.74 148.32,247.74 149.05,247.01 155.64,247.01 158.72,250.09 171.17,250.09 172.29,251.2 179.74,251.2 182.22,253.69 183.58,253.69 184.58,254.69 195.33,254.69 196.29,255.65 197.15,255.65 198.01,254.79 198.01,253.14 198.72,252.43 199.26,252.43 199.51,252.68 199.51,252.94 v1(199.81,253.24)
USB31_P4_TX_ESD_DN: length 25.6
  TOP w0.115: v1(198.67,271.91) 198.37,271.61 198.37,269.87 199.58,268.66 199.58,267.96 199.72,267.82 U4A1.4 U4A1.7 199.72,266.34 199.57,266.19 199.57,265.8 199.49,265.71 199.49,265.48 R4A12.1
  BOTTOM w0.115: v1(198.67,271.91) 198.37,271.61 198.37,271.27 197.99,270.89 197.03,270.89 195.22,272.7 195.22,276.25 195.96,276.99 195.96,278.51 194.94,279.53 193.42,279.53 193.14,279.25 191.4,279.25 190.55,280.1 J4A2.8
USB31_P4_TX_ESD_DP: length 25.6
  TOP w0.115: R4A20.2 199.26,265.45 199.26,265.81 199.34,265.89 199.34,266.17 199.22,266.29 U4A1.6 U4A1.5 199.22,267.82 199.35,267.95 199.35,268.57 198.14,269.78 198.14,271.61 v1(197.84,271.91)
  BOTTOM w0.115: v1(197.84,271.91) 198.14,271.61 198.14,271.37 197.89,271.12 197.12,271.12 195.45,272.79 195.45,276.15 196.19,276.89 196.19,278.6 195.04,279.76 193.32,279.76 193.04,279.48 192.78,279.48 192.63,279.63 192.63,279.98 193.16,280.51 193.16,280.79 192.83,281.12 192.45,281.12 191.79,280.46 J4A2.9
USB31_P4_TX_RD_DN: length 2
  TOP w0.115: C4A38.1 201.82,259.38 201.82,258.87 201.93,258.77 201.93,258.47 202.06,258.34 EU4B5.34
USB31_P4_TX_RD_DP: length 2
  TOP w0.115: C4A37.1 201.59,259.38 201.59,258.77 201.7,258.67 201.7,258.47 201.56,258.33 EU4B5.35
USB31_P5_RX_DN: length 65.9
  TOP w0.089: U6E1.J13 110.13,152.74 110.01,152.87 110.01,153.12 v1(110.13,153.25)
  TOP w0.115: R6D17.1 107.3,195.03 107.3,195.24 107.41,195.35 108.93,195.35 110,194.28 110,191.82 111.02,190.81 111.02,189.22 124.88,175.36 124.88,173.45 126.57,171.75 126.95,171.75 127.38,171.32 v1(127.38,171.15)
  BOTTOM w0.089: v1(110.13,153.25) 110.13,153.11 110.22,153.02 110.42,153.02 110.58,153.17 111.03,153.35 111.17,153.49 113.19,153.49 113.45,153.75 113.86,153.75
  BOTTOM w0.115: v1(127.38,171.15) 127.38,171.32 127.8,171.75 128,171.75 128.16,171.58 128.16,166.14 124.62,162.6 124.62,161.15 122.37,158.89 121.96,158.89 121.54,158.47 119.88,158.47 119.15,157.73 118.51,157.73 114.52,153.75 113.86,153.75
USB31_P5_RX_DP: length 65.9
  TOP w0.089: U6E1.K13 v1(109.49,152.98)
  TOP w0.115: v1(127.38,171.98) 126.67,171.98 125.11,173.54 125.11,175.46 111.25,189.31 111.25,190.9 110.23,191.92 110.23,194.38 109.03,195.58 107.69,195.58 R6D16.1
  BOTTOM w0.089: v1(109.49,152.98) 109.98,152.82 110.51,152.82 110.69,153 111.14,153.17 111.25,153.28 113.27,153.28 113.41,153.41 113.53,153.54 113.76,153.54 113.77,153.53 113.83,153.53 113.85,153.52 113.86,153.52
  BOTTOM w0.115: v1(127.38,171.98) 128.09,171.98 128.39,171.68 128.39,166.05 124.85,162.51 124.85,161.05 122.47,158.66 122.06,158.66 121.63,158.24 119.98,158.24 119.24,157.5 118.6,157.5 114.61,153.52 113.86,153.52
USB31_P5_RX_R_DN: length 7.2
  TOP w0.115: J6C3.P6 103.56,192.83 103.28,193.11 103.28,195.05 103.4,195.17 103.89,195.17 U6D3.5 U6D3.6 105.06,195.05 105.23,195.22 105.75,195.22 105.91,195.37 106.43,195.37 106.6,195.21 106.6,194.94 R6D17.2
USB31_P5_RX_R_DP: length 7.2
  TOP w0.115: J6C3.P5 102.76,192.83 103.05,193.11 103.05,195.14 103.3,195.4 103.86,195.4 U6D3.4 U6D3.7 105.1,195.55 105.2,195.45 105.66,195.45 105.81,195.6 106.32,195.6 R6D16.2
USB31_P5_TX_C_CMC_ESD_DN: length 9.9
  TOP w0.115: R6D14.2 106.31,196.94 105.75,196.94 105.48,196.67 105.15,196.67 105.03,196.55 U6D3.9 U6D3.2 103.75,196.55 103.63,196.67 103.12,196.67 100.59,194.14 100.59,193.02 100.71,192.91 101.01,192.91 101.16,192.75 J6C3.P3
USB31_P5_TX_C_CMC_ESD_DP: length 9.8
  TOP w0.115: J6C3.P2 100.36,194.24 103.02,196.9 103.6,196.9 103.75,197.05 U6D3.1 U6D3.10 105.02,197.05 105.18,196.9 105.38,196.9 105.65,197.17 106.33,197.17 R6D15.2
USB31_P5_TX_C_DN: length 1.3
  TOP w0.115: R6D14.1 107.27,196.93 107.68,196.93 C6D8.2
USB31_P5_TX_C_DP: length 1.3
  TOP w0.115: R6D15.1 107.25,197.16 107.68,197.16 C6D7.2
USB31_P5_TX_DN: length 63.6
  TOP w0.089: 114.49,151.76 113.54,151.76 113.46,151.84 113.09,151.84 112.97,151.72 112.97,151.62 112.88,151.53 112.78,151.53 112.69,151.62 112.69,151.76 U6E1.C15
  TOP w0.115: v1(126.55,174.45) 126.23,174.77 126.02,174.77 125.74,175.05 125.74,175.71 112.48,188.97 110.65,195.59 109.45,196.79 109.08,196.79 108.96,196.68 C6D8.1 ; v1(120.85,159.51) 121.28,159.09 121.28,158.1 121.45,157.92 121.45,156.58 121.15,156.28 121.15,154.56 119.39,152.79 117.92,152.79 116.89,151.76 114.49,151.76 114.49,151.76
  BOTTOM w0.115: v1(126.55,174.45) 126.84,174.74 127.03,174.74 127.15,174.62 127.15,173.92 126.51,172.65 126.51,167.17 125.07,164.38 123.77,163.08 123.77,161.99 122.23,160.45 121.66,160.45 121.27,160.05 121.27,159.75 121.03,159.51 v1(120.85,159.51)
USB31_P5_TX_DP: length 63.6
  TOP w0.089: 114.42,151.53 114.4,151.55 113.31,151.55 U6E1.B15
  TOP w0.115: C6D7.1 108.79,197.39 108.79,197.17 108.94,197.02 109.55,197.02 110.85,195.71 112.69,189.09 125.97,175.81 125.97,175.15 126.11,175 126.28,175 v1(126.55,175.28) ; v1(121.68,159.51) 121.51,159.33 121.51,158.19 121.68,158.01 121.68,156.48 121.38,156.18 121.38,154.46 119.48,152.56 118.02,152.56 116.99,151.53 114.42,151.53
  BOTTOM w0.115: v1(126.55,175.28) 126.87,174.97 127.13,174.97 127.38,174.72 127.38,173.86 126.74,172.59 126.74,167.12 125.26,164.24 124,162.98 124,161.89 122.32,160.22 121.76,160.22 121.5,159.96 121.5,159.7 v1(121.68,159.51)
USB31_P6_RX_DN: length 42.5
  TOP w0.115: C6D19.1 131.85,177.44 131.85,177.2 130.85,176.2 130.16,176.2 130.04,176.08 130.04,175.96 v1(130.34,175.66) ; U6E1.G14 v1(110.78,152.48)
  BOTTOM w0.089: v1(110.78,152.48) 110.85,152.41 111.46,152.41 111.46,152.4 111.86,152.4 112.12,152.67 113.45,152.67 113.47,152.66 113.53,152.66 113.54,152.65 113.56,152.65
  BOTTOM w0.115: 113.56,152.65 114.99,152.65 118.98,156.64 119.65,156.64 120.38,157.37 121.99,157.37 122.42,157.8 122.85,157.8 125.12,160.07 127.02,160.07 127.64,160.69 127.64,162.75 132,167.11 132,174.26 131.08,175.18 130.26,175.18 130.07,175.37 130.07,175.54 130.2,175.66 v1(130.34,175.66)
USB31_P6_RX_DP: length 42.5
  TOP w0.115: v1(129.51,175.66) 129.81,175.96 129.81,176.18 130.06,176.43 130.75,176.43 131.62,177.29 131.62,177.78 131.5,177.9 131.3,177.9 131.19,177.78 C6D18.1 ; v1(111.44,152.85) 111.43,152.85 111.22,152.64 111.22,152.45 111.36,152.31 U6E1.F14
  BOTTOM w0.089: v1(111.44,152.85) 111.44,152.72 111.55,152.61 111.77,152.61 112.04,152.88 113.56,152.88
  BOTTOM w0.115: 113.56,152.88 114.89,152.88 118.89,156.87 119.55,156.87 120.28,157.6 121.89,157.6 122.32,158.03 122.75,158.03 125.03,160.3 126.93,160.3 127.41,160.78 127.41,162.84 131.77,167.21 131.77,174.17 130.98,174.95 130.16,174.95 129.84,175.28 129.84,175.49 129.66,175.66 v1(129.51,175.66)
USB31_P6_RX_FP3_DN: length 2.5
  TOP w0.115: C6D19.2 131.76,178.87 131.76,179.35 131.92,179.51 131.92,180.19 132.02,180.28 EU6D1.5
USB31_P6_RX_FP3_DP: length 2.5
  TOP w0.115: C6D18.2 131.53,178.91 131.53,179.45 131.69,179.6 131.69,180.14 131.62,180.21 EU6D1.4
USB31_P6_TX_DN: length 41.1
  TOP w0.089: U6E1.C17 112.96,150.91 113.05,151 114.47,151 114.47,150.99
  TOP w0.115: v1(126.33,161.45) 126.03,161.15 126.03,160.92 123.06,157.95 123.06,156.86 122.04,155.85 122.04,154.13 119.9,151.99 118.33,151.99 117.34,150.99 114.47,150.99 ; v1(130.32,173.61) 130.04,173.88 130.04,174.12 130.3,174.37 131.82,174.37 134.51,177.06 134.51,177.44 C5D13.1
  BOTTOM w0.115: v1(126.33,161.45) 126.04,161.75 126.04,162.36 130.53,166.86 130.53,171.35 130.02,171.85 130.02,173.31 v1(130.32,173.61)
USB31_P6_TX_DP: length 41.1
  TOP w0.089: U6E1.C16 112.82,151.2 114.39,151.2 114.41,151.22
  TOP w0.115: v1(125.51,161.45) 125.8,161.16 125.8,161.02 122.83,158.05 122.83,156.96 121.81,155.94 121.81,154.23 119.81,152.22 118.24,152.22 117.24,151.22 114.41,151.22 ; v1(129.49,173.61) 129.81,173.93 129.81,174.21 130.2,174.6 131.73,174.6 134.28,177.16 134.28,177.58 134.17,177.7 133.88,177.7 C6D20.1
  BOTTOM w0.115: v1(129.49,173.61) 129.79,173.31 129.79,171.76 130.3,171.25 130.3,166.95 125.81,162.46 125.81,161.75 v1(125.51,161.45)
USB31_P6_TX_FP3_DN: length 3.2
  TOP w0.115: C5D13.2 134.33,178.98 134.33,179.58 133.89,180.02 133.34,180.02 133.22,180.13 EU6D1.8
USB31_P6_TX_FP3_DP: length 3.2
  TOP w0.115: C6D20.2 134.1,178.8 134.1,179.49 133.8,179.79 133.24,179.79 132.82,180.21 EU6D1.7
USB31_P7_RX_C_DN: length 2.2
  TOP w0.115: EU4B5.16 207.56,254.39 207.68,254.27 207.68,254.26 207.68,254.07 208.22,253.53 208.22,253.28 208.05,253.11 C3B10.1
USB31_P7_RX_C_DP: length 2.2
  TOP w0.115: C3B11.1 208.67,253.11 208.45,253.32 208.45,253.62 208.13,253.94 207.91,254.16 207.91,254.27 208.06,254.42 EU4B5.17
USB31_P7_RX_DN: length 196.5
  TOP w0.115: C3B10.2 208.12,251.99 208.12,251.67 208.37,251.42 209.77,251.42 210.04,251.69 210.04,251.9 v1(210.26,252.13) ; U6E1.G17 v1(110.78,151.08)
  BOTTOM w0.115: v1(110.78,151.08) 110.85,151.01 113.88,151.01 113.97,151.1 115.89,151.1 117.09,152.3 121.44,152.3 122.44,153.3 123.78,153.3 126.35,155.88 127.67,155.88 131.3,159.5 131.3,161.34 137.01,167.05 137.01,177.78 136.04,178.75 136.04,201.64 133.92,203.76 133.92,223.57 133.16,224.33 133.16,234.35 134.06,235.26 134.82,235.26 135.44,235.87 135.44,241.68 138.36,244.6 139.82,244.6 140.84,245.62 144.14,245.62 145.1,244.65 146.12,244.65 147.04,243.73 155.91,243.73 156.75,244.57 157.49,244.57 158.94,246.02 171.41,246.02 172.65,247.26 181.03,247.26 184.32,250.55 207.32,250.55 208.03,251.26 209.94,251.26 210.18,251.5 210.18,252.05 v1(210.26,252.13)
USB31_P7_RX_DP: length 196.5
  TOP w0.115: v1(209.46,252.13) 209.67,252.13 209.81,251.99 209.81,251.78 209.67,251.65 208.47,251.65 208.35,251.76 208.35,252.35 208.45,252.45 208.56,252.45 C3B11.2 ; v1(111.44,151.46) 111.63,151.46 111.83,151.26 111.83,150.95 111.72,150.84 111.51,150.84 U6E1.F16
  BOTTOM w0.115: v1(111.44,151.46) 111.66,151.24 113.79,151.24 113.88,151.33 115.79,151.33 117,152.53 121.34,152.53 122.34,153.53 123.68,153.53 126.26,156.11 127.57,156.11 131.07,159.6 131.07,161.43 136.78,167.14 136.78,177.69 135.81,178.66 135.81,201.55 133.69,203.67 133.69,223.47 132.93,224.23 132.93,234.44 133.97,235.49 134.73,235.49 135.21,235.96 135.21,241.77 138.26,244.83 139.73,244.83 140.74,245.85 144.24,245.85 145.2,244.88 146.21,244.88 147.14,243.96 155.81,243.96 156.65,244.8 157.39,244.8 158.84,246.25 171.32,246.25 172.56,247.49 180.94,247.49 184.23,250.78 207.23,250.78 207.94,251.49 209.84,251.49 209.95,251.6 209.95,251.78 209.6,252.13 v1(209.46,252.13)
USB31_P7_RX_ESD_DN: length 38.9
  TOP w0.115: C3A25.2 207.81,260.91 207.81,261.28 207.13,261.96 206.28,261.96 204.93,263.31 204.93,264.71 R4A16.1 204.85,265.17 204.92,265.25 204.92,265.64 204.69,265.87 204.69,266.24 204.57,266.36 U4A2.4 U4A2.7 204.57,267.87 204.72,268.01 204.72,268.73 v1(204.4,269.05)
  BOTTOM w0.115: v1(204.4,269.05) 204.71,269.36 204.71,269.46 204.58,269.58 204.17,269.58 203.89,269.29 203.89,268.72 203.38,268.22 201.42,268.22 200.91,268.73 196.59,268.73 193.29,272.03 193.29,273.36 192.46,274.19 185.67,274.19 184.65,275.21 184.65,276.7 184.46,276.9 J4A2.14
USB31_P7_RX_ESD_DP: length 38.9
  TOP w0.115: C3A26.2 208.04,260.92 208.04,261.37 207.23,262.19 206.38,262.19 205.16,263.41 205.16,264.71 R4A17.1 205.29,265.17 205.15,265.32 205.15,265.74 204.92,265.97 204.92,266.21 205.07,266.36 U4A2.5 U4A2.6 205.07,267.87 204.95,268 204.95,268.75 v1(205.24,269.05)
  BOTTOM w0.115: J4A2.15 184.99,276.9 184.88,276.79 184.88,275.3 185.76,274.42 192.55,274.42 193.52,273.45 193.52,272.13 196.69,268.96 201,268.96 201.51,268.45 203.29,268.45 203.66,268.82 203.66,269.39 204.08,269.81 204.68,269.81 204.94,269.55 204.94,269.35 v1(205.24,269.05)
USB31_P7_RX_RD_DN: length 2
  TOP w0.115: C3A25.1 207.82,259.38 207.82,258.97 207.7,258.85 207.7,258.5 207.56,258.36 EU4B5.23
USB31_P7_RX_RD_DP: length 2
  TOP w0.115: EU4B5.22 208.06,258.35 207.93,258.48 207.93,258.75 208.05,258.87 208.05,259.39 C3A26.1
USB31_P7_TX_C_DN: length 2
  TOP w0.115: C4B16.2 205.91,253.44 205.91,253.74 205.7,253.95 205.7,254.32 205.56,254.46 EU4B5.12
USB31_P7_TX_C_DP: length 2
  TOP w0.115: C4B17.2 206.14,253.44 206.14,253.83 205.94,254.03 205.93,254.05 205.93,254.32 206.06,254.45 EU4B5.13
USB31_P7_TX_CMC_DN: length 5.2
  TOP w0.115: C4A41.2 205.76,260.91 205.76,261.21 204.75,262.22 204.42,262.22 203.09,263.56 203.09,263.98 R4A21.1
USB31_P7_TX_CMC_DP: length 5.2
  TOP w0.115: C4A42.2 205.99,260.96 205.99,261.31 204.85,262.45 204.52,262.45 203.32,263.65 203.32,264.01 R4A15.2
USB31_P7_TX_DN: length 188.3
  TOP w0.115: v1(123.07,154.54) 122.79,154.54 122.69,154.44 122.69,153.87 120.18,151.36 118.71,151.36 117.82,150.47 114.12,150.47 114.03,150.56 U6E1.A17 ; v1(205.58,251.46) 205.89,251.46 206.01,251.59 206.01,252.3 205.9,252.41 205.71,252.41 205.58,252.29 C4B16.1
  BOTTOM w0.115: v1(205.58,251.46) 205.86,251.46 206.03,251.62 206.03,251.8 205.86,251.97 204.17,251.97 203.62,251.41 183.96,251.41 180.55,248 171.99,248 171.29,247.29 159.06,247.29 157.1,245.34 156.34,245.34 155.45,244.45 148.02,244.45 144.95,247.52 139.85,247.52 133.98,241.65 133.98,236.47 132.23,234.72 132.23,223.92 133.05,223.1 133.05,203.07 133.59,202.53 133.59,194.39 133.05,193.85 133.05,186.74 135.11,184.68 135.11,166.4 130.35,161.64 130.35,159.76 127.24,156.66 125.92,156.66 124.07,154.81 123.34,154.81 v1(123.07,154.54)
USB31_P7_TX_DP: length 188.3
  TOP w0.088: 114.12,150.79 113.49,150.79 U6E1.B17
  TOP w0.115: v1(123.07,155.37) 122.46,154.77 122.46,153.96 120.09,151.59 118.62,151.59 117.73,150.7 114.22,150.7 114.12,150.79 ; v1(206.47,251.46) C4B17.1
  BOTTOM w0.115: v1(123.07,155.37) 123.4,155.04 123.98,155.04 125.83,156.89 127.14,156.89 130.12,159.86 130.12,161.73 134.88,166.49 134.88,184.59 132.82,186.65 132.82,193.94 133.36,194.48 133.36,202.43 132.82,202.97 132.82,223.01 132,223.83 132,234.81 133.75,236.57 133.75,241.75 139.76,247.75 145.05,247.75 148.12,244.68 155.35,244.68 156.24,245.57 157.01,245.57 158.96,247.52 171.19,247.52 171.9,248.23 180.45,248.23 183.86,251.64 203.52,251.64 204.08,252.2 205.96,252.2 206.26,251.9 206.26,251.67 v1(206.47,251.46)
USB31_P7_TX_ESD_DN: length 23
  TOP w0.115: v1(201.65,269.01) 201.97,268.69 201.97,268.47 202.26,268.19 203.08,268.19 203.19,268.08 203.19,267.88 203.07,267.76 U4A2.10 U4A2.1 203.07,266.36 203.19,266.24 203.19,265.97 203.06,265.84 203.06,265.45 R4A21.2
  BOTTOM w0.115: v1(201.65,269.01) 202.05,269.4 202.05,269.98 201.72,270.31 201.12,270.31 200.74,269.93 196.64,269.93 194.23,272.33 194.23,273.85 192.95,275.13 191.68,275.13 190.63,276.18 190.63,276.72 190.46,276.9 J4A2.17
USB31_P7_TX_ESD_DP: length 23
  TOP w0.115: R4A15.1 203.29,265.48 203.29,265.75 203.42,265.87 203.42,266.21 203.57,266.36 U4A2.2 U4A2.9 203.57,267.75 203.42,267.9 203.42,268.18 203.17,268.42 202.35,268.42 202.2,268.57 202.2,268.72 v1(202.49,269.01)
  BOTTOM w0.115: J4A2.18 191.03,276.9 190.86,276.73 190.86,276.28 191.78,275.36 193.05,275.36 194.46,273.95 194.46,272.43 196.73,270.16 200.64,270.16 201.02,270.54 201.81,270.54 202.28,270.07 202.28,269.23 v1(202.49,269.01)
USB31_P7_TX_RD_DN: length 1.9
  TOP w0.115: EU4B5.27 205.56,258.39 205.75,258.58 205.75,259.42 C4A41.1
USB31_P7_TX_RD_DP: length 1.9
  TOP w0.115: C4A42.1 205.98,259.34 205.98,258.58 206.06,258.5 EU4B5.26
USB31_P8_RX_DN: length 67.4
  TOP w0.115: R6D11.1 109.72,182.82 110.09,182.82 117.02,179.39 124.71,171.7 126.85,168.2 132.09,162.97 132.83,161.63 133.92,160.55 134.1,160.55 v1(134.32,160.77) ; v1(106.94,149.25) 106.94,148.71 U6E1.R21
  BOTTOM w0.088: v1(106.94,149.25) 107.37,149.68 107.69,149.68 107.95,149.95 108.03,149.95 108.04,149.95 109.32,149.95 111.13,150.65 112.58,150.65 112.8,150.43
  BOTTOM w0.115: v1(134.32,160.77) 134.03,160.47 133.83,160.47 133.14,159.78 133.14,159.24 128.55,154.65 126.93,154.65 126.09,153.81 126.09,153.62 123.46,151 119.26,151 116.84,150.43 112.8,150.43
USB31_P8_RX_DP: length 67.4
  TOP w0.115: R6D10.1 109.34,182.32 109.34,182.52 109.41,182.59 110.04,182.59 116.88,179.2 124.52,171.56 126.67,168.05 131.9,162.83 132.65,161.49 133.82,160.32 134.21,160.32 134.32,160.2 v1(134.32,159.97) ; U6E1.P21 107.71,148.71 v1(107.71,149.25)
  BOTTOM w0.088: v1(107.71,149.25) 107.71,149.42 108.04,149.75 109.36,149.75 111.16,150.45 112.5,150.45 112.74,150.2
  BOTTOM w0.115: v1(134.32,159.97) 134.32,160.13 134.21,160.24 133.93,160.24 133.37,159.68 133.37,159.15 128.65,154.42 127.02,154.42 126.32,153.72 126.32,153.53 123.56,150.77 119.28,150.77 116.87,150.2 112.74,150.2
USB31_P8_RX_R_DN: length 8.6
  TOP w0.115: R6D11.2 108.65,183.01 108.65,182.75 108.53,182.63 107.58,182.63 107.44,182.78 U6D7.7 U6D7.4 105.94,182.78 105.82,182.65 105.52,182.65 104.37,183.8 103.69,185.84 103.69,186.12 103.96,186.39 J6C3.P15
USB31_P8_RX_R_DP: length 8.7
  TOP w0.115: J6C3.P16 103.16,186.39 103.46,186.09 103.46,185.81 104.17,183.68 105.19,182.66 105.42,182.42 105.78,182.42 105.93,182.28 U6D7.5 U6D7.6 107.42,182.28 107.54,182.4 108.36,182.4 R6D10.2
USB31_P8_TX_C_CMC_ESD_DN: length 5.9
  TOP w0.115: R6D13.2 107.91,184.31 107.58,184.31 107.44,184.18 107.17,184.18 U6D7.10 U6D7.1 106.15,184.13 105.9,184.13 105.82,184.21 105.82,184.84 105.93,184.95 105.93,185.95 106.04,186.07 106.26,186.07 106.36,186.17 J6C3.P12
USB31_P8_TX_C_CMC_ESD_DP: length 5.9
  TOP w0.115: J6C3.P13 105.56,186.23 105.7,186.09 105.7,185.04 105.59,184.93 105.59,184.12 105.8,183.9 106.17,183.9 U6D7.2 U6D7.9 107.24,183.95 107.54,183.95 107.67,184.08 108.21,184.08 R6D12.2
USB31_P8_TX_C_DN: length 1
  TOP w0.115: C6D6.2 109.2,184.46 108.97,184.46 R6D13.1
USB31_P8_TX_C_DP: length 1
  TOP w0.115: R6D12.1 108.97,184.23 109.19,184.23 C6D5.2
USB31_P8_TX_DN: length 60.6
  TOP w0.115: v1(122.7,151.78) 122.6,151.89 122.04,151.89 120.95,150.8 118.97,150.8 118.15,149.98 113.8,149.98 113.53,150.25 113.41,150.25 113.31,150.15 113.31,150.09 U6E1.B18 ; v1(134.35,161.67) 134.28,161.67 134.02,161.94 134.02,162.47 127.2,169.28 126.35,171.07 117.11,180.32 113.27,182.08 110.95,184.4 110.54,184.4 110.41,184.52 C6D6.1
  BOTTOM w0.115: v1(134.35,161.67) 134.1,161.42 134.1,161.25 133.82,160.97 133.42,160.97 132.37,159.92 132.37,159.36 128.16,155.15 126.72,155.15 123.7,152.13 123.05,152.13 v1(122.7,151.78)
USB31_P8_TX_DP: length 60.6
  TOP w0.115: v1(122.7,152.61) 122.7,152.45 122.37,152.12 121.95,152.12 120.86,151.03 118.88,151.03 118.06,150.21 113.89,150.21 113.63,150.48 113.32,150.48 113.2,150.36 113.11,150.36 U6E1.C18 ; v1(133.55,161.67) 133.79,161.91 133.79,162.37 126.99,169.16 126.99,169.18 126.16,170.94 116.98,180.12 113.13,181.89 110.85,184.17 110.62,184.17 110.41,183.97 C6D5.1
  BOTTOM w0.115: v1(133.55,161.67) 133.73,161.67 133.87,161.53 133.87,161.34 133.72,161.2 133.32,161.2 132.14,160.02 132.14,159.46 128.06,155.38 126.63,155.38 123.61,152.36 122.8,152.36 122.7,152.46 v1(122.7,152.61)
USB_FORCE_PWR: length 208
  TOP w0.089: U6E1.AA45 104.2,136.79 104.2,136.39 104.12,136.3 104.12,135.75 104.09,135.72 104.09,135.3 104.03,135.23 103.9,135.1 103.9,130.98 103.44,130.52 103.44,129.6 103.78,129.26 103.78,128.97
  TOP w0.1: v1(105.41,120.65) 104.97,121.08 104.97,124.4 104.51,124.86 104.51,127.68 103.78,128.42 103.78,128.97
  LAY5 w0.125: v1(105.41,120.65) 105.58,120.65 110.54,125.6 111.12,125.6 116.83,131.31 116.83,137.57 115.18,139.22 115.18,152.87 116.51,154.2 116.51,159.99 115.3,161.2 115.3,164.74 115.05,164.99 115.05,165.82 115.81,166.59 115.81,171.39 117.09,172.67 117.09,176.73 117.78,177.42 117.78,183.75 117.09,184.44 117.09,185.57 v1(116.58,186.08)
  LAY6 w0.125: v1(154.68,260.6) 154.43,260.35 150.22,260.35 148.95,259.09 146.25,259.09 145.61,258.45 143.97,258.45 142.41,256.89 142.41,256.21 141.07,254.87 137.98,254.87 131.24,248.14 131.24,246.55 123.58,238.89 123.58,238.33 123.06,237.81 123.06,236.09 124.2,234.95 124.2,226.95 126.04,225.11 126.04,218.57 127.38,217.23 127.38,215.79 127.95,215.22 127.95,213.45 128.43,212.96 128.43,210.6 127.03,209.2 127.03,200.92 125.89,199.78 125.89,189.84 127.75,187.98 127.75,186.15 124.6,183 118.87,183 116.58,185.29 v1(116.58,186.08)
  BOTTOM w0.1: v1(154.68,260.6) 155.82,260.6 R5L25.2 156.84,260.6 157.48,260.6 R5L24.2
USB_OC_BACK0_N: length 376.7
  TOP w0.1: R3A2.1 R3A3.2 v1(233.42,283.46)
  LAY5 w0.125: v1(99.31,108.71) 99.38,108.64 100.76,108.64 102.48,110.36 102.48,114.81 103.37,115.69 104.31,115.69 110.13,121.51 110.13,122.75 118.36,130.98 118.36,137.33 116.08,139.61 116.08,150.45 117.73,152.1 117.73,160.07 116.21,161.59 116.21,163.48 116.83,164.11 116.83,171.02 119.19,173.38 119.19,183.77 118.1,184.86 118.1,187.61 v1(117.37,188.34) ; v1(233.42,283.46) 227.96,278 225.82,278 224.31,276.49 222.38,276.49 219.13,273.24 210.62,273.24 205.61,278.26 205.61,285.04 201.86,288.79 177.61,288.79 176.1,287.28 176.1,285.24 177.16,284.17 177.16,281.78 176.65,281.27 176.65,280.11 176.19,279.65 172.21,279.65 170.94,278.39 168.68,278.39 167.04,280.02 163.15,280.02 162.17,279.04 162.17,277.39 161.38,276.6 147.6,276.6 144.22,279.98 144.22,283.79 142.82,285.19 136.7,285.19 135.38,283.87 135.38,280.44 133.09,278.15 133.09,275.48 132.71,275.1 132.71,272.99 131.95,272.23 130.98,272.23 129.41,270.66 129.41,268.35 128.77,267.71 124.46,267.71 123.9,268.27 122.57,268.27 122.27,267.97 117.26,267.97 116.8,267.5 115.23,267.5 114.8,267.08 110.51,267.08 107.97,264.54 106.55,264.54 v1(106.04,264.03)
  LAY6 w0.125: v1(117.37,188.34) 117.39,188.34 117.85,188.8 117.85,189.91 116.15,191.61 113.97,191.61 100.33,205.26 100.33,215.4 100.82,215.9 100.82,217.13 99.88,218.07 99.88,223.07 100.85,224.04 100.85,227.84 100.19,228.5 100.19,231.99 98.37,233.81 98.37,237.37 101.03,240.03 104.23,240.03 105.22,239.04 106.04,239.04 106.53,239.53 106.53,241.95 106.04,242.44 106.04,243.97 106.79,244.71 106.79,246.44 110.19,249.84 110.19,252.13 109.97,252.35 109.47,252.35 107.44,254.38 107.44,258.32 105.66,260.09 105.66,263.65 v1(106.04,264.03)
  BOTTOM w0.1: R6T5.1 100.45,113.79 101.09,113.16 101.09,111.25 100.07,110.23 100.07,109.47 v1(99.31,108.71)
USB_OC_BACK1_N: length 1.9
  TOP w0.1: R3B16.1 R3B15.1 229.23,255.4
USB_OC_BACK2_N: length 361.7
  TOP w0.1: v1(205.35,287.15) 205.99,286.51 205.99,276.86 205.74,276.6 R4A3.2 R4A4.1
  LAY5 w0.125: v1(123.44,186.05) 122.93,185.55 122.93,175.51 123.82,174.62 123.82,167.33 122.67,166.18 122.67,164.62 124.05,163.25 124.05,157.88 125.85,156.08 125.85,151.27 125.59,151 125.59,142.35 129.26,138.68 131.19,138.68 132.33,137.54 132.33,136.93 131.29,135.89 123.62,135.89 121.79,134.06 121.79,128.93 112.01,119.15 112.01,118.53 108.62,115.15 108.62,112.69 107.56,111.63 107.56,110.99 103.63,107.05 102.42,107.05 96.77,101.39 v1(96.77,100.71) ; v1(205.35,287.15) 203.46,289.04 177.51,289.04 175.84,287.38 175.84,285.13 176.91,284.07 176.91,281.89 176.4,281.38 176.4,280.21 176.09,279.9 172.11,279.9 170.84,278.64 168.78,278.64 167.14,280.27 163.05,280.27 161.92,279.14 161.92,277.49 161.28,276.85 147.7,276.85 144.47,280.08 144.47,283.89 142.92,285.44 136.6,285.44 135.12,283.97 135.12,280.54 132.84,278.26 132.84,275.59 132.46,275.21 132.46,273.09 131.84,272.48 130.87,272.48 129.16,270.76 129.16,268.45 128.67,267.97 124.56,267.97 124,268.53 122.47,268.53 122.16,268.22 118.29,268.22 118.01,268.5 115.5,268.5 115.24,268.24 111.27,268.24 107.95,264.92 106.82,264.92 v1(106.68,265.05)
  LAY6 w0.125: v1(106.68,265.05) 107.56,265.05 109.85,262.76 109.85,260.35 108.71,259.21 108.71,255.27 110.61,253.36 112.77,253.36 114.3,251.84 114.3,249.05 113.28,248.03 110.87,248.03 108.45,245.61 108.45,241.41 109.47,240.39 109.47,236.4 103.25,230.18 103.25,227.4 103.76,226.89 103.76,213.81 106.93,210.63 106.93,202.38 114.24,195.08 118.89,195.08 119.91,194.06 121.05,194.06 122.81,192.3 122.81,186.69 v1(123.44,186.05)
  BOTTOM w0.1: R7T27.1 v1(96.77,100.71)
USB_OC_USB2_FP_N: length 277.4
  TOP w0.1: v1(41.91,209.17) 42.03,209.04 43.59,209.04 43.68,209.13 44.72,209.13 45.17,209.59 53.86,209.59 55.4,208.05 60.67,208.05 65.5,212.88 65.5,219.94 66.16,220.6 71.37,220.6 73.66,218.31 76.32,218.31 76.96,217.68 R7C13.2 76.96,216.66 R7C15.1
  LAY5 w0.125: v1(46.99,76.2) 50.62,76.2 51.36,76.94 52.27,76.94 53.96,78.62 55.03,78.62 55.57,79.17 59.28,79.17 60.49,80.39 64.38,80.39 65.01,81.02 67.1,81.02 68.62,82.55 70.2,82.55 70.68,82.07 73.98,82.07 75.49,83.57 79.55,83.57 81.45,85.47 82.06,85.47 82.31,85.22 84.73,85.22 89.53,90.02 89.53,98.96 89.78,99.21 89.78,102.92 v1(90.37,103.5)
  LAY6 w0.125: v1(41.91,209.17) 42.92,208.15 42.92,206.32 42.42,205.82 42.42,204.37 42.79,203.99 42.79,201.93 42.23,201.37 42.23,199.47 42.93,198.78 42.93,193.08 43.82,192.19 43.82,184.9 44.7,184.02 45.33,184.02 46.48,182.88 46.48,176.66 45.97,176.15 45.97,171.83 47.37,170.43 47.37,169.31 46.25,168.2 46.25,160.3 45.46,159.51 45.46,155.6 48.03,153.03 48.03,149.2 46.76,147.93 46.76,145.97 46.22,145.44 46.22,139.06 46.76,138.53 46.76,135.76 46.05,135.06 46.05,133.6 46.69,132.97 47.75,132.97 51.43,129.28 51.43,120.52 46.4,115.49 46.4,99.14 46.99,98.55 46.99,95.59 45.74,94.34 45.74,80.57 46.35,79.96 46.35,77.32 46.99,76.68 v1(46.99,76.2)
  BOTTOM w0.1: R7T3.1 94.1,120.08 93.43,119.41 92.61,119.41 91.69,118.49 91.69,115.57 91.44,115.31 91.44,111.5 90.14,110.21 90.14,106.6 90.65,106.09 90.65,104.75 90.42,104.52 90.42,103.58 90.37,103.53 v1(90.37,103.5)
USB_OC_USB31_FP1_N: length 122.5
  TOP w0.1: v1(127.76,194.56) R6C20.2 R6C21.1
  LAY5 w0.125: v1(127.76,194.56) 128.39,193.93 128.39,192.02 125.6,189.23 125.6,186.86 126.48,185.99 126.48,180.15 127.13,179.49 127.13,173.49 126.87,173.23 126.87,170.05 127.25,169.67 129.38,169.67 130.7,168.35 130.7,165.77 129.92,164.99 129.92,159.17 136.51,152.57 136.51,138.8 130.42,132.71 126.23,132.71 124.99,131.47 124.99,127.66 123.62,126.29 119.55,126.29 112.26,119 112.26,118.43 108.98,115.15 108.98,111.41 107.96,110.4 107.33,110.4 103.73,106.8 102.96,106.8 100.33,104.16 v1(100.33,103.5)
  BOTTOM w0.1: v1(100.33,103.5) 99.82,103 R6T19.1
USB_OC_USB31_FP2_N: length 185.3
  TOP w0.1: v1(88.39,107.82) 88.72,108.15 88.72,114 89.61,114.88 89.61,117.17 R7F35.1 ; R6B26.2 R6B25.1 108.33,236.22 108.58,236.47 v1(108.58,236.96)
  LAY5 w0.125: v1(88.39,107.82) 89.28,106.93 90.55,106.93 91.29,106.19 95.69,106.19 95.69,106.18 100.49,106.18 102.11,107.81 103.32,107.81 106.81,111.3 106.81,113.8 107.3,114.29 107.3,116.56 112,121.26 112,121.76 120.01,129.77 120.01,133.71 122.93,136.62 122.93,137.62 121.91,138.64 121.91,141.5 118.41,145 118.41,150.37 122.55,154.51 122.55,155.57 123.05,156.07 123.05,162.83 121.66,164.21 121.66,166.73 122.8,167.87 122.8,174.21 121.89,175.13 121.89,184.56 v1(119.88,186.56)
  LAY6 w0.125: v1(108.58,236.96) 108.58,236.22 103.75,231.39 101.74,231.39 101.09,230.73 101.09,229 101.75,228.35 101.75,226.77 102.25,226.27 102.25,213.18 103.63,211.81 103.63,203.35 114.32,192.66 116.73,192.66 119.01,190.39 119.01,187.44 v1(119.88,186.56)
USBC_BP_ESD_CC1: length 48.7
  TOP w0.2: R5A22.2 v1(143.76,259.78) 143.76,259.21 C5A20.1 ; v1(171.57,281.19) CR4A6.1 171.19,282.21 171.19,282.72 171.35,282.88 J4A1.A5
  BOTTOM w0.2: v1(143.76,259.78) 144.71,260.73 145.54,260.73 147.53,262.73 147.53,263.61 146.1,265.04 146.1,268.99 148,270.89 150.49,270.89 150.93,271.32 150.93,271.65 152.57,273.29 157.8,273.29 162.46,277.96 162.46,278.97 165.68,282.19 166.75,282.19 167.63,281.31 171.46,281.31 v1(171.57,281.19)
USBC_BP_ESD_CC2: length 69.2
  TOP w0.2: R5A21.2 144.52,259.84 144.5,259.82 v1(144.5,259.78) 144.5,259.76 144.52,259.74 C5A19.1 ; J4A1.B5 170.1,286.22 169.79,286.53 169.79,287.62 v1(169.75,287.67)
  LAY5 w0.38: v1(175.89,280.38) 172.04,280.38 170.68,279.02 169.03,279.02 v1(166.37,281.68)
  BOTTOM w0.2: v1(175.89,280.38) 175.76,280.25 CR4L1.1 175.38,280.16 175.38,282.21 176.65,283.48 176.65,286.15 174.62,288.18 170.25,288.18 v1(169.75,287.67) ; v1(144.5,259.78) 145.12,260.4 145.67,260.4 147.86,262.59 147.86,263.74 146.43,265.17 146.43,268.86 146.81,269.24 148.71,269.24 149.09,268.86 150.62,268.86 151.25,269.49 151.25,271.51 152.7,272.97 157.94,272.97 162.79,277.82 162.79,278.76 165.71,281.68 v1(166.37,281.68)
USBC_BP_OC_EC_N: length 16.5
  TOP w0.1: CR8F2.1 v1(33.65,112.9) ; v1(27.43,103.76) 28.02,104.35 U8F6.10
  BOTTOM w0.1: v1(33.65,112.9) 32.76,112.01 32.76,110.36 30.08,107.68 30.08,106.65 29.98,106.55 29.97,106.55 28.32,104.9 28.32,104.65 v1(27.43,103.76)
USBC_BP_OC_PD_N: length 227.5
  TOP w0.1: EU5A1.41 146.21,269.53 146.43,269.75 146.43,270.13 145.92,270.64 145.87,270.64 v1(145.79,270.71)
  LAY5 w0.125: v1(89.4,105.92) 89.91,106.42 90.34,106.42 91.09,105.68 100.7,105.68 102.32,107.3 103.52,107.3 107.31,111.09 107.31,111.74 108.37,112.79 108.37,115.25 111.75,118.64 111.75,119.27 121.53,129.06 121.53,134.16 123.51,136.14 131.19,136.14 132.08,137.03 132.08,137.44 131.08,138.43 129.15,138.43 125.31,142.28 125.31,156.27 123.8,157.78 123.8,163.14 122.42,164.52 122.42,166.29 123.56,167.43 123.56,174.53 122.68,175.41 122.68,186.06 123.19,186.56 123.95,186.56 124.07,186.69 124.07,193.42 124.58,193.93 124.58,199.13 126.23,200.79 126.23,206.63 v1(124.58,208.28)
  LAY6 w0.125: v1(145.79,270.71) 146.05,270.46 146.05,263.88 144.55,262.38 142.77,262.38 141.88,261.49 141.14,261.49 131.06,251.41 130.33,251.41 127.27,248.35 127.27,246.66 120.01,239.39 120.01,238.31 118.84,237.14 118.84,226.44 119.47,225.8 120.77,225.8 123.34,223.24 123.34,216.26 124.19,215.4 124.19,213.6 124.56,213.23 124.56,208.31 v1(124.58,208.28)
  BOTTOM w0.1: CR7T1.1 89.02,110.23 89.4,109.85 v1(89.4,105.92)
USBC_BP_PD_CC1: length 2.7
  TOP w0.1: R5A22.1 143.76,262.3 143.27,262.79 143.27,263.19 143.36,263.29 EU5A1.24
USBC_BP_PD_CC2: length 2.6
  TOP w0.1: R5A21.1 144.27,261.75 144.27,263.19 144.16,263.29 EU5A1.26
USBC_BP_SBU1: length 16.1
  TOP w0.1: R4A2.1 170.18,279.67 169.95,279.67 v1(169.92,279.64)
  BOTTOM w0.1: R5L4.1 161.29,270.25 161.29,273.69 163.6,276 166.59,276 169.92,279.33 v1(169.92,279.64)
USBC_BP_SBU1_R_ESD: length 3.6
  TOP w0.2: 170.68,281.07 170.81,281.19 CR4A5.1 170.81,282.84 170.43,283.22 170.18,283.22 169.85,283.55 J4A1.A8
USBC_BP_SBU2: length 21.3
  BOTTOM w0.1: R4L1.1 171.95,279.91 170.83,281.03 169.61,281.03 168.29,279.7 168.29,278.02 166.49,276.22 163.5,276.22 160.14,272.86 160.14,269.62 R5L7.1
USBC_BP_SBU2_R_ESD: length 14.3
  TOP w0.1: J4A1.B8 171.6,286.05 172.08,286.53 v1(172.08,287.29)
  BOTTOM w0.1: v1(172.08,287.29) 172.21,287.42 174.75,287.42 176.02,286.15 176.02,283.73 174.75,282.46 174.75,280.41 174.24,279.91 CR4L2.1 R4L1.2
USBC_FP3_ACTVSW_DCI_CLK: length 4.7
  TOP w0.1: R6D30.1 126.23,186.05 127.65,184.64 EU6D1.32
USBC_FP3_ACTVSW_DCI_DATA: length 3.2
  TOP w0.1: EU6D1.29 129.51,185.84 129.41,185.94 129.41,187.07 R6D25.1
USBC_FP3_ACTVSW_I2C_EN: length 2.6
  TOP w0.1: R5D10.1 R5D11.2 134.87,184.4 134.63,184.64 EU6D1.17
USBC_FP3_CC1: length 2.9
  TOP w0.1: EU5A1.45 144.16,271.17 145.28,272.29 R5A53.1
USBC_FP3_CC2: length 2.5
  TOP w0.1: R5A54.1 143.36,273.03 EU5A1.47
USBC_FP3_CTL0: length 102.1
  TOP w0.1: v1(129.41,192.91) 132.08,192.91 132.33,192.66 R6D8.1 ; EU5A1.53 140.96,271.27 v1(141.35,271.65)
  LAY5 w0.125: v1(129.41,192.91) 129.55,192.91 130.24,193.6 130.24,195.45 127.88,197.81 127.88,208.43 124.63,211.68 124.63,212.71 124.01,213.33 123.54,213.33 v1(123.06,212.85)
  LAY6 w0.125: v1(141.35,271.65) 140.46,270.76 140.2,270.76 139.44,270 139.44,264.76 137.41,262.74 137.41,261.62 134.49,258.7 134.49,257.57 125.87,248.95 125.87,247.38 118.53,240.04 118.53,238.89 117.4,237.76 117.4,232.8 116.59,231.98 116.59,222.42 117.45,221.56 117.45,218.15 120.97,214.64 121.4,214.64 123.06,212.98 v1(123.06,212.85)
USBC_FP3_CTL0_SDA_R: length 6.3
  TOP w0.1: EU6D1.22 132.82,187.18 133.22,187.58 R6D24.2 R6D27.1 132.76,188.52 132.76,190.04 R6D9.2 R6D8.2
USBC_FP3_CTL1: length 6.8
  TOP w0.1: EU6D1.23 132.42,187.23 132.08,187.58 131.82,187.58 R6D26.1 R6D23.2 130.87,188.53 130.87,190.06 R6D22.1 R6D7.2
USBC_FP3_DCI_CLK: length 112.2
  TOP w0.1: v1(19.05,162.94) 16,162.94 R9D40.2 ; U7D1.4 91.82,189.36 92.71,188.47 92.71,187.07 92.07,186.43 R7D9.1 R7D7.2 90.44,185.95 80.62,185.95 79.78,186.79 66.86,186.79 64.22,184.15 53.08,184.15 52.63,183.69 52.63,179.81 50.74,177.93 43.12,177.93 42.25,177.05 38.47,177.05 38.37,176.95 38.37,176.37 38.27,176.27 38.07,176.27 37.97,176.37 37.97,176.95 37.87,177.05 37.48,177.05 37.38,176.95 37.38,176.34 37.28,176.24 37.08,176.24 36.98,176.34 36.98,176.95 36.88,177.05 36.68,177.05 36.58,176.95 36.58,176.34 36.48,176.24 36.28,176.24 36.18,176.34 36.18,176.95 36.08,177.05 35.68,177.05 35.58,176.95 35.58,176.34 35.48,176.24 35.28,176.24 35.18,176.34 35.18,176.95 35.08,177.05 34.88,177.05 34.78,176.95 34.78,176.34 34.68,176.24 34.48,176.24 34.38,176.34 34.38,176.95 34.28,177.05 34.08,177.05 33.98,176.95 33.98,176.34 33.88,176.24 33.68,176.24 33.58,176.34 33.58,176.95 33.48,177.05 33.07,177.05 31.39,175.38 31.39,174.05 30.57,173.22 30.57,171.96 30.92,171.6 30.92,169.09 30.26,168.43 28.29,168.43 26.32,170.4 19.65,170.4 v1(19.05,169.8)
  BOTTOM w0.1: v1(19.05,162.94) v1(19.05,169.8)
USBC_FP3_DCI_CLK_LT: length 102.8
  TOP w0.1: R7C46.2 v1(92.22,195.96) 92.71,195.48 92.71,194.82 92.58,194.69 91.56,194.69 91.35,194.48 U7D1.5 ; v1(126.61,186.69) 125.6,186.69 R6D30.2 ; R6D22.2 130.55,192.15 v1(129.41,192.15) ; R7D9.2 91.69,188.11 91.79,188.21 v1(92.22,188.21)
  LAY5 w0.125: v1(94.1,212.72) 96.45,210.37 98.43,210.37 101.72,207.08 104.02,207.08 107.61,210.67 118.51,210.67 120.24,212.4 121.92,212.4 123.17,213.66 124.15,213.66 124.95,212.86 124.95,211.82 128.21,208.56 128.21,197.95 130.58,195.58 130.58,193.47 130.05,192.94 130.05,192.4 129.8,192.15 v1(129.41,192.15) 129.41,191.77 125.92,188.28 125.92,187.38 v1(126.61,186.69)
  BOTTOM w0.1: v1(92.22,188.21) 92.2,188.21 91.82,188.59 91.82,194.05 92.71,194.94 92.71,195.48 v1(92.22,195.96) 92.68,196.42 92.68,197.67 93.21,198.2 93.21,204.82 93.85,205.45 93.85,212.47 v1(94.1,212.72)
USBC_FP3_DCI_DATA: length 106.7
  TOP w0.1: v1(19.05,162.18) 16,162.18 14.29,163.88 14.29,165.17 R9D38.2 ; U7D1.3 90.7,188.5 90.42,188.21 90.42,186.69 90.17,186.43 R7D6.2 R7D8.1 88.01,186.43 85.72,188.72 80.45,188.72 79.93,188.2 66.31,188.2 63.5,185.39 53.59,185.39 52.15,183.94 52.15,180.01 50.54,178.4 42.92,178.4 42.05,177.53 32.87,177.53 30.92,175.57 30.92,174.24 30.09,173.42 30.09,171.58 30.45,171.22 30.45,169.29 30.06,168.9 28.48,168.9 26.51,170.88 19.23,170.88 v1(19.05,170.69)
  BOTTOM w0.1: v1(19.05,170.69) 18.57,170.21 18.57,162.4 18.79,162.18 v1(19.05,162.18)
USBC_FP3_DCI_DATA_LT: length 97.3
  TOP w0.1: R7D8.2 v1(89.15,187.98) ; v1(92.22,195.2) 90.8,195.2 90.7,195.1 U7D1.6 ; R7C42.2 92.1,196.85 v1(92.22,196.72) ; R6D25.2 v1(128.39,189.74)
  LAY5 w0.125: v1(93.47,213.87) 93.98,213.36 94.38,213.36 96.91,210.83 98.55,210.83 101.98,207.4 103.88,207.4 107.48,211 118.36,211 120.09,212.73 121.77,212.73 123.03,213.98 124.3,213.98 125.28,213 125.28,211.96 128.54,208.7 128.54,198.08 130.91,195.71 130.91,193.33 130.38,192.8 130.38,192.08 128.39,190.09 v1(128.39,189.74)
  BOTTOM w0.1: v1(89.15,187.98) 90.17,189 90.17,190.88 90.67,191.39 90.67,193.65 v1(92.22,195.2) 91.71,195.71 91.71,196.21 v1(92.22,196.72) 92.22,197.65 92.83,198.26 92.83,204.86 93.55,205.58 93.55,213.79 v1(93.47,213.87)
USBC_FP3_DPEQ0_A1: length 2.5
  TOP w0.1: R5D13.1 R5D12.2 134.62,183.51 134.54,183.44 EU6D1.14
USBC_FP3_DPEQ1: length 4.5
  TOP w0.1: R6D46.2 R6D43.1 129.3,179.34 130.07,179.34 130.82,180.09 EU6D1.2
USBC_FP3_EQ0: length 5
  TOP w0.1: EU6D1.38 125.86,182.24 R6D36.1 R6D37.2
USBC_FP3_EQ1: length 5
  TOP w0.1: R6D32.1 R6D35.2 127.88,183.51 127.96,183.44 EU6D1.35
USBC_FP3_ESD_CC1: length 96.1
  TOP w0.2: 122.3,207.01 CR6C6.2 122.82,207.24 ; v1(144.39,272.16) C5B9.1 R5A53.2
  TOP w0.38: 122.82,207.24 C6C6.1 124.07,207.01 v1(124.58,207.52) ; J6C4.P8 120.8,205.05 122.3,206.55 122.3,207.01
  LAY6 w0.2: v1(144.39,272.16) 144.45,272.21 147.05,272.21 148.64,270.63 148.64,267.47 147.75,266.58 147.75,263.07 146.27,261.59 143.1,261.59 142.2,260.7 141.47,260.7 140.79,260.02 140.79,256.89 140.42,256.52 137.33,256.52 131.42,250.61 130.66,250.61 128.07,248.02 128.07,246.33 121.59,239.85 121.59,238.77 121.13,238.31 119.63,236.81 119.63,234.95 121.43,233.14 121.43,227.42 124.13,224.72 124.13,217.65 125.51,216.27 125.51,207.93 125.09,207.52 v1(124.58,207.52)
USBC_FP3_ESD_CC2: length 111.4
  TOP w0.2: v1(142.62,272.41) C5B10.1 R5A54.2
  LAY6 w0.2: v1(114.42,197.86) 115.31,198.75 124.46,198.75 126.69,200.99 126.69,211.5 125.83,212.36 125.83,216.41 124.46,217.79 124.46,224.86 121.76,227.55 121.76,234.72 120.14,236.35 120.14,236.85 121.91,238.63 121.91,239.72 128.39,246.2 128.39,247.88 130.79,250.29 131.55,250.29 137.46,256.19 140.55,256.19 141.11,256.75 141.11,258.59 141.98,259.46 141.98,260.01 143.23,261.26 146.41,261.26 148.08,262.94 148.08,266.44 148.97,267.33 148.97,270.76 147.19,272.54 145.03,272.54 144.87,272.7 142.91,272.7 v1(142.62,272.41)
USBC_FP3_FLIP: length 110.1
  TOP w0.1: v1(127.76,193.57) 128.95,194.76 128.95,195.38 129.31,195.74 133.31,195.74 136.65,192.4 136.65,188.59 R5D9.1 ; EU5A1.54 v1(140.56,271.65)
  LAY5 w0.125: v1(123.06,211.91) 123.06,211.88 126.87,208.07 126.87,194.46 v1(127.76,193.57)
  LAY6 w0.125: v1(140.56,271.65) 139.19,270.27 139.19,264.87 137.16,262.84 137.16,261.73 134.24,258.8 134.24,257.68 125.61,249.05 125.61,247.48 118.28,240.15 118.28,239 117.15,237.87 117.15,232.9 116.33,232.09 116.33,218.92 120.86,214.39 121.29,214.39 122.18,213.5 122.18,212.97 123.06,212.09 v1(123.06,211.91)
USBC_FP3_FLIP_SCL_R: length 5.6
  TOP w0.1: R5D6.2 135.25,190.37 R5D8.2 R5D9.2 R6D28.1 134.11,187.7 133.22,186.82 EU6D1.21
USBC_FP3_OC_EC_N: length 18.4
  TOP w0.1: CR8F1.1 v1(30.22,112.9) ; U8F6.20 24.02,104.49 25,103.5 26.92,103.5 v1(27.43,103)
  BOTTOM w0.1: v1(30.22,112.9) 29.71,112.9 27.81,111 27.81,107.06 26.92,106.17 26.92,103.5 v1(27.43,103)
USBC_FP3_OC_PD_N: length 272
  TOP w0.1: EU5A1.55 140.16,271.31 v1(139.82,271.65) ; CR6H2.1 v1(113.03,58.8)
  LAY5 w0.125: v1(104.13,87.29) 104.13,87.78 113.89,97.54 113.89,105.58 114.82,106.51 114.82,106.93 113.98,107.77 113.98,109.58 114.31,109.9 114.31,113.62 119.81,119.12 121.92,119.12 123.81,121.01 124.82,121.01 126.84,119 128.91,119 134.1,124.18 134.1,131.94 140.01,137.85 140.01,152.86 132.59,160.28 132.59,163.87 133.38,164.66 133.38,167.96 134.2,168.77 134.2,170.65 133.02,171.83 133.02,175.61 132.07,176.56 132.07,177.82 130.3,179.6 130.3,183.77 130.93,184.4 131.32,184.4 131.7,184.78 131.7,185.16 131.19,185.67 131.19,190.22 132.14,191.17 132.14,192.07 132.71,192.64 132.71,196.4 132.45,196.66 132.45,201.75 131.31,202.9 131.31,211.04 128.24,214.12 126.31,214.12 125.47,214.96 122.6,214.96 121.51,213.87 v1(121.03,213.87)
  LAY6 w0.125: v1(121.03,213.87) 116.08,218.81 116.08,232.19 116.9,233.01 116.9,237.97 118.03,239.1 118.03,240.25 125.36,247.59 125.36,249.16 133.99,257.78 133.99,258.91 136.91,261.83 136.91,262.95 138.93,264.97 138.93,270.76 v1(139.82,271.65) ; v1(104.13,87.29) 104.13,86.48 104.77,85.83 104.77,78.43 104.73,78.38 104.73,77.82 104.77,77.78 104.77,67.25 104.73,67.21 104.73,66.65 104.77,66.61 104.77,64.17 108.91,60.02 111.8,60.02 v1(113.03,58.8)
USBC_FP3_RX1_DN: length 6.8
  TOP w0.115: EU6D1.30 129.94,185.47 129.58,185.47 129.39,185.27 129.05,185.27 127.76,186.56 127.76,188.23 126.74,189.24 126.74,189.67 126.86,189.79 127.07,189.79 C6D2.1
USBC_FP3_RX1_DP: length 6.8
  TOP w0.115: EU6D1.31 128.95,185.04 127.53,186.47 127.53,188.13 126.51,189.15 126.51,189.46 C6D1.1
