# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Library data of the parts (continued)
R1C21 = RES: alternate symbols: (); part number: RES_0402-A93549-028,CHIP,1M,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_1_2
R1C26 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_1000.000000OHM_1_2
R1C31 R1C33 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_100000OHM_1_2
R1C38 = RES: alternate symbols: (); part number: RES_0402-A93548-005,CHIP,150,1%,1/16W,LPDB,GENERIC
R1C42 R1C44 R1C46 R3B9 R3B10 R3B25 R4B19 R4B35 R5C38 R5D11 R5D13 R5D14 R5D19 R5H14 R6D35 R6D36 R6D46 R6D47 R7F22 R8F37 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC
R1C45 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 135
R1C47 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 135
R1C94 R2A38 R2A39 R2M2 R3M10 R3M12 R4M10 R5D10 R5D12 R5D15 R6A67 R6D32 R6D37 R6D43 R6D44 R6H22 R7C26 R7C30 R7F34 R7G1 R7H23 R7H24 R7H28 R7H39 R7H45 R7H56 R7H60 R7H62 R7H66 R7T14 R7T15 R8E11 R8E31 R8E39 R8E40 R8G48 R8G49 R8G53 R8G54 R8H54 R9A3 R9G5 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC
R1D2 = RES: alternate symbols: (); part number: RES_0402-A93548-518,CHIP,8.2K,1%,1/16W,LPDB,GENERIC
R1D4 R1D7 R2B10 R2B11 R3B33-R3B35 R4B24-R4B26 = RES: alternate symbols: (); part number: RES_0603-A93551-133,CHIP,2.2,5%,1/10W,LPDB,GENERIC
R1D5 R1D8 R2B5-R2B7 R3B26-R3B28 R4B20 R4B21 R6W4 = RES: alternate symbols: (); part number: RES_0603-A93550-324,CHIP,1,1%,1/10W,LPDB,GENERIC
R1D16 R1E15 R1E31 R3H23 R4H25 R4H28 R5A34 R5A35 R5A41 R5B8 R5C30 R5C69 R5D42 R5L8 R5L9 R5M10 R7A14 R7E31 R7E51 R7F3 R7F9 R7G7 R7G18 R7R50 R8H40 R8H45 R8H49 R8H53 R8H55 = RES: alternate symbols: (); part number: RES_0402-A93549-027,CHIP,100K,5%,1/16W,LPDB,GENERIC
R1E4 R1E16 R1E35 R3A45 R3A46 R3H29 R3H33 R4H31 R5C72 R5M6 R5M13 R5M15 R7E8 R7F24 R7T10 R8D94 = RES: alternate symbols: (); part number: RES_0402-A93549-027,EMPTY,100K,5%,1/16W,LPDB,GENERIC
R1E8 = RES: alternate symbols: (); part number: RES_0402-A93548-494,RES,5.23K,1%,1/16W,LPDB,GENERIC
R1E17 R9C6 = RES: alternate symbols: (); part number: RES_0402-A93549-101,CHIP,6.2K,5%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R1E18 R9C7 = RES: alternate symbols: (); part number: RES_0402-A93548-132,CHIP,15K,1%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R1E19 R2B42 = RES: alternate symbols: (); part number: RES_0402-A93548-201,CHIP,806,1%,1/16W,LPDB,GENERIC
R1E23 R1E24 R2A70 R5J5 R6J8 R6J23 R7B29 R7B66 R7B70 R7E27 R7E30 R7E34 R7E44 R7H26 R7H33 R7H37 R7H42 R7H48-R7H50 R7H52 R7H53 R7H58 R7H59 R7R11 R7R33 R7R39 R7R49 R7R63 R8C69 R8C74 R8C84 R8D47 R8D59 R8E57 R8F8 R8G55 R8G57 R8G58 R8G64 R8G76 R8G77 R8H1 R8H2 R8H4 R8H5 R8H26 R8H30 R8H31 R8R1 R8R2 R8R4 R8R5 R8R8 R8R9 R8R11 R8R12 R9D12 R9D16 R9D38 R9D40 R9H16 R9H21 R9J2 R9J4 R9J6 R9J7 R9J10 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: LPSS
R1E25 R6F41 R9C5 = RES: alternate symbols: (); part number: RES_0402-A93549-019,CHIP,3.3K,5%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R1E32 R2M18 R2M19 R2N1 R2P3 R2P5 R3M41 R3M42 R4M27 R4M28 R8B5 R8B10 R8G69 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-E41880-003,CHIP,0.002,1%,2W,LPDB,GENERIC
R1E33 R5C51 R5C52 R5D25 R5D26 R9C2 = RES: alternate symbols: (); part number: RES_0805-A93552-002,CHIP,0,5%,1/8W,LPDB,GENERIC; room: FAN_CNTL
R1E38 = RES: alternate symbols: (); part number: RES_0402-A93548-569,CHIP,2.05K,1%,1/16W,LPDB,GENERIC
R1F3 R1F5 R1F21 R1F22 R1F32 R1F34 R1F39 R1F43 = RES: alternate symbols: (); part number: RES_0402-A93548-138,CHIP,2K,1%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH
R1F6 R1F26 = RES: alternate symbols: (); part number: RES_0402-A93548-149,CHIP,2,1%,1/16W,LPDB,GENERIC; room: DCL_PCIX
R1F7 R1F8 = RES: alternate symbols: (); part number: RES_0402-A93548-067,CHIP,24.9,1%,1/16W,LPDB,GENERIC; room: 31
R1F12 R1F52 = RES: alternate symbols: (); part number: RES_0402-A93548-149,CHIP,2,1%,1/16W,LPDB,GENERIC; room: EV
R1F25 R1F50 = RES: alternate symbols: (); part number: RES_0402-A93548-067,CHIP,24.9,1%,1/16W,LPDB,GENERIC
R2A1 RT2A1 = RES: alternate symbols: (); part number: RES_0603-D71825-005,CHIP,50MOHM,1%,2/5W,LPDB,GENERIC; room: DP_HDMI_COMBO_CONNECTOR
R2A2 = RES: alternate symbols: (); part number: RES_0402-A93549-037,CHIP,47K,5%,1/16W,LPDB,GENERIC
R2A3 R2A5 R5A59 R5A60 R5B6 R5B7 R5L21 R7H15 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC
R2A4 = RES: alternate symbols: (); part number: RES_0402-A93549-033,CHIP,560,5%,1/16W,LPDB,GENERIC
R2A6 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-H11304-001,CHIP,10MOHM,01%,1/4W,LPDB,GENERIC; room: 62
R2A7 = RES: alternate symbols: (); part number: RES_0402-A93549-028,CHIP,1M,5%,1/16W,LPDB,GENERIC; room: DP_HDMI_COMBO_CONNECTOR
R2A8 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: RAIL_FET_SWITCH
R2A9 = RES: alternate symbols: (); part number: RES_0402-A93549-036,EMPTY,20K,5%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH
R2A10 = RES: alternate symbols: (); part number: RES_0402-A93549-028,CHIP,1M,5%,1/16W,LPDB,GENERIC; room: 59
R2A11-R2A18 = RES: alternate symbols: (); part number: RES_0201-C80792-009,EMPTY,0,5%,1/20W,LPDB,GENERIC; room: 58
R2A19 R2A20 R2A32 R2A33 = RES: alternate symbols: (); part number: RES_0402-A93549-027,CHIP,100K,5%,1/16W,LPDB,GENERIC; room: 59
R2A21 R2A53 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 62
R2A22 R2A23 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC; room: 62
R2A24-R2A31 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 61
R2A34 R2G8 R4C16 R4C19 R5B54 R5C14 R5D27 R5D29 R5G14 R6A3 R6A4 R6A29 R6A34 R6J1 R6T12 R7C43 R7G26 R7R36 R7R37 R7R48 R7T22 R8A11 R8F38 R8F54 R8G8 R8G28 R8G35 R8H29 R9A23 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC
R2A35 R2A60 R3A25 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: LSPCON_CHIP
R2A36 R2A46 R2A50 R2A54 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC; room: HDMI
R2A37 R2A41 R2A43-R2A45 R2A69 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: 60
R2A40 R2A42 R2A56 R5J6 R6B10 R6J10 R6J14 R6J21 R6J22 R7E29 R7E45 R7H25 R7H29 R7H31 R7H32 R7H35 R7H36 R7H40 R7H43 R7R13 R7R18 R7R21 R7R34 R7V1 R7V2 R8D53 R8E62 R8F5 R8G50 R8G51 R8G59 R8G62 R8G63 R8G65 R8G83 R8G84 R8H3 R8H25 R8H27 R8H28 R9D17 R9D18 R9D39 R9D41 R9H17 R9J1 R9J9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: LPSS
R2A47 R2A58 R7P6 R7T4 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-C49684-019,CHIP,0.022,1%,1/16W,LPDB,GENERIC
R2A48 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 62
R2A49 R3A5 R5C8 R5G20 R7B53 R7B64 R8C48 R8E52 R8E53 R8G40 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH
R2A52 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 60
R2A57 = RES: alternate symbols: (); part number: RES_0402-A93548-186,CHIP,200K,1%,1/16W,LPDB,GENERIC; room: 173
R2A59 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 173
R2A61 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 60
R2A62 R2L2 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: LSPCON_CHIP
R2A63 = RES: alternate symbols: (); part number: RES_0402-A93548-259,CHIP,402K,1%,1/16W,LPDB,GENERIC; room: 173
R2A64 = RES: alternate symbols: (); part number: RES_0402-A93549-084,EMPTY,330K,5%,1/16W,LPDB,GENERIC
R2A65 = RES: alternate symbols: (); part number: RES_0402-A93549-084,EMPTY,330K,5%,1/16W,LPDB,GENERIC; room: 173
R2A66 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: LSPCON_CHIP
R2A67 = RES: alternate symbols: (); part number: RES_0402-A93549-027,CHIP,100K,5%,1/16W,LPDB,GENERIC; room: LSPCON_CHIP
R2A68 = RES: alternate symbols: (); part number: RES_0402-A93548-202,CHIP,4.99K,1%,1/16W,LPDB,GENERIC; room: 60
R2B3 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 173
R2B4 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 173
R2B20 R2B34 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC; room: 169
R2B22 = RES: alternate symbols: (); part number: RES_0402-A93548-004,EMPTY,110,1%,1/16W,LPDB,GENERIC
R2B23 = RES: alternate symbols: (); part number: RES_0402-A93548-069,CHIP,45.3,1%,1/16W,LPDB,GENERIC
R2B26 R5B87 R5G8 = RES: alternate symbols: (); part number: RES_0402-A93548-031,CHIP,10,1%,1/16W,LPDB,GENERIC
R2B28 R5B83 = RES: alternate symbols: (); part number: RES_0402-A93548-045,CHIP,49.9,1%,1/16W,LPDB,GENERIC
R2B29 = RES: alternate symbols: (); part number: RES_0402-A93548-506,CHIP,36.5K,1%,1/16W,LPDB,GENERIC
R2B30 = RES: alternate symbols: (); part number: RES_0402-A93548-087,CHIP,357,1%,1/16W,LPDB,GENERIC
R2B31 R2G1 R2M16 R2M17 R2P4 R2P6 R3M36 R3M37 R4M23-R4M25 R5D1 R5D36 R5M2 R5U2 = RES: alternate symbols: (); part number: RES_1206-A93559-144,EMPTY,2.2,5%,1/4W,LPDB,GENERIC
R2B33 = RES: alternate symbols: (); part number: RES_0402-A93548-190,CHIP,37.4K,1%,1/16W,LPDB,GENERIC
R2B37 R2C8 = RES: alternate symbols: (); part number: RES_0402-A93548-447,CHIP,23.7K,1%,1/16W,LPDB,GENERIC
R2B38 = RES: alternate symbols: (); part number: RES_0402-A93548-456,CHIP,3.16K,1%,1/16W,LPDB,GENERIC
R2B40 R2B61 = RES: alternate symbols: (); part number: RES_0402-A93548-131,CHIP,73.2K,1%,1/16W,LPDB,GENERIC
R2B41 R5L3 R5L5 R6B1 R7R7 = RES: alternate symbols: (); part number: RES_0402-A93548-060,CHIP,200,1%,1/16W,LPDB,GENERIC
R2B45 = RES: alternate symbols: (); part number: RES_0402-A93548-653,CHIP,2.4K,1%,1/16W,LPDB,GENERIC
R2B46 = RES: alternate symbols: (); part number: RES_0402-A93548-204,CHIP,19.6K,1%,1/16W,LPDB,GENERIC
R2B47 = RES: alternate symbols: (); part number: RES_0402-A36092-329,CHIP,11.5,1%,1/16W,LPDB,GENERIC
R2B48 = RES: alternate symbols: (); part number: RES_0402-A93548-619,CHIP,23.7,1%,1/16W,LPDB,GENERIC; room: 169
R2B49 = RES: alternate symbols: (); part number: RES_0402-A93548-272,CHIP,7.15K,1%,1/16W,LPDB,GENERIC
R2B50 = RES: alternate symbols: (); part number: RES_0402-A93548-103,CHIP,825,1%,1/16W,LPDB,GENERIC
R2B53 R6A81 = RES: alternate symbols: (); part number: RES_0402-A93548-017,CHIP,11.5K,1%,1/16W,LPDB,GENERIC
R2B54 = RES: alternate symbols: (); part number: RES_0402-A93548-542,CHIP,8.66K,1%,1/16W,LPDB,GENERIC
R2B55 R2M9 R3M24 R3M25 R4M17 = RES: alternate symbols: (); part number: RES_0402-A93548-252,RESISTOR,3.9,1%,1/16W,LPDB,GENERIC
R2B56 R2C9 = RES: alternate symbols: (); part number: RES_0402-A93548-275,CHIP,8.45K,1%,1/16W,LPDB,GENERIC
R2B59 = RES: alternate symbols: (); part number: RES_0402-A93548-548,CHIP,316,1%,1/16W,LPDB,GENERIC
R2B62 = RES: alternate symbols: (); part number: RES_0402-A93548-386,CHIP,1.27K,1%,1/16W,LPDB,GENERIC
R2C1 = RES: alternate symbols: (); part number: RES_0402-A93548-064,CHIP,12.4K,1%,1/16W,LPDB,GENERIC
R2C2 = RES: alternate symbols: (); part number: RES_0402-G21796-061,CHIP,51.1K,1%,1/16W,LPDB,GENERIC; room: 169
R2C4 = RES: alternate symbols: (); part number: RES_0402-G64084-153,CHIP,402,1%,1/16W,LPDB,GENERIC; room: 169
R2C5 R5B77 = RES: alternate symbols: (); part number: RES_0402-A93548-130,CHIP,27.4K,1%,1/16W,LPDB,GENERIC
R2C10 = RES: alternate symbols: (); part number: RES_0402-A93548-335,CHIP,16.9K,1%,1/16W,LPDB,GENERIC
R2C11 = RES: alternate symbols: (); part number: RES_0402-A93548-526,CHIP,732,1%,1/16W,LPDB,GENERIC
R2C13 = RES: alternate symbols: (); part number: RES_0402-A93548-002,CHIP,40.2,1%,1/16W,LPDB,GENERIC
R2C16 = RES: alternate symbols: (); part number: RES_0402-A93548-068,CHIP,30.1,1%,1/16W,LPDB,GENERIC
R2C18 R2C19 = RES: alternate symbols: (); part number: RES_0402-A93548-191,CHIP,3.48K,1%,1/16W,LPDB,GENERIC
R2C20 R2C21 R7B13 R7B14 = RES: alternate symbols: (); part number: RES_0402-A93549-017,EMPTY,2.2K,5%,1/16W,LPDB,GENERIC
R2C22 R2M1 R3M9 R3M11 R4M9 = RES: alternate symbols: (); part number: RES_0805-A93555-148,CHIP,6.8,5%,1/8W,LPDB,GENERIC
R2C23 = RES: alternate symbols: (); part number: RES_0805-A93555-148,EMPTY,6.8,5%,1/8W,LPDB,GENERIC
R2C24 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 169
R2C26 R7D12 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,EMPTY,100,1%,1/16W,LPDB,GENERIC
R2C27 R2C29 R2C31 R7D18 R7D33 = RES: alternate symbols: (); part number: RES_0402-A93549-007,EMPTY,51,5%,1/16W,LPDB,GENERIC
R2C28 R7D22 R7D27 = RES: alternate symbols: (); part number: RES_0402-A93549-007,CHIP,51,5%,1/16W,LPDB,GENERIC
R2C32 R2G2 R4B41 R4D1 R5E1 R6F30 R6F37 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-C44950-008,CHIP,.002,1%,1/2W,LPDB,GENERIC
R2G5 = RES: alternate symbols: (); part number: RES_0603-D71825-003,CHIP,0.01,0.5%,1/10W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.01OHM_1_2
R2G12 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 164
R2G13 = RES: alternate symbols: (); part number: RES_0805-A93555-018,CHIP,51,5%,1/8W,LPDB,GENERIC; room: 179
R2G15 R6A82 R7A8 R7B79 R7B82 R7D5 R7E55 R7U12 R8C70 R8C71 = RES: alternate symbols: (); part number: RES_0402-A93548-325,CHIP,75K,1%,1/16W,LPDB,GENERIC
R2G16 R2G17 R2G24 R2G30 R2G38 R2G39 R8D11 R8D50 R8D54 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 179
R2G19 R8D12 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 179
R2G23 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: 179
R2G25 = RES: alternate symbols: (); part number: RES_0402-A93548-197,CHIP,6.04K,1%,1/16W,LPDB,GENERIC
R2G27 R6A58 = RES: alternate symbols: (); part number: RES_0402-C59248-002,CHIP,619K,1%,1/16W,LPDB,GENERIC
R2G32 = RES: alternate symbols: (); part number: RES_0402-A93548-476,EMPTY,47K,1%,1/16W,LPDB,GENERIC; room: 179
R2G34 = RES: alternate symbols: (); part number: RES_0402-A93549-036,EMPTY,20K,5%,1/16W,LPDB,GENERIC; room: 179
R2L1 R3A28 R3L2 R3L3 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: LSPCON_CHIP
R2M12-R2M15 R3M30-R3M35 R3M38 R3M39 R4M20-R4M22 R4M26 = RES: alternate symbols: (); part number: RES_0603-A93550-492,CHIP,2.32K,1%,1/10W,LPDB,GENERIC
R3A1 R3A3 R3A22 R3B11 R4A1 R4A3 R6B26 R6B27 R6C19 R6C20 R7C13 R7C21 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: USB_OUT
R3A2 R3B15 R4A4 R6B25 R6C21 R7C15 = RES: alternate symbols: (); part number: RES_0402-A93548-132,CHIP,15K,1%,1/16W,LPDB,GENERIC; room: USB_OUT
R3A4 = RES: alternate symbols: (); part number: RES_0402-A93549-019,CHIP,3.3K,5%,1/16W,LPDB,GENERIC
R3A6-R3A13 = RES: alternate symbols: (); part number: RES_0201-C80792-009,EMPTY,0,5%,1/20W,LPDB,GENERIC; room: DP_HDMI_COMBO_CONNECTOR
R3A14-R3A21 = RES: alternate symbols: (); part number: RES_0402-A93548-328,CHIP,5.11,1%,1/16W,LPDB,GENERIC; room: LSPCON_CHIP
R3A23 = RES: alternate symbols: (); part number: RES_0402-A93549-019,EMPTY,3.3K,5%,1/16W,LPDB,GENERIC
R3A24 = RES: alternate symbols: (); part number: RES_0402-A93549-101,EMPTY,6.2K,5%,1/16W,LPDB,GENERIC; room: LSPCON_CHIP
R3A26 R3A27 R3A29 R3A36-R3A39 R3A41 R4A7-R4A10 R6C14-R6C16 R6C18 R6D1 R6D2 R7C8 R7C9 R7C32-R7C35 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: SB_USB
R3A30 R3A42 R3A43 = RES: alternate symbols: (); part number: RES_0201-C80792-009,EMPTY,0,5%,1/20W,LPDB,GENERIC; room: 81
R3A31 R3A32 R3A34 R3A35 R6D3-R6D6 = RES: alternate symbols: (); part number: RES_0402-A93549-038,CHIP,220K,5%,1/16W,LPDB,GENERIC
R3A40 = RES: alternate symbols: (); part number: RES_0402-A93548-202,EMPTY,4.99K,1%,1/16W,LPDB,GENERIC; room: LSPCON_CHIP
R3A44 = RES: alternate symbols: (); part number: RES_0402-A93548-048,CHIP,249,1%,1/16W,LPDB,GENERIC
R3B8 R3B24 R3M5 R3M6 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-G21796-187,CHIP,68.1K,1%,1/16W,LPDB,GENERIC; room: 80
R3B12 R3B18 R3B19 R3B21 R3M1 R3M2 R3M7 R3M8 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: 80
R3B13 R3B23 R4B5 R4B14 R4M1 R4M2 R4M6 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-G21796-187,CHIP,68.1K,1%,1/16W,LPDB,GENERIC; room: 77
R3B14 R3M3 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 80
R3B17 R3B20 R4B9 R4B11 R4M3 R4M4 R4M7 R4M8 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: 77
R3B22 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-G21796-187,CHIP,68.1K,1%,1/16W,LPDB,GENERIC; room: 85
R3F1 = RES: alternate symbols: (); part number: RES_0402-A93548-504,CHIP,240,1%,1/16W,LPDB,GENERIC; room: 23
R3F2 = RES: alternate symbols: (); part number: RES_0402-A93548-504,CHIP,240,1%,1/16W,LPDB,GENERIC; room: 25
R3F3 = RES: alternate symbols: (); part number: RES_0402-A93548-504,CHIP,240,1%,1/16W,LPDB,GENERIC; room: 29
R3G1 = RES: alternate symbols: (); part number: RES_0402-A93548-504,CHIP,240,1%,1/16W,LPDB,GENERIC; room: 27
R3G2 R3G3 R5B52 R5C4 R5F5 R5H11-R5H13 R7B65 R8B21 R8B27 R8B28 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: DCL_CORE_IOH
R3G4 R3G5 R5B25 R5B53 R5C6 R5E2 R5F6 R7B42 R7B50 R8B19 R8B22 R8B24 R8C9 R8C10 R8C12 R8C30 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: DCL_CORE_IOH
R3G32 R5A2 = RES: alternate symbols: (); part number: RES_0402-A93548-186,EMPTY,200K,1%,1/16W,LPDB,GENERIC
R3G33 = RES: alternate symbols: (); part number: RES_0402-A93548-186,CHIP,200K,1%,1/16W,LPDB,GENERIC; room: 160
R3G34 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-H11304-001,CHIP,10MOHM,01%,1/4W,LPDB,GENERIC; room: 160
R3G35-R3G40 = RES: alternate symbols: (); part number: RES_1206-A93557-038,CHIP,1K,1%,1/4W,LPDB,GENERIC; room: 160
R3G42 = RES: alternate symbols: (); part number: RES_0603-A93551-073,EMPTY,10K,5%,1/10W,LPDB,GENERIC
R3H4 R3H8 R3H9 R3H19 R3H22 R3H27 = RES: alternate symbols: (); part number: RES_1206-A93557-234,CHIP,549,1%,1/4W,LPDB,GENERIC; room: 175
R3H13-R3H16 R3H25 R3H30 R3H37 R3H41-R3H43 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 217
R3H17 R3H18 R4H53 R4H54 R4J1 R4J3 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 217
R3H21 = RES: alternate symbols: (); part number: RES_0402-A93549-027,CHIP,100K,5%,1/16W,LPDB,GENERIC; room: 217
R3H28 = RES: alternate symbols: (); part number: RES_0402-A93549-027,EMPTY,100K,5%,1/16W,LPDB,GENERIC; room: 217
R3H39 = RES: alternate symbols: (); part number: RES_0402-A93548-321,CHIP,34K,1%,1/16W,LPDB,GENERIC
R3L4 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 69
R3M4 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-G21796-187,EMPTY,68.1K,1%,1/16W,LPDB,GENERIC; room: 80
R3M13 = RES: alternate symbols: (); part number: RES_0402-G64084-102,CHIP,15K,1%,1/16W,LPDB,GENERIC
R3M40 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-E41880-003,CHIP,0.002,1%,2W,LPDB,GENERIC; room: 170
R3P1 = RES: alternate symbols: (); part number: RES_0402-A93548-053,CHIP,20,1%,1/16W,LPDB,GENERIC; room: 13
R4A11 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 82
R4A12 R4A15 R4A20 R4A21 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 78
R4A13 R4A14 R4A16 R4A17 = RES: alternate symbols: (); part number: RES_0402-A93549-038,CHIP,220K,5%,1/16W,LPDB,GENERIC; room: 78
R4A18 R4A19 = RES: alternate symbols: (); part number: RES_0402-A93549-012,CHIP,330,5%,1/16W,LPDB,GENERIC; room: LAN
R4A22 = RES: alternate symbols: (); part number: RES_0402-A93548-024,CHIP,3.01K,1%,1/16W,LPDB,GENERIC; room: LAN
R4A23 R4B1 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 92
R4A24 R4B3 R4B7 R4B15 R7B19 R7B23 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: LAN
R4A25 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 92
R4B2 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: DEBUG
R4B4 R4B12 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: LAN
R4B6 R6B13 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 175
R4B8 R4B17 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: 92
R4B10 R8B30 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 175
R4B13 R4B18 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 92
R4B16 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: 92
R4B40 = RES: alternate symbols: (); part number: RES_0402-A93548-094,CHIP,499,1%,1/16W,LPDB,GENERIC; room: 17
R4C2 = RES: alternate symbols: (); part number: RES_0402-A93549-117,CHIP,56,5%,1/16W,LPDB,GENERIC
R4C3 = RES: alternate symbols: (); part number: RES_0402-A93548-069,EMPTY,45.3,1%,1/16W,LPDB,GENERIC
R4C4 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 17
R4C5 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: CORE_PCSPKR
R4C6 = RES: alternate symbols: (); part number: RES_0402-A93548-053,CHIP,20,1%,1/16W,LPDB,GENERIC; room: 17
R4C8 = RES: alternate symbols: (); part number: RES_0402-G64084-058,CHIP,220,1%,1/16W,LPDB,GENERIC
R4C10 = RES: alternate symbols: (); part number: RES_0402-A93549-077,CHIP,62,5%,1/16W,LPDB,GENERIC
R4C11 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: CORE_PCSPKR
R4C12 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 20
R4C20 R4C21 R4C26 = RES: alternate symbols: (); part number: RES_0603-H26858-001,EMPTY,.005,1%,1/3W,LPDB,GENERIC
R4D2 R5E57 = RES: alternate symbols: (); part number: RES_0603-G64606-052,CHIP,100,1%,1/10W,LPDB,GENERIC
R4D5 R6J2 R6J9 R6J17 R6J18 R6J29 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH
R4D8 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 17
R4G6 R7T17 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC
R4G7 R4G9 R7B30 R9E27 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC
R4G10 = RES: alternate symbols: (); part number: RES_2512-202153-012,CHIP,30,5%,1W,LPDB,GENERIC; room: 181
R4G14 = RES: alternate symbols: (); part number: RES_2512-202153-012,CHIP,30,5%,1W,LPDB,GENERIC
R4G15 R4G16 R7A9 R7B1 R8C26 R8C49 R8D68 R8D71 R8D72 R8D77-R8D79 R8D81 R8D91 R9G21 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: VREG
R4G17 R8C33 R8C73 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 181
R4G18 = RES: alternate symbols: (); part number: RES_0402-A93549-038,CHIP,220K,5%,1/16W,LPDB,GENERIC; room: 181
R4G22 R4H8 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: VREG_PWR_CONN
R4G23 R4G24 = RES: alternate symbols: (); part number: RES_1206-A93559-018,CHIP,51,5%,1/4W,LPDB,GENERIC; room: 175
R4G25 R4H1 R4H2 = RES: alternate symbols: (); part number: RES_1206-A93559-022,CHIP,75,5%,1/4W,LPDB,GENERIC; room: 175
R4H3 R4H6 R4H21 = RES: alternate symbols: (); part number: RES_0402-G64084-106,EMPTY,22K,1%,1/16W,LPDB,GENERIC; room: 178
R4H4 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: VREG_PWR_CONN
R4H5 = RES: alternate symbols: (); part number: RES_0402-A93548-639,CHIP,22K,1%,1/16W,LPDB,GENERIC; room: DCL_VREG_PWR_CONN
R4H7 R4H11 R4H12 R4H22 R4H29 R4H48 = RES: alternate symbols: (); part number: RES_0402-A93548-639,CHIP,22K,1%,1/16W,LPDB,GENERIC; room: 178
R4H23 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 175
R4H26 R4H30 R8D64 = RES: alternate symbols: (); part number: RES_0402-A93548-476,CHIP,47K,1%,1/16W,LPDB,GENERIC; room: 178
R4H27 R8D84 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 178
R4H34 R4H47 R8D85 R8D90 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 178
R4H35 R5B84 = RES: alternate symbols: (); part number: RES_0402-A93548-175,CHIP,13.3K,1%,1/16W,LPDB,GENERIC
R4H38 = RES: alternate symbols: (); part number: RES_0402-A93548-417,CHIP,88.7K,1%,1/16W,LPDB,GENERIC
R4H39 = RES: alternate symbols: (); part number: RES_0402-A93549-028,CHIP,1M,5%,1/16W,LPDB,GENERIC; room: 178
R4H49 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC; room: 178
R4H50 R8E1 R8E4 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 178
R4J4 = RES: alternate symbols: (); part number: RES_0402-A93548-476,CHIP,47K,1%,1/16W,LPDB,GENERIC; room: 175
R4J5 R4J8 R8D16 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 179
R4J6 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: DCL_CORE_CPU
R4J7 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 179
R4M5 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-G21796-187,EMPTY,68.1K,1%,1/16W,LPDB,GENERIC; room: 77
R5A1 R5A9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: COMBO_JACK
R5A3 R5A56 R5D39 R6A43 R6D51 R8A31 R8F70 = RES: alternate symbols: (); part number: RES_0402-A93548-128,EMPTY,100K,1%,1/16W,LPDB,GENERIC
R5A4 R5A15 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC; room: COMBO_JACK
R5A8 R5A14 = RES: alternate symbols: (); part number: RES_0402-A93549-006,CHIP,47,5%,1/16W,LPDB,GENERIC; room: COMBO_JACK
R5A10 R5A13 = RES: alternate symbols: (); part number: RES_0402-A93549-003,EMPTY,22,5%,1/16W,LPDB,GENERIC; room: COMBO_JACK
R5A11 R5A12 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: SB_USB; signal model: DEFAULT_RESISTOR_0.001OHM_1_2
R5A17 R6A24 = RES: alternate symbols: (); part number: RES_0805-A93552-002,EMPTY,0,5%,1/8W,LPDB,GENERIC
R5A18 R6A31 = RES: alternate symbols: (); part number: RES_0805-A93552-002,CHIP,0,5%,1/8W,LPDB,GENERIC
R5A19 R6A77 R6A83 R7G4 R8B31 R8B32 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-H11304-001,CHIP,10MOHM,01%,1/4W,LPDB,GENERIC
R5A22 R5A23 R5A53 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 190
R5A24 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 190
R5A25 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 190
R5A31 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 190
R5A33 R5A38 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC; room: 191
R5A36 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 191
R5A45 R5A61 R5A62 R6H40 R6H43 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 191
R5A47 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 191
R5A51 R7C2 R8H56 = RES: alternate symbols: (); part number: RES_0402-A93549-028,CHIP,1M,5%,1/16W,LPDB,GENERIC
R5B3-R5B5 R6B3 R6B4 R6B7 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 192
R5B13 R6B8 = RES: alternate symbols: (); part number: RES_0402-A93549-019,CHIP,3.3K,5%,1/16W,LPDB,GENERIC; room: 192
R5B14 R5B15 = RES: alternate symbols: (); part number: RES_0402-A93549-017,CHIP,2.2K,5%,1/16W,LPDB,GENERIC; room: 192
R5B16 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH
R5B20 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 49
R5B26 R7H61 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: DEBUG
R5B27 R5B91 R5G9 R7U1 R7U17 R9U13 R9U15 R9U17 R9U19 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R5B39 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 49
R5B45 = RES: alternate symbols: (); part number: RES_0402-A93549-008,CHIP,75,5%,1/16W,LPDB,GENERIC
R5B48 R5B49 R5C12 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 51
R5B55 = RES: alternate symbols: (); part number: RES_0805-A93555-138,CHIP,1.6,5%,1/8W,LPDB,GENERIC
R5B57 = RES: alternate symbols: (); part number: RES_0402-A36092-050,CHIP,332,1%,1/16W,LPDB,GENERIC
R5B61 = RES: alternate symbols: (); part number: RES_0402-A36092-367,CHIP,47.5K,1%,1/16W,LPDB,GENERIC
R5B62 = RES: alternate symbols: (); part number: RES_0402-A93548-207,CHIP,9.76K,1%,1/16W,LPDB,GENERIC
R5B63 = RES: alternate symbols: (); part number: RES_0402-G64084-001,CHIP,0,1%,1/16W,LPDB,GENERIC
R5B65 = RES: alternate symbols: (); part number: RES_0402-A93548-428,CHIP,26.1K,1%,1/16W,LPDB,GENERIC
R5B66 = RES: alternate symbols: (); part number: RES_0402-A36092-322,CHIP,3.9,1%,1/16W,LPDB,GENERIC
R5B67 = RES: alternate symbols: (); part number: RES_0402-A93548-096,CHIP,121K,1%,1/16W,LPDB,GENERIC
R5B68 = RES: alternate symbols: (); part number: RES_0402-A93548-162,CHIP,169,1%,1/16W,LPDB,GENERIC
R5B69 = RES: alternate symbols: (); part number: RES_0402-A93548-405,CHIP,215K,1%,1/16W,LPDB,GENERIC
R5B70 = RES: alternate symbols: (); part number: RES_0402-A93548-378,CHIP,14.3K,1%,1/16W,LPDB,GENERIC
R5B72 = RES: alternate symbols: (); part number: RES_0603-A93552-008,CHIP,0,5%,1/16W,LPDB,GENERIC
R5B74 = RES: alternate symbols: (); part number: RES_0402-A93548-657,RES,270,1%,1/16W,LPDB,GENERIC
R5B75 = RES: alternate symbols: (); part number: RES_0402-A93548-059,CHIP,475,1%,1/16W,LPDB,GENERIC
R5B76 = RES: alternate symbols: (); part number: RES_0402-A36092-125,CHIP,54.9K,1%,1/16W,LPDB,GENERIC
R5B78 R5M7 = RES: alternate symbols: (); part number: RES_0402-A93548-268,CHIP,63.4,1%,1/16W,LPDB,GENERIC
R5B79 = RES: alternate symbols: (); part number: RES_0402-A93548-182,CHIP,130K,1%,1/16W,LPDB,GENERIC
R5B81 = RES: alternate symbols: (); part number: RES_0402-A93548-511,CHIP,470,1%,1/16W,LPDB,GENERIC
R5B86 = RES: alternate symbols: (); part number: RES_0402-J69281-001,CHIP,160,1%,1/16W,LPDB,GENERIC
R5B89 = RES: alternate symbols: (); part number: RES_0805-G64609-024,CHIP,8.2,1%,1/8W,LPDB,GENERIC
R5C5 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 49
R5C7 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 51
R5C9 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 51
R5C13 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 51
R5C17 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 51
R5C20 R5F9 = RES: alternate symbols: (); part number: RES_1206-A93559-044,EMPTY,620,5%,1/4W,LPDB,GENERIC
R5C29 R5F18 = RES: alternate symbols: (); part number: RES_0402-A93548-525,CHIP,34.8K,1%,1/16W,LPDB,GENERIC
R5C46 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 169
R5C47 = RES: alternate symbols: (); part number: RES_0402-A93548-156,CHIP,43.2K,1%,1/16W,LPDB,GENERIC
R5C63 R7A6 R8A5 R8A21 R8F56 = RES: alternate symbols: (); part number: RES_0402-A93548-639,CHIP,22K,1%,1/16W,LPDB,GENERIC
R5D6 R6D23 R6D27 R6D28 R7E33 R7E39 R7R52 R9G31 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: CORE_PCSPKR
R5D24 = RES: alternate symbols: (); part number: RES_0402-A93548-159,CHIP,53.6K,1%,1/16W,LPDB,GENERIC
R5E5 R5E8 R5E15 R5E19 R5E25 R5E29 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 48
R5E14 R6A71 R6A75 = RES: alternate symbols: (); part number: RES_0402-A93548-476,CHIP,47K,1%,1/16W,LPDB,GENERIC
R5E48 R5E49 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 25
R5E50 R5E51 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 25
R5E52 R5E55 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 23
R5E53 R5E54 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 23
R5F3 R5F8 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 29
R5F4 R5F7 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 29
R5F12 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 165
R5F14 R5F16 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 27
R5F15 R5F17 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 27
R5F21 = RES: alternate symbols: (); part number: RES_0402-A93548-645,CHIP,160K,1%,1/16W,LPDB,GENERIC
R5G4 = RES: alternate symbols: (); part number: RES_0402-H88611-001,CHIP,5.1K,1%,1/16W,LPDB,GENERIC
R5G15 R7W2 = RES: alternate symbols: (); part number: RES_0805-E58715-001,EMPTY,0.005,1%,1/8W,LPDB,GENERIC
R5G16 R7W1 = RES: alternate symbols: (); part number: RES_0805-E58715-001,CHIP,0.005,1%,1/8W,LPDB,GENERIC
R5G22 R5G29 R5G30 R5G34 R5G35 R5H1-R5H3 R5H5 R8G80 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 98
R5G24 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 98
R5G26 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 98
R5H7 R5H15 R8G2 R9F11 R9F37 R9G17 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 124
R5H8 R5H9 R8H73 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: SIO_STDFNTPNL
R5H10 R9G41 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 138
R5J1 R5J2 = RES: alternate symbols: (); part number: RES_0402-A93549-017,EMPTY,2.2K,5%,1/16W,LPDB,GENERIC; room: 217
R5J7 R6J13 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: VREG
R5J13 R6J3 R6J4 R6J11 R6J15 R6J19 R8C80 R8D70 R8D80 R8D92 R9G1 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: VREG
R5L6 = RES: alternate symbols: (); part number: RES_0402-J44580-001,CHIP,4.75K,0.5%,1/16W,LPDB,GENERIC
R5L10 R6J28 = RES: alternate symbols: (); part number: RES_0402-A93548-024,CHIP,3.01K,1%,1/16W,LPDB,GENERIC
R5L16 = RES: alternate symbols: (); part number: RES_0402-A93549-017,EMPTY,2.2K,5%,1/16W,LPDB,GENERIC; room: ICH
R5L19 = RES: alternate symbols: (); part number: RES_0402-A93548-060,CHIP,200,1%,1/16W,LPDB,GENERIC; room: CPU
R5M1 R5M3 = RES: alternate symbols: (); part number: RES_0603-A93550-078,CHIP,1.58K,1%,1/10W,LPDB,GENERIC
R5M4 = RES: alternate symbols: (); part number: RES_0402-A93548-174,CHIP,1.15K,1%,1/16W,LPDB,GENERIC
R5M5 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-G21796-026,CHIP,1K,1%,1/16W,LPDB,GENERIC
R5M8 = RES: alternate symbols: (); part number: RES_0402-A93548-217,CHIP,143K,1%,1/16W,LPDB,GENERIC
R5M9 = RES: alternate symbols: (); part number: RES_0402-G64084-107,CHIP,24K,1%,1/16W,LPDB,GENERIC
R5M11 = RES: alternate symbols: (); part number: RES_0402-A93548-292,CHIP,30.1K,1%,1/16W,LPDB,GENERIC
R5M12 = RES: alternate symbols: (); part number: RES_0402-A93548-214,CHIP,68.1K,1%,1/16W,LPDB,GENERIC
R5U1 = RES: alternate symbols: (); part number: RES_0402-A93548-515,CHIP,30K,1%,1/16W,LPDB,GENERIC
R5W1 R5W2 R6G1 R6G3 R6G4 R6G8 R6G11 R6G13 R8H9-R8H13 R8H16 R8H19 R8H22 = RES: alternate symbols: (); part number: RES_0201-C80792-009,CHIP,0,5%,1/20W,LPDB,GENERIC
R6A13 R6A19 R8A9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 174
R6A18 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 174
R6A30 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 105
R6A50 = RES: alternate symbols: (); part number: RES_0402-A93549-003,CHIP,22,5%,1/16W,LPDB,GENERIC; room: SIO_STDFNTPNL
R6B11 = RES: alternate symbols: (); part number: RES_0402-A93548-045,EMPTY,49.9,1%,1/16W,LPDB,GENERIC
R6B12 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 175
R6B14 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 175
R6B20 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-E41880-003,CHIP,0.002,1%,2W,LPDB,GENERIC; room: 175
R6B24 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-H11304-001,CHIP,10MOHM,01%,1/4W,LPDB,GENERIC; room: 175
R6C7 R6C9 = RES: alternate symbols: (); part number: RES_0201-C80792-009,EMPTY,0,5%,1/20W,LPDB,GENERIC; room: 87
R6C10 R6C13 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 87
R6C11 R6C12 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: SB_USB
R6C17 = RES: alternate symbols: (); part number: RES_1206-A93552-001,EMPTY,0,5%,1/4W,LPDB,GENERIC; room: USB_OUT
R6D10 R6D11 R6D16 R6D17 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 83
R6D12-R6D15 = RES: alternate symbols: (); part number: RES_0201-C80792-009,EMPTY,0,5%,1/20W,LPDB,GENERIC; room: 83
R6D18 = RES: alternate symbols: (); part number: RES_0201-C80792-009,EMPTY,0,5%,1/20W,LPDB,GENERIC; room: 85
R6D24 R6D26 R7E19 R7E21 R7F32 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: CORE_PCSPKR
R6D25 R6D30 R7B62 = RES: alternate symbols: (); part number: RES_0402-A93549-003,CHIP,22,5%,1/16W,LPDB,GENERIC
R6D40 R7F1 R7F5 R7R5 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-C49684-019,CHIP,0.022,1%,1/16W,LPDB,GENERIC; room: 157
R6D49 = RES: alternate symbols: (); part number: RES_0402-A93549-188,CHIP,620,5%,1/16W,LPDB,GENERIC; room: 35
R6D57 = RES: alternate symbols: (); part number: RES_0402-A93549-028,CHIP,1M,5%,1/16W,LPDB,GENERIC; room: 42
R6D59 R6D62 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 42
R6D60 R6D61 R7F14 R7F15 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 42
R6D65 = RES: alternate symbols: (); part number: RES_0402-A93548-120,CHIP,60.4,1%,1/16W,LPDB,GENERIC; room: 42
R6D66 = RES: alternate symbols: (); part number: RES_0402-A93549-073,CHIP,30,5%,1/16W,LPDB,GENERIC; room: 35
R6D67 R7E23 R7E24 R7E26 R7E38 R7E46 R7E49 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 36
R6D68 = RES: alternate symbols: (); part number: RES_0402-A93548-077,RES,113,1%,1/16W,LPDB,GENERIC; room: ICH
R6E1 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC; room: 43
R6F1 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC; room: 47
R6F2 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: 47
R6F3 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH
R6F4 R6H47 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 144
R6F5 R6F12 R6J16 R7E50 R7F4 R7F41 R7F42 R7F47 R7T18 R9G23 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: ICH
R6F8 R6T6 R7D41 R7E42 R7P3 R7P4 R7R41 R7R42 = RES: alternate symbols: (); part number: RES_0402-A93548-517,EMPTY,4.7K,1%,1/16W,LPDB,GENERIC; room: ICH
R6F9 = RES: alternate symbols: (); part number: RES_0402-A93549-019,EMPTY,3.3K,5%,1/16W,LPDB,GENERIC; room: FAN_CNTL
R6F11 R6F21 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 40
R6F15 R7P7 R8F9 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 33
R6F17 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 33
R6F19 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 40
R6H7 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 132
R6H9 R6H11 R6H12 R6H14-R6H18 R6H25-R6H27 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 132
R6H20 R7E4 R7F49 R8H34 R8H44 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: ICH
R6H21 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: 133
R6H23 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: CORE_DEBUG
R6H32 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 132
R6H38 R6H39 R8F20 R8F22 R9F7 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 127
R6H45 R6H46 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 144
R6J6 R7E52 R7E54 R7E60 R7F26 R7F28 R7R54 R7R55 R7R57 R7R59 R7R61 R7T11 R9F4 R9G25 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: ICH
R6J7 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: ICH
R6J31 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-E58715-001,CHIP,0.005,1%,1/8W,LPDB,GENERIC; room: 105
R6J32 = RES: alternate symbols: (); part number: RES_0402-A93549-027,CHIP,100K,5%,1/16W,LPDB,GENERIC; room: 106
R6J33 R8C18 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 106
R6L1 R6L2 = RES: alternate symbols: (); part number: RES_0402-A93549-003,EMPTY,22,5%,1/16W,LPDB,GENERIC
R6T3 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 33
R6T5 R6T19 R7F35 R7P2 R7T3 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 34
R6T11 = RES: alternate symbols: (); part number: RES_0402-A93549-027,CHIP,100K,5%,1/16W,LPDB,GENERIC; room: ICH
R6T17 R6T18 R7D35 R7E22 R7E43 R7R47 R7R51 R7T25 R7T26 = RES: alternate symbols: (); part number: RES_0402-A93549-036,EMPTY,20K,5%,1/16W,LPDB,GENERIC; room: ICH
R6U3 R7U4 R7U5 R7U9 R7U13 = RES: alternate symbols: (); part number: RES_0402-A93548-031,CHIP,10,1%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R6U4 R7U15 R7U16 R7U20 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R6U5 R7U22 R7U23 R7U26 R7U29 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: 38
R6U6 R7U21 R7U24 R7U25 R7U28 = RES: alternate symbols: (); part number: RES_0402-A93549-005,EMPTY,33,5%,1/16W,LPDB,GENERIC; room: ICH; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R7A2 R7A4 = RES: alternate symbols: (); part number: RES_0402-A93549-012,CHIP,330,5%,1/16W,LPDB,GENERIC
R7B3 = RES: alternate symbols: (); part number: RES_0402-A93548-128,EMPTY,100K,1%,1/16W,LPDB,GENERIC; room: VREG
R7B4-R7B6 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: VREG
R7B8 R8C83 R8D18 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 182
R7B16 R7B20 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC; room: 182
R7B18 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 92
R7B25 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-D71825-003,CHIP,0.01,0.50%,1/10W,LPDB,GENERIC; room: 182
R7B28 R7B35 R7B37 R7B40 R7B41 R7B43 R7B47 R7B48 R7B51 R7B52 R7B54 R7B57-R7B59 R7B71 R7B72 R7B74 R7B78 R7B80 R7B83 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 90
R7B31 R7B38 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 91
R7B36 R7B44 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 91
R7B45 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 90
R7B46 R7B49 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 91
R7B73 R7B76 R7B81 R7C1 R7C6 R7C7 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: 183
R7B75 = RES: alternate symbols: (); part number: RES_0402-A93549-003,CHIP,22,5%,1/16W,LPDB,GENERIC; room: 90
R7B77 R7E35 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: 90
R7C10 R7C11 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC; room: 90
R7D14 R7D29 R7D36 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; room: 35
R7D15 R7D30 R7D37 R7F51 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 35
R7D19 R7D31 = RES: alternate symbols: (); part number: RES_0402-A93549-003,CHIP,22,5%,1/16W,LPDB,GENERIC; room: 43
R7D20 R7D21 = RES: alternate symbols: (); part number: RES_0402-A93549-036,CHIP,20K,5%,1/16W,LPDB,GENERIC
R7D24 = RES: alternate symbols: (); part number: RES_0402-A93549-068,CHIP,13,5%,1/16W,LPDB,GENERIC
R7D25 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: 44
R7D32 = RES: alternate symbols: (); part number: RES_0402-A93548-517,CHIP,4.7K,1%,1/16W,LPDB,GENERIC; room: ICH
R7D39 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: 35
R7D40 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC; room: 45
R7D46 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; room: 43
R7D47 = RES: alternate symbols: (); part number: RES_0402-A93549-073,CHIP,30,5%,1/16W,LPDB,GENERIC; room: 37
R7D48 R7D49 = RES: alternate symbols: (); part number: RES_0402-A93549-073,CHIP,30,5%,1/16W,LPDB,GENERIC; room: 36
R7D51 = RES: alternate symbols: (); part number: RES_0402-A93548-005,CHIP,150,1%,1/16W,LPDB,GENERIC; room: 43
R7E3 R7E6 R7E9 R9B3 = RES: alternate symbols: (); part number: RES_0402-A93549-005,EMPTY,33,5%,1/16W,LPDB,GENERIC; room: SIO_STDFNTPNL
R7E5 R7E7 R7E10 R7E12 R9A12 R9A15 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; room: SIO_STDFNTPNL
R7E11 R9A22 = RES: alternate symbols: (); part number: RES_0402-A93549-026,EMPTY,33K,5%,1/16W,LPDB,GENERIC
R7E13 R7E14 R7E16 R7F19 R7R10 R7R12 R7R17 R7U27 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC
R7E15 R7R8 = RES: alternate symbols: (); part number: RES_0402-A93548-128,EMPTY,100K,1%,1/16W,LPDB,GENERIC; room: 111
R7E18 R7R16 R8B12 R9B9 = RES: alternate symbols: (); part number: RES_0402-A93549-005,CHIP,33,5%,1/16W,LPDB,GENERIC; room: 104
R7E20 R7E37 R8G38 R9G22 = RES: alternate symbols: (); part number: RES_0402-A93548-023,EMPTY,1K,1%,1/16W,LPDB,GENERIC; room: ICH
