# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TCH_PNL_INTR_N: length 115.5
  TOP w0.089: U6E1.AT10 v1(96.32,153.87)
  TOP w0.1: v1(83.43,189.36) 80.77,189.36 79.84,188.42 66.22,188.42 63.4,185.61 53.5,185.61 51.92,184.04 51.92,180.1 50.45,178.63 42.83,178.63 41.96,177.75 32.5,177.75 31.56,178.69 29.12,178.69 28.64,179.16 27.49,179.16 27.07,179.58 25.52,179.58 24.51,180.59 23.6,180.59 23.24,180.95 R9D11.2 22.35,182.62 R9D8.2 21.97,182.88 20.59,184.25 CR9D4.2
  BOTTOM w0.089: v1(96.32,153.87) 96.32,154.63 96.01,154.94 96.01,155.27 95.63,155.65 95.63,156.32 95.75,156.43 95.75,158.76 95.57,158.93
  BOTTOM w0.1: 95.57,158.93 94.86,159.64 94.86,160.28 89.3,165.84 89.3,170.15 84.77,174.69 84.77,188.02 v1(83.43,189.36)
TCH_PNL_INTR_R_N: length 16.6
  TOP w0.1: J9D2.3 15.5,181.5 15.74,181.74 R9D10.2 15.74,184.53 16.25,185.04 CR9D4.1 18.66,185.04 19.93,183.77 20.7,183.77 21.46,183.01 21.46,182.62 R9D11.1
TCH_PNL_RST_N: length 149.6
  TOP w0.089: 104.77,129.11 104.77,129.38 104.95,129.56 104.95,135.86 105.01,135.92 U6E1.W47
  TOP w0.1: v1(30.22,178.05) 28.95,178.05 28.32,178.69 27.29,178.69 26.87,179.1 25.24,179.1 24.22,180.12 23.2,180.12 22.35,180.97 22.09,180.97 20.57,182.5 CR9D5.1 18.66,182.62 18.16,182.12 R9D15.2 ; v1(106.14,122.3) 106.14,124.99 105.69,125.44 105.69,127.93 104.77,128.85 104.77,129.11
  LAY6 w0.125: v1(58.92,167.13) 59.06,167 59.06,163.26 59.58,162.74 59.58,160.63 58.7,159.75 58.7,152.27 60.19,150.78 60.19,148.21 61.85,146.55 62.67,146.55 63.46,145.76 63.46,143.82 65.56,141.73 66.04,141.73 66.42,141.35 66.42,138.17 69.08,135.51 70.73,135.51 72.39,133.85 72.39,130.67 75.43,127.63 75.43,126.27 78.82,122.89 79.23,122.89 84.65,117.47 95.1,117.47 97.66,120.02 102.31,120.02 104.59,122.3 v1(106.14,122.3)
  BOTTOM w0.1: v1(58.92,167.13) 58.03,168.02 56.14,168.02 51.13,173.03 46.04,173.03 42.97,176.1 40.91,176.1 40,177 31.14,177 30.35,177.8 30.35,177.93 v1(30.22,178.05)
TCH_PNL_RST_R_N: length 9.8
  TOP w0.1: CR9D5.2 17.27,182.6 R9D15.1 16.63,180.34 15.49,180.34 R9D14.2 14.22,180.34 12.7,180.34 12.44,180.59 R9D13.1 12.42,181 J9D2.4
TCH_PNL_SCL: length 75
  TOP w0.1: Q8E8.2 35.96,145.31 36.32,145.67 39.62,145.67 39.75,145.54 Q8E7.2 40.25,144.78 40.38,144.91 40.38,145.92 40.51,146.05 R8E40.2 41.14,147.19 41.77,147.82 41.77,152.15 41.14,152.78 R8E16.1 41.78,154.3 41.78,154.94 41.52,155.19 40.51,155.19 40.25,155.45 40.25,158.05 v1(39.9,158.41) ; R9D4.2 v1(14.09,185.55)
  BOTTOM w0.1: v1(39.9,158.41) 31.66,158.41 31.48,158.23 24.29,158.23 23.87,157.82 19.77,157.82 16.59,160.99 16.59,166.89 15.76,167.73 15.76,172.24 17.49,173.97 17.49,182.15 v1(14.09,185.55)
TCH_PNL_SDA: length 62.8
  TOP w0.1: v1(32.38,157.64) 31.87,157.13 31.87,156.59 R8E13.1 32,156.08 32.63,155.45 32.63,154.3 33.62,153.31 33.62,152.17 34.13,151.66 Q8E5.2 34.92,150.88 35.68,151.64 36.83,151.64 37.59,150.87 Q8E6.2 38.22,150.87 39.34,151.99 41.04,151.99 41.14,151.89 R8E31.2 ; R9D7.2 v1(14.09,184.4)
  BOTTOM w0.1: v1(14.09,184.4) 17.14,181.35 17.14,174.12 15.41,172.38 15.41,167.58 16.24,166.75 16.24,160.85 19.62,157.47 24.02,157.47 24.43,157.88 32.13,157.88 v1(32.38,157.64)
TCH_PNL_SPI1_CLK_I2C_MODE_SEL: length 8.1
  TOP w0.1: J9D2.5 11.78,180.5 12.41,179.86 16.83,179.86 17.05,180.08 C9D5.1 R9D20.1
TCH_PNL_SPI1_CS_N: length 5.4
  TOP w0.1: R9D26.2 R9D22.2 11.13,179.5 J9D2.7
TCH_PNL_SPI1_MISO_I2C1_SDA: length 4.4
  TOP w0.1: R9D6.1 C9D4.1 R9D9.2 12.32,182 J9D2.2
TCH_PNL_SPI1_MOSI_I2C1_SCL: length 5.2
  TOP w0.1: J9D2.1 10.41,184.28 11.04,184.91 11.81,184.91 R9D5.1 C9D3.1
TCHPNL_I2C_DIVIDER_EN: length 15.9
  TOP w0.1: R8E11.2 40.51,158.88 Q8E2.3 38.79,158.18 38.48,157.86 34.41,157.86 34.03,157.48 Q8E1.1 34.03,156.08 34.16,155.95 34.79,155.95 35.01,155.74 Q8E4.3 36.7,155.06 37.84,153.92 Q8E3.1
TCHPNL_IO_EN_G_N: length 5.6
  TOP w0.1: R8C69.2 C8C24.1 52.83,196.72 52.07,195.96 51.43,195.96 51.05,195.58 Q8C14.1
TCHPNL_IO_EN_N: length 3.7
  TOP w0.1: R8C69.1 R8C70.2 54.86,199.39 54.99,199.26 54.99,197.55 Q8C15.3
TCHPNL_PWREN: length 68.5
  TOP w0.089: v1(89.4,163.8) 89.68,163.8 92.04,161.44 93.76,161.44 95.33,159.87 95.33,158.02 95.29,157.97 95.29,157.62 95.37,157.54 U6E1.AW3
  TOP w0.1: v1(73.15,190.24) 66.26,190.24 66.01,190.5 66.01,195.63 65.38,196.26 65.38,198.65 65.27,198.75 58.67,198.75 R8C74.1
  BOTTOM w0.1: v1(73.15,190.24) 73.15,187.23 73.91,186.47 73.91,184.4 75.34,182.98 75.34,180.06 75.94,179.45 75.94,174.62 76.86,173.71 78.14,173.71 84.32,167.54 86.32,167.54 89.4,164.46 v1(89.4,163.8)
TCHPNL_PWREN_N: length 10.1
  TOP w0.1: Q8C15.2 56.38,193.8 57.27,192.91 Q8D7.3 58.35,190.44 58.54,190.24 58.54,189.36 59.05,189.36 60.45,190.75 Q8D8.1
TCHPNL_PWREN_R: length 12.2
  TOP w0.1: v1(57.4,191.87) Q8D7.1 ; U8C5.A1 60.57,197.23 R8C77.2 R8C74.2 v1(60.07,198.25)
  BOTTOM w0.1: v1(57.4,191.87) 57.4,191.9 58.67,193.17 58.67,196.34 60.07,197.74 v1(60.07,198.25)
TCHPNL_PWRSEL: length 2.8
  TOP w0.1: R8C84.2 R8C81.2 59.56,196.72 U8C5.B1
TCHPNL_PWRSEL_3V3_N: length 69.1
  TOP w0.1: SW7C1.8 56.76,201.42 56.51,201.17 56.51,196.34 57.15,195.71 57.65,195.71 R8C84.1 57.4,194.44 v1(57.4,193.55) ; v1(37.21,155.7) 37.84,156.34 Q8E2.1
  LAY5 w0.125: v1(38.22,191.92) 38.22,191.54 38.37,191.39 48.03,191.39 49.68,193.03 54.85,193.03 55.37,193.55 v1(57.4,193.55)
  LAY6 w0.125: v1(38.22,191.92) 38.22,191.9 38.1,191.77 38.1,185.29 37.59,184.78 37.59,175 37.08,174.5 37.08,173.35 36.7,172.97 36.7,172.01 36.95,171.75 36.95,167.16 37.49,166.62 37.49,155.98 v1(37.21,155.7)
TCHPNL_PWRSEL_DIPSW: length 1.4
  TOP w0.1: SW7C1.1 R7C30.2
TCHPNL_SCL_DIVIDER: length 2.6
  TOP w0.1: R8E16.2 41.14,154.54 40.14,154.54 39.62,155.07 38.79,155.07
TCHPNL_SDA_DIVIDER: length 3.7
  TOP w0.1: Q8E1.3 34.29,158.88 33.52,158.11 33.52,157.11 32.87,156.46 R8E13.2
TEST_D8: length 2.8
  TOP w0.1: R3A28.1 235.88,265.68 237.39,267.19 U3A5.D8
TEST_SETUP_MENU: length 274.6
  TOP w0.089: 106.79,129.3 106.28,129.8 106.28,135.02 106.45,135.19 106.45,135.63 106.51,135.69 106.51,136.22 U6E1.T46
  TOP w0.1: J9G6.1 6.09,35.3 R9G23.2 14.35,35.3 15.62,34.03 v1(15.62,33.4) ; v1(108.76,122.1) 108.76,127.33 106.79,129.3
  LAY5 w0.125: v1(131.82,32.38) 122.68,32.38 121.46,33.6 113.28,33.6 113.07,33.4 106.55,33.4 105.65,34.29 102.85,34.29 101.83,33.27 63.65,33.27 62.38,32 50.24,32 49.86,32.38 40.25,32.38 38.73,33.91 34.92,33.91 33.77,32.76 23.93,32.76 22.52,34.17 19.05,34.17 18.28,33.4 v1(15.62,33.4)
  LAY6 w0.125: v1(131.82,32.38) 133.22,33.78 133.22,40 136.27,43.05 136.27,59.41 135.51,60.16 135.51,69.93 133.64,71.8 129.83,71.8 125.95,75.68 125.95,88.67 124.69,89.93 124.69,93.46 120.65,97.51 120.65,100.46 122.48,102.29 122.48,116.13 125.09,118.74 125.09,127.25 124.5,127.84 120.91,127.84 115.16,122.1 v1(108.76,122.1)
TP3: length 1.6
  TOP w0.1: v1(248.74,76.07) 248.76,76.07 248.79,76.1 248.79,77.09 248.97,77.27 U2G2.12
TP_+V3P3DSW_NC: length 0.8
  TOP w0.1: EU8G1.7 v1(51.3,88.75)
TP_CLK_ITPXDP_DN: length 10.9
  TOP w0.088: 103.62,164.12 103.63,164.11 103.63,164.1 103.67,164.06 103.67,164.05 103.79,163.93 103.79,163.17 104.3,162.66 104.3,158.91 104.08,158.7 104.08,158.3 104.28,158.1 104.28,157.4 104.4,157.28 104.49,157.28 104.54,157.33 U6E1.Y3
  TOP w0.1: TP6D1.1 103.4,166.47 103.4,164.34 103.62,164.12
TP_CLK_ITPXDP_DP: length 9.6
  TOP w0.088: 103.48,163.98 103.6,163.85 103.6,163.09 104.11,162.58 104.11,158.99 103.9,158.78 103.9,158.22 104.1,158.02 104.1,157.32 104.21,157.2 104.21,157.2 104.28,157.14 104.28,157.13 104.41,157 U6E1.Y4
  TOP w0.1: 103.48,163.98 103.2,164.26 103.2,165.48 103.07,165.61 TP6D2.1
TP_CLKOUT_SRC12_DP: length 0.5
  TOP w0.1: U6E1.AC6 v1(103.77,156.06)
TP_DEVELOPER_MODE: length 5.2
  TOP w0.1: J6J2.155 135.12,18.32 135.12,21.97 TP5J1.1
TP_FPF_MON: length 33.9
  TOP w0.089: U6E1.AN35 v1(97.75,141.77)
  LAY5 w0.125: TP6T3.1 97.66,112.14 97.66,115.44 97.28,115.82 97.28,122.43 96.13,123.57 96.13,136.4 97.53,137.79 97.53,138.3 98.04,138.81 98.04,139.57 98.29,139.83 98.29,141.22 v1(97.75,141.77)
TP_FPF_VREF: length 31
  TOP w0.089: U6E1.AL37 v1(98.84,141.03)
  LAY5 w0.125: v1(98.84,141.03) 99.31,140.56 99.31,139.29 99.08,139.07 99.08,138.56 98.87,138.34 98.87,137.84 98.68,137.64 98.68,137.41 98.29,137.03 98.29,135.25 98.68,134.87 98.68,124.06 97.66,123.04 97.66,116.23 98.17,115.72 98.17,113.28 TP6T1.1
TP_GPP_A_16_CLKOUT_48: length 13.7
  TOP w0.089: U6E1.BE33 92.18,142.59 91.97,142.38 91.73,142.38 89.68,142.38 89.62,142.32 86.57,142.32 86.14,141.9 84.73,141.9 83.17,140.33 82.29,140.33 TP7E1.1
TP_I2C_CLK_R: length 1.7
  TOP w0.1: 239.21,268.79 v1(238.81,269.19)
  BOTTOM w0.1: v1(238.81,269.19) 238.68,269.19 TP3L2.1
TP_I2C_DATA_R: length 3.6
  TOP w0.305: 239.21,267.99 v1(238.8,268.39)
  BOTTOM w0.1: v1(238.8,268.39) 238.29,268.9 238.08,268.9 237.23,269.75 TP3L1.1
TP_KBC_SCANIN_0: length 186.2
  TOP w0.1: J6J2.173 v1(137.74,15.7) ; v1(34.29,92.79) 34.19,92.69 U8F6.98
  LAY3 w0.1: v1(65.65,28.95) 65.65,28.32 66.5,27.47 75.09,27.47 76.28,28.65 76.83,28.65 77.72,27.77 80.89,27.77 81.6,28.47 96.54,28.47 96.79,28.73 97.67,28.73 98.18,28.22 100.08,28.22 101.82,26.49 106.01,26.49 107.85,24.64 113.97,24.64 114.02,24.6 121,24.6 122.42,23.17 128.7,23.17 129.54,22.33 130.58,22.33 130.93,21.99 130.93,20.95 131.59,20.29 136.28,20.29 138.19,18.38 138.19,16.15 v1(137.74,15.7)
  LAY8 w0.1: v1(34.29,92.79) 33.06,94.01 30.51,94.01 29.05,95.48 22.89,95.48 21.23,93.82 21.23,91.17 25.27,87.13 25.27,84.45 25.12,84.3 25.12,80.03 27.27,77.88 27.27,72.93 31.49,68.71 31.49,66.94 35.72,62.71 37.88,62.71 40.01,60.58 41.3,60.58 47.25,54.64 48.29,54.64 52.35,50.58 52.35,49.31 52.73,48.92 54,48.92 55.17,47.76 55.17,45.55 60.83,39.88 60.83,33.78 v1(65.65,28.95)
TP_KBC_SCANIN_1: length 184.4
  TOP w0.1: J6J2.181 v1(139.01,15.7) ; v1(31.47,93.39) 31.95,93.39 32.26,93.09 U8F6.99
  LAY3 w0.1: v1(139.01,15.7) 139.31,16 139.31,18.41 138.93,18.79 138.1,18.79 136.37,20.52 131.69,20.52 131.16,21.05 131.16,22.08 130.68,22.56 129.63,22.56 128.79,23.4 122.52,23.4 121.09,24.82 114.11,24.82 114.07,24.87 110.78,24.87 108.94,26.71 101.91,26.71 100.18,28.45 98.27,28.45 97.76,28.96 96.7,28.96 96.44,28.7 81.51,28.7 80.8,28 77.81,28 76.92,28.88 76.18,28.88 75,27.7 67.04,27.7 v1(66.54,28.19)
  LAY8 w0.1: v1(66.54,28.19) 67.05,28.7 67.05,29.21 66.54,29.72 65.65,29.72 61.06,34.32 61.06,39.98 55.39,45.64 55.39,47.85 54.1,49.15 52.83,49.15 52.57,49.4 52.57,50.67 48.38,54.86 47.34,54.86 41.4,60.8 40.1,60.8 37.97,62.94 35.82,62.94 31.72,67.04 31.72,68.8 27.49,73.03 27.49,77.98 26.16,79.31 26.16,85.6 25.9,85.85 25.9,86.81 21.46,91.26 21.46,93.72 22.98,95.25 28.95,95.25 30.81,93.39 v1(31.47,93.39)
TP_KBC_SCANIN_2: length 192.6
  TOP w0.1: U8F6.6 29.62,107.54 29.16,108 v1(29.16,108.08) ; J6J2.189 v1(140.28,15.7)
  LAY3 w0.1: v1(58.54,34.92) 61.84,31.62 62.61,31.62 64.82,29.41 66.75,29.41 67.31,28.85 67.31,28.57 67.95,27.92 73.64,27.92 74.64,28.93 75.91,28.93 76.09,29.11 77.02,29.11 77.9,28.22 80.71,28.22 81.41,28.93 96.35,28.93 96.6,29.18 97.86,29.18 98.37,28.67 100.27,28.67 102,26.94 109.04,26.94 110.88,25.1 114.16,25.1 114.21,25.05 121.19,25.05 122.61,23.63 128.89,23.63 129.73,22.79 131.7,22.79 132.59,21.9 134.74,21.9 135.89,20.75 136.47,20.75 138.19,19.02 139.03,19.02 139.54,18.51 139.54,16.44 v1(140.28,15.7)
  LAY8 w0.1: v1(29.16,108.08) 28.7,107.62 28.7,106.87 26.44,104.61 26.44,101.75 22.88,98.2 22.88,96.43 20.55,94.1 20.55,88.92 22.6,86.87 22.6,86.08 22.7,85.98 22.7,81.37 25.01,79.06 25.01,70.93 29.87,66.08 31.39,66.08 32.54,64.93 32.54,64.29 41.75,55.08 45.58,55.08 48.11,52.56 49.4,52.56 51.67,50.3 51.67,49.03 52.45,48.24 53.41,48.24 53.74,47.91 53.74,46.01 58.42,41.33 58.42,35.05 v1(58.54,34.92)
TP_KBC_SCANIN_3: length 194.2
  TOP w0.1: J6J2.198 v1(141.55,14.43) ; v1(29.16,107.31) 29.22,107.25 U8F6.7
  LAY3 w0.1: v1(59.3,34.92) 59.3,34.64 62.1,31.85 62.7,31.85 64.91,29.64 66.84,29.64 67.53,28.95 67.53,28.67 68.05,28.15 73.55,28.15 74.55,29.15 75.81,29.15 75.99,29.34 77.11,29.34 78,28.45 80.61,28.45 81.32,29.15 96.25,29.15 96.51,29.41 97.95,29.41 98.46,28.9 100.36,28.9 102.1,27.17 109.13,27.17 110.97,25.32 114.26,25.32 114.3,25.28 121.28,25.28 122.71,23.85 124.33,23.85 125.06,24.59 129.71,24.59 130.2,24.1 130.2,23.64 130.82,23.02 131.79,23.02 132.69,22.12 134.84,22.12 135.99,20.97 136.56,20.97 137.54,19.99 139.22,19.99 140.51,18.7 140.51,17.69 141.55,16.65 v1(141.55,14.43)
  LAY8 w0.1: v1(29.16,107.31) 29.16,107.01 26.67,104.52 26.67,101.66 23.11,98.1 23.11,96.34 20.78,94.01 20.78,90.98 23.74,88.01 23.74,85.47 23.49,85.22 23.49,80.9 26.1,78.29 26.1,70.16 29.96,66.3 31.49,66.3 32.77,65.02 32.77,64.39 41.85,55.31 45.93,55.31 47.14,54.1 48.18,54.1 51.89,50.39 51.89,49.12 52.55,48.47 53.51,48.47 53.97,48 53.97,46.1 59.43,40.64 59.43,35.05 v1(59.3,34.92)
TP_KBC_SCANIN_4: length 189.2
  TOP w0.1: J6J2.205 v1(142.82,15.7) ; v1(34.29,94.99) 34.19,95.09 U8F6.104
  LAY3 w0.1: v1(142.82,15.7) 140.74,17.79 140.74,18.79 139.32,20.21 137.64,20.21 136.65,21.2 136.08,21.2 134.82,22.46 132.67,22.46 131.89,23.24 130.92,23.24 130.43,23.73 130.43,24.2 129.81,24.82 124.97,24.82 124.23,24.08 122.8,24.08 121.37,25.51 114.4,25.51 114.35,25.55 111.07,25.55 109.22,27.39 102.19,27.39 100.46,29.13 98.55,29.13 98.04,29.64 96.42,29.64 96.16,29.38 81.22,29.38 80.52,28.68 78.09,28.68 77.21,29.56 75.9,29.56 75.72,29.38 74.46,29.38 74.16,29.08 67.72,29.08 66.93,29.87 65,29.87 60.07,34.8 v1(60.07,34.92)
  LAY8 w0.1: v1(60.07,34.92) 60.07,40.32 54.94,45.45 54.94,47.66 53.91,48.69 52.64,48.69 52.12,49.21 52.12,50.48 48.19,54.41 47.15,54.41 41.21,60.35 39.91,60.35 37.78,62.48 35.63,62.48 31.58,66.53 30.06,66.53 26.33,70.26 26.33,78.39 24.89,79.83 24.89,84.71 24.13,85.47 24.13,87.95 21,91.07 21,93.91 22.79,95.7 30.78,95.7 31.49,94.99 v1(34.29,94.99)
TP_KBC_SCANIN_5: length 190.7
  TOP w0.1: J6J2.213 v1(144.09,15.7) ; U8F6.105 v1(31.76,95.49)
  LAY3 w0.1: v1(31.76,95.49) 32.51,94.74 32.51,88.76 32.85,88.42 32.85,72.54 31.97,71.65 30.79,71.65 30.22,71.09 30.22,69.89 30.6,69.51 30.6,67.44 29.08,65.91 29.08,62.97 26.89,60.78 26.89,55.28 26.26,54.64 26.26,53.74 27.42,52.58 27.42,50.11 29.56,47.97 31.58,47.97 34.19,45.37 34.19,42.7 38.66,38.23 46.48,38.23 47.7,39.45 50.26,39.45 53.25,36.46 60.87,36.46 64.39,32.94 66.97,32.94 69.4,30.51 73.23,30.51 74.25,31.52 75.75,31.52 76.28,30.99 77.54,30.99 78.34,31.79 80.81,31.79 81.62,30.99 84.2,30.99 85,31.79 100.45,31.79 102.97,29.27 110,29.27 111.19,28.08 114.57,28.08 115.26,27.39 133.88,27.39 137.51,23.75 141.07,23.75 143.89,20.93 143.89,15.91 v1(144.09,15.7)
TP_KBC_SCANOUT_0: length 181.7
  TOP w0.1: J6J2.237 v1(148.93,15.7) ; U8F6.2 v1(31.22,104.92)
  LAY3 w0.1: v1(76.15,35.89) 76.84,36.58 87.03,36.58 87.63,35.98 90.01,35.98 90.3,36.27 107.51,36.27 108.18,35.61 114.86,35.61 116.05,34.42 118.74,34.42 120.62,32.54 130.52,32.54 131.6,31.46 142.89,31.46 149.75,24.6 149.75,17.04 148.93,16.21 v1(148.93,15.7)
  LAY8 w0.1: v1(76.15,35.89) 76.15,37.22 64.73,48.64 62.25,48.64 58.06,52.83 57.78,52.83 51.94,58.68 51.94,61.48 51.06,62.36 48.26,62.36 45.84,64.77 45.84,68.96 45.36,69.44 45.36,78.1 42.41,81.05 42.41,83.42 40.64,85.2 40.64,93.22 37.59,96.26 36.7,96.26 36.06,96.9 36.06,100.07 v1(31.22,104.92)
TP_KBC_SCANOUT_8: length 212.6
  TOP w0.1: J6J2.206 v1(143.85,14.43) ; v1(31.87,101.32) 31.26,100.71 22.09,100.71 20.87,99.49 U8F6.46
  LAY3 w0.1: v1(143.85,14.43) 143.63,14.65 143.63,20.83 140.97,23.49 137.41,23.49 133.74,27.16 115.17,27.16 114.47,27.86 111.1,27.86 109.91,29.05 102.88,29.05 100.36,31.57 85.1,31.57 84.29,30.76 81.53,30.76 80.72,31.57 78.43,31.57 77.63,30.76 75.39,30.76 75.21,30.58 73.95,30.58 73.65,30.28 69.31,30.28 66.87,32.71 64.3,32.71 60.78,36.23 53.16,36.23 50.17,39.22 47.79,39.22 45.82,37.25 39.32,37.25 33.96,42.61 33.96,45.28 31.49,47.75 29.47,47.75 27.2,50.02 27.2,52.48 26.03,53.65 26.03,54.74 26.67,55.37 26.67,60.88 28.85,63.06 28.85,67.66 29.5,68.3 29.5,70.86 30.51,71.88 31.87,71.88 32.38,72.39 32.38,74.99 31.13,76.24 31.13,85.36 31.75,85.98 31.75,89.53 30.49,90.78 30.49,99.94 v1(31.87,101.32)
TP_KBC_SCANOUT_11: length 182.6
  TOP w0.1: U8F6.74 22.82,91.98 v1(21.99,92.81) ; J6J2.238 v1(148.93,14.43)
  LAY3 w0.1: v1(148.93,14.43) 149.47,14.98 149.47,16.44 149.98,16.95 149.98,24.69 142.98,31.69 131.69,31.69 130.62,32.77 121.04,32.77 117.98,35.83 108.27,35.83 107.6,36.5 90.21,36.5 89.92,36.21 87.72,36.21 87.12,36.81 76.3,36.81 75.14,35.65 71.79,35.65 v1(71.24,36.19)
  LAY8 w0.1: v1(71.24,36.19) 67.69,39.75 66.92,39.75 66.67,40 66.67,40.51 65.4,41.78 61.34,41.78 55.75,47.37 55.75,47.82 54.43,49.14 54.43,50.09 53.46,51.05 53.46,53.34 51.49,55.31 51.49,56.2 47.87,59.82 47.87,60.2 45.21,62.86 42.41,62.86 37.18,68.09 37.18,76.97 35.99,78.16 31.69,78.16 27.36,82.49 27.36,87.31 23.04,91.63 23.04,92.07 22.3,92.81 v1(21.99,92.81)
TP_ME_G3_TO_M3_N: length 2.2
  TOP w0.1: J6J2.137 133.17,22.39 TP6J3.1
TP_MECC_ALS_INTR_N: length 6.6
  TOP w0.1: J6J2.92 125.01,17.01 125.01,22.82 TP6J2.1
TP_MECC_EC_SENSORHUB_N: length 9.2
  TOP w0.1: J6J2.93 124.78,15.96 124.78,22.15 124.58,22.35 124.58,23.49 TP6J1.1
TP_MECC_RSVD_PIN76: length 0.7
  TOP w0.38: J6J2.76 v1(122.5,16.97)
TP_MECC_RSVD_PIN108: length 0.7
  TOP w0.38: J6J2.108 v1(128.61,16.97)
TP_MECC_RVSD_PIN43: length 1.3
  TOP w0.1: J6J2.43 J6J2.51
TP_MECCSMB_BS_ALRT_N: length 3.9
  TOP w0.1: J6J2.207 142.82,12.13 142.82,10.85 TP5J2.1
TP_PCON_FUNC2: length 1.5
  TOP w0.305: U3A5.D7 v1(238,267.59)
  BOTTOM w0.1: TP3L5.1 237.61,267.59 v1(238,267.59)
TP_PCON_FUNC4: length 2
  TOP w0.1: U3A5.F3 241.61,268.79 v1(242.01,269.19)
  BOTTOM w0.1: TP3L3.1 243.15,269.19 v1(242.01,269.19)
TP_PCON_FUNC5: length 1.6
  TOP w0.305: U3A5.E7 v1(238,268.39)
  BOTTOM w0.1: TP3L4.1 237.82,268.39 v1(238,268.39)
TP_RECOV_MODE_SW: length 5.3
  TOP w0.1: J6J2.142 133.69,13.41 133.69,9.56 TP5J3.1
TP_RSVD_B39: length 224.9
  TOP w0.089: v1(241.14,197.64) 240.69,197.18 J3D1.B39
  TOP w0.1: TP5J4.1 v1(75.69,203.2)
  LAY8 w0.1: v1(75.69,203.2) 73.91,204.98 73.91,217.42 75.18,218.69 93.67,218.69 97.39,222.42 97.39,224.34 107.24,234.19 120.52,234.19 122.29,235.96 131.31,235.96 133.08,237.73 133.08,242.94 139.19,249.05 146.62,249.05 148.94,246.73 148.94,246.09 150.08,244.95 151.53,244.95 152.4,244.09 152.4,242.44 153.03,241.81 153.03,241.55 154.81,239.77 155.32,239.77 155.57,239.52 155.57,238.24 158.73,235.08 159.76,235.08 168.75,226.09 171.85,226.09 186.65,211.29 195.48,211.29 203.73,203.04 217.36,203.04 217.65,203.33 234.18,203.33 239.87,197.64 v1(241.14,197.64)
TP_SAR_NIRQ: length 10.4
  TOP w0.1: TP8G1.1 56.64,67.31 59.18,67.31 59.56,66.93 59.56,63.63 60.57,62.61 61.14,62.61 61.46,62.29 J8H2.34
TP_SERIRQ_TPM: length 1.6
  TOP w0.1: R7G34.2 89.15,75.06 TP7G1.1
TP_SMC_LID: length 423.1
  TOP w0.1: v1(21.84,104.14) 22.42,104.72 U8F6.24 22.42,106.99 21.84,107.57 21.69,107.57 R9F15.2 ; J6J2.135 v1(132.42,12.14)
  LAY3 w0.1: v1(132.42,12.14) 130.3,12.14 129.08,10.92 126.23,10.92 124.78,9.47 118.01,9.47 117.5,8.96 112.19,8.96 106.05,15.1 85.8,15.1 84.59,16.31 83.04,16.31 82.45,15.72 71.8,15.72 71.21,16.31 69.58,16.31 66.91,13.64 60.02,13.64 57.65,16 26.92,16 24.38,18.54 22.02,18.54 20.5,20.06 20.5,29.78 11.76,38.51 11.76,49.05 9.83,50.98 9.83,69.35 11.49,71.01 11.49,79.89 14.15,82.55 14.15,83.3 14.5,83.66 14.5,84.49 16.3,86.29 16.3,92.28 19.83,95.82 19.83,98.54 22.35,101.06 22.35,103.63 v1(21.84,104.14) ; v1(125.34,38.48) 126.36,39.5 184.87,39.5 188.79,43.42 195.36,43.42 201.5,49.56 211.51,49.56 218.01,43.05 231.14,43.05 234.77,39.42 283.64,39.42 v1(284.6,40.38)
  LAY8 w0.1: v1(125.34,38.48) 126.23,38.48 126.73,37.99 126.73,36.64 127.02,36.35 129.52,36.35 132.96,32.9 132.96,30.41 133.96,29.41 133.96,22.02 133.06,21.12 133.06,20.6 132.38,19.92 132.3,19.92 132.09,19.71 132.09,18.76 132.3,18.56 132.3,18.16 133.22,17.24 133.22,12.94 v1(132.42,12.14)
TP_V1P8A_CSN: length 295.6
  LAY3 w0.1: R8F38.4 59.51,106.36 55.01,106.36 51.81,103.16 51.81,86.01 48.56,82.76 48.56,77.8 54.78,71.58 54.78,70.65 58.28,67.15 58.95,67.15 59.73,66.37 59.73,64.3 61.89,62.15 62.9,62.15 66.08,58.97 66.08,58.21 69.63,54.66 73.19,54.66 74.94,52.91 78.88,52.91 80.43,51.36 126.41,51.36 126.61,51.56 128.65,51.56 129.1,51.1 145.97,51.1 146.43,51.56 148.04,51.56 148.58,51.03 167.25,51.03 168.37,49.91 169.92,49.91 171.04,51.03 175.9,51.03 176.86,51.99 193.57,51.99 198.22,56.64 200.66,56.64 201.16,57.15 201.16,57.62 201.88,58.34 210.98,58.34 212.51,56.82 215.72,56.82 216.66,55.88 217.8,55.88 219.25,54.43 219.25,52.75 221.27,50.72 235.28,50.72 235.69,51.13 239.34,51.13 240.2,51.99 250.86,51.99 251.17,51.69 263.27,51.69 264.54,50.42 270,50.42 272.28,52.7 272.28,53.21 272.97,53.9 273.6,53.9 275.59,55.88 275.59,57.06 274.15,58.5 272.57,58.5 272.05,57.98 272.05,57.76 271.95,57.66 v1(271.52,57.66)
TP_V1P8A_CSP: length 293.9
  LAY3 w0.1: R8F38.3 59.51,106.16 55.1,106.16 52.02,103.07 52.02,85.93 48.76,82.68 48.76,77.89 54.99,71.66 54.99,70.74 58.37,67.36 59.04,67.36 59.94,66.46 59.94,64.39 61.97,62.36 62.99,62.36 66.29,59.05 66.29,58.29 69.72,54.86 73.27,54.86 75.02,53.11 78.96,53.11 80.51,51.56 126.32,51.56 126.53,51.77 128.73,51.77 129.19,51.31 145.88,51.31 146.34,51.77 148.13,51.77 148.66,51.23 167.34,51.23 168.46,50.11 169.84,50.11 170.95,51.23 175.82,51.23 176.78,52.2 193.48,52.2 198.13,56.85 200.57,56.85 200.96,57.23 200.96,57.71 201.8,58.55 211.07,58.55 212.59,57.02 215.8,57.02 216.74,56.08 217.89,56.08 219.45,54.52 219.45,52.83 221.36,50.93 235.2,50.93 235.61,51.33 239.26,51.33 240.12,52.2 250.95,52.2 251.25,51.89 263.35,51.89 264.62,50.62 269.91,50.62 272.08,52.79 272.08,53.3 272.88,54.1 273.52,54.1 275.38,55.96 275.38,56.97 274.06,58.29 272.65,58.29 272.26,57.9 272.26,57.76 272.36,57.66 v1(272.79,57.66)
TP_V3P3_SLOTM_CSN: length 201.6
  TOP w0.1: R3H44.1 v1(227.71,49.66)
  LAY3 w0.1: v1(227.71,49.66) 227.94,49.42 227.94,49.29 227.75,49.1 220.28,49.1 219.61,49.77 219.61,51.17 214.95,55.83 212.13,55.83 211.7,56.26 202.43,56.26 201.93,55.75 198.85,55.75 193.98,50.88 185.71,50.88 183.3,48.46 159.72,48.46 158.83,49.35 147.99,49.35 146.72,48.08 124.5,48.08 123.31,49.27 107.82,49.27 107.44,48.89 105.19,48.89 103.66,50.42 78.35,50.42 78.1,50.16 74.67,50.16 71.42,53.42 66.08,53.42 62.1,57.4 62.1,59.18 54.48,66.8 48.85,66.8 47.54,65.49 47.54,64.56 47.92,64.18 48.13,64.18 48.26,64.06 R8G86.4
TP_V3P3_SLOTM_CSP: length 201.6
  TOP w0.1: R3H45.1 v1(228.85,49.66)
  LAY3 w0.1: v1(228.85,49.66) 228.6,49.66 227.83,48.89 220.2,48.89 219.4,49.69 219.4,51.09 214.86,55.62 212.05,55.62 211.62,56.05 202.52,56.05 202.01,55.55 198.94,55.55 194.06,50.67 185.8,50.67 183.38,48.26 159.63,48.26 158.75,49.15 148.08,49.15 146.81,47.88 124.42,47.88 123.23,49.07 107.9,49.07 107.52,48.69 105.1,48.69 103.58,50.21 78.44,50.21 78.19,49.96 74.59,49.96 71.33,53.21 66,53.21 61.89,57.32 61.89,59.1 54.39,66.6 48.94,66.6 47.75,65.4 47.75,64.64 48,64.39 48.13,64.39 48.26,64.51 R8G86.3
TP_V3P3_SLOTM_EAC_CSN: length 2.7
  TOP w0.1: U3H2.D2 229.1,53.23 229.1,52.83 228.28,52.01 228.28,51.88 R3H44.2
TP_V3P3_SLOTM_EAC_CSP: length 2.7
  TOP w0.1: R3H45.2 228.72,51.31 228.48,51.55 228.48,51.93 229.3,52.75 229.3,53.17 U3H2.D3
TP_V3P3DSW_CSN: length 236
  LAY3 w0.1: v1(271.52,56.26) 271.95,56.26 272.05,56.16 272.05,55.14 270.63,53.72 265.08,53.72 263.77,55.03 263.77,57.63 263.29,58.12 261.51,58.12 258.71,55.32 252.56,55.32 251.41,56.46 249.97,56.46 249.21,55.7 225.72,55.7 225.54,55.53 223.65,55.53 221.95,57.23 220.64,57.23 219.37,58.5 219.37,59 219.02,59.36 217.91,59.36 217.2,60.07 213.99,60.07 212.57,61.49 179.05,61.49 178.6,61.04 173.94,61.04 167.72,67.26 152.22,67.26 151.76,66.8 148.08,66.8 147.19,65.91 137.19,65.91 134.55,68.55 124.49,68.55 117.22,75.82 114.68,75.82 114.09,76.4 99.65,76.4 94.7,81.36 86.91,81.36 86.15,82.12 81.86,82.12 81.53,81.79 77.21,81.79 76.88,82.12 73.36,82.12 71.79,83.69 64.04,83.69 62.2,85.53 62.2,88.98 R7G4.4
TP_V3P3DSW_CSP: length 236.6
  LAY3 w0.1: R7G4.3 62,88.98 62,85.45 63.95,83.49 71.7,83.49 73.27,81.91 76.79,81.91 77.13,81.58 81.61,81.58 81.95,81.91 86.07,81.91 86.83,81.15 94.61,81.15 99.56,76.2 114.01,76.2 114.59,75.61 117.14,75.61 124.4,68.35 134.46,68.35 137.11,65.71 147.27,65.71 148.16,66.6 151.85,66.6 152.3,67.05 167.64,67.05 173.86,60.83 178.68,60.83 179.14,61.29 212.48,61.29 213.91,59.86 217.12,59.86 217.83,59.15 218.93,59.15 219.17,58.92 219.17,58.41 220.56,57.02 221.86,57.02 223.57,55.32 225.62,55.32 225.8,55.5 249.3,55.5 250.06,56.26 251.33,56.26 252.47,55.12 258.8,55.12 261.59,57.91 263.21,57.91 263.57,57.55 263.57,54.94 265,53.51 270.72,53.51 272.26,55.06 272.26,56.16 272.36,56.26 v1(272.79,56.26)
TP_V3P3DX_CPU_SSD2_CSN: length 252.9
  TOP w0.1: v1(201.67,57.4) 201.64,57.4 201.54,57.3 R4H19.1
  LAY8 w0.1: R5C17.4 150.26,214.64 150.26,213.97 152.01,212.22 156.46,212.22 157.98,210.69 161.16,210.69 162.68,209.17 163.44,209.17 164.21,208.41 164.21,207.03 164.69,206.55 165.52,206.55 166.33,205.74 169.68,205.74 173.75,209.8 175.89,209.8 178.23,207.47 178.23,204.8 180.16,202.87 181.77,202.87 183.17,201.47 186.6,201.47 189.02,199.05 189.02,193.5 183.17,187.66 181.01,187.66 175.6,182.24 172.17,182.24 168.57,178.65 168.57,173.18 164.13,168.74 164.13,165.18 155.57,156.63 155.57,151.4 146.17,142 146.17,133.07 147.59,131.65 147.59,105.48 148.25,104.82 148.25,102.03 147.57,101.34 147.57,93.69 156.3,84.96 159.1,84.96 162.48,81.59 162.48,79.51 162.96,79.02 162.96,76.91 172.06,67.82 176.02,67.82 179.34,64.49 189.38,64.49 192.91,60.96 194.94,60.96 197.82,58.08 201.65,58.08 201.9,57.83 201.9,57.63 v1(201.67,57.4)
TP_V3P3DX_CPU_SSD2_CSP: length 252.9
  TOP w0.1: R4H20.1 202.69,57.15 v1(202.43,57.4)
  LAY8 w0.1: R5C17.3 151,214.68 150.87,214.81 150.72,214.81 150.47,214.56 150.47,214.05 152.1,212.42 156.54,212.42 158.07,210.9 161.24,210.9 162.77,209.37 163.53,209.37 164.41,208.49 164.41,207.12 164.78,206.75 165.6,206.75 166.41,205.94 169.6,205.94 173.66,210.01 175.98,210.01 178.43,207.55 178.43,204.89 180.24,203.07 181.86,203.07 183.26,201.67 186.69,201.67 189.23,199.13 189.23,193.42 183.26,187.45 181.1,187.45 175.69,182.04 172.26,182.04 168.78,178.56 168.78,173.1 164.33,168.65 164.33,165.1 155.78,156.54 155.78,151.31 146.38,141.91 146.38,133.16 147.8,131.74 147.8,105.56 148.46,104.9 148.46,101.94 147.77,101.26 147.77,93.77 156.38,85.17 159.19,85.17 162.68,81.67 162.68,79.59 163.16,79.11 163.16,77 172.14,68.02 176.1,68.02 179.43,64.69 189.46,64.69 192.99,61.16 195.03,61.16 197.91,58.28 201.74,58.28 202.1,57.92 202.1,57.73 v1(202.43,57.4)
TP_V3P3DX_CPU_SSD2_EAC_CSN: length 2.2
  TOP w0.1: R4H19.2 202,55.29 202,54.86 202.46,54.41 202.46,54.11 U4H2.A2
TP_V3P3DX_CPU_SSD2_EAC_CSP: length 2.2
  TOP w0.1: R4H20.2 202.2,55.27 202.2,54.95 202.66,54.49 202.66,54.11 U4H2.A3
TP_V3P3S_CSN: length 50.3
  TOP w0.1: R3H30.1 214.35,52.83 v1(214.24,52.93)
  BOTTOM w0.1: v1(214.24,52.93) 213.96,52.65 212.68,52.65 204.68,60.65 188.55,60.65 188.03,61.17 188.03,70.06 183.47,74.62 181.27,74.62 180.68,74.03 180.68,73.63 180.58,73.53 R4G19.4
TP_V3P3S_CSP: length 50.3
  TOP w0.1: v1(214.24,52.2) 214.24,51.92 214.47,51.69 R3H37.1
  BOTTOM w0.1: R4G19.3 180.98,73.53 180.88,73.63 180.88,73.95 181.35,74.42 183.38,74.42 187.83,69.98 187.83,61.09 188.46,60.45 204.59,60.45 212.59,52.45 213.99,52.45 v1(214.24,52.2)
TP_V3P3S_EAC_CSN: length 3.1
  TOP w0.1: R3H30.2 216.37,52.36 216.73,52.36 217.04,52.66 217.04,53.24 217.44,53.64 217.73,53.64 217.81,53.72 U3H1.C1
TP_V3P3S_EAC_CSP: length 3
  TOP w0.1: U3H1.D1 217.73,53.44 217.52,53.44 217.24,53.15 217.24,52.58 216.82,52.16 216.37,52.16 R3H37.2
TP_V5DSW_CSN: length 32.7
  TOP w0.1: R3H15.1 217.55,57.96 217.65,58.06 217.92,58.06 218.02,58.16 218.02,58.6 217.92,58.7 v1(217.55,58.7)
  BOTTOM w0.1: v1(217.55,58.7) 217.57,58.67 217.92,58.67 218.02,58.77 218.02,59.54 218.23,59.76 222.67,59.76 224.59,61.68 224.59,63.8 222.29,66.09 218.25,66.09 216.91,67.44 216.91,70.23 214.44,72.7 212.89,72.7 212.39,73.19 212.39,74.12 212.69,74.42 213,74.42 213.1,74.52 R3G34.4
TP_V5DSW_CSP: length 32.3
  TOP w0.1: R3H16.1 218.69,57.96 218.59,58.06 218.32,58.06 218.22,58.16 218.22,58.6 218.32,58.7 v1(218.69,58.7)
  BOTTOM w0.1: R3G34.3 213.1,74.12 213,74.22 212.77,74.22 212.59,74.04 212.59,73.28 212.97,72.9 214.53,72.9 217.11,70.31 217.11,67.52 218.34,66.29 222.37,66.29 224.79,63.88 224.79,61.59 222.75,59.56 218.32,59.56 218.22,59.46 218.22,58.77 218.32,58.67 218.66,58.67 v1(218.69,58.7)
TP_V5DSW_EAC_CSN: length 2.2
  TOP w0.1: U3H1.A2 218.46,55 218.46,55.3 218.01,55.75 218.01,56.18 R3H15.2
TP_V5DSW_EAC_CSP: length 2.2
  TOP w0.1: R3H16.2 218.21,56.16 218.21,55.84 218.66,55.38 218.66,55 U3H1.A3
TP_V5S_CSN: length 43.5
  TOP w0.1: v1(215.26,58.7) 215.63,58.7 215.73,58.6 215.73,58.16 215.63,58.06 215.36,58.06 215.26,57.96 R3H13.1
  BOTTOM w0.1: v1(215.26,58.7) 215.63,58.7 215.73,58.8 215.73,59.09 215.62,59.2 215.51,59.31 206.85,59.31 205.07,61.09 192.53,61.09 191.64,61.97 191.64,70.36 193.67,72.39 195.7,72.39 196.3,72.99 196.3,73.43 196.2,73.53 R4G20.4
TP_V5S_CSP: length 43.5
  TOP w0.1: R3H14.1 216.4,57.96 216.3,58.06 216.03,58.06 215.93,58.16 215.93,58.6 216.03,58.7 v1(216.4,58.7)
  BOTTOM w0.1: R4G20.3 196.6,73.53 196.5,73.43 196.5,72.9 195.78,72.19 193.75,72.19 192.8,71.23 191.84,70.27 191.84,62.06 192.61,61.29 205.15,61.29 206.93,59.51 215.6,59.51 215.93,59.17 215.93,58.8 216.03,58.7 v1(216.4,58.7)
TP_V5S_EAC_CSN: length 3.8
  TOP w0.1: U3H1.B1 216.41,55.75 215.95,55.75 215.71,55.99 215.71,56.42 215.49,56.64 R3H13.2
TP_V5S_EAC_CSP: length 3.3
  TOP w0.1: U3H1.A1 217.59,54.85 216.49,55.95 216.03,55.95 215.91,56.07 215.91,56.4 216.15,56.64 R3H14.2
TP_V12S_CSN: length 36.7
  TOP w0.1: v1(218.94,50.04) R3H42.1
  BOTTOM w0.1: v1(218.94,50.04) 219.31,50.04 219.41,49.94 219.41,49.49 219.63,49.27 225.07,49.27 227.15,51.36 232.87,51.36 236.85,55.34 236.85,66.17 234.85,68.16 234.85,68.61 234.95,68.71 R3G41.4
TP_V12S_CSP: length 36
  TOP w0.1: R3H43.1 v1(220.09,50.04)
  BOTTOM w0.1: R3G41.3 234.55,68.71 234.65,68.61 234.65,68.08 236.65,66.08 236.65,55.42 232.79,51.56 227.07,51.56 224.99,49.47 219.71,49.47 219.61,49.57 219.61,49.94 219.71,50.04 v1(220.09,50.04)
TP_V12S_EAC_CSN: length 2.6
  TOP w0.1: U3H1.D2 218.49,53.17 218.49,52.88 218.76,52.61 219.24,52.61 219.48,52.37 219.48,52.22 218.94,51.69
TP_V12S_EAC_CSP: length 2.6
  TOP w0.1: 220.09,51.69 219.68,52.09 219.68,52.45 219.32,52.81 218.85,52.81 218.69,52.97 218.69,53.23 U3H1.D3
TP_VCCCORE_PH1_CSN: length 193.7
  TOP w0.1: R2E6.1 v1(279.01,153.8)
  LAY3 w0.1: 279.01,153.55 278.93,153.55 278.91,153.54 278.85,153.54 278.17,152.86 278.17,152.44 278.42,152.19 279.86,152.19 280.79,153.12 282.86,153.12 283.33,152.65 284.44,152.65 286.46,150.63 286.46,144.09 286.31,143.95 285.87,143.51 285.87,140.38 286.56,139.7 286.56,95.55 285.62,94.61 285.62,87.37 282.28,84.04 279.77,84.04 279.55,83.82 279.55,83.59 v1(279.27,83.31) ; 279.01,153.55 279.11,153.45 279.53,153.45 279.63,153.55 279.63,154.42 274.36,159.68 274.36,165.31 272.35,167.32 272.35,172.07 270.35,174.07 270.35,180.11 267.97,182.5 266.38,182.5 263.44,185.44 263.44,186.31 252.34,197.41 252.34,200.28 246.83,205.79 246.83,219.02 249.85,222.04 249.85,223.44 250.16,223.74 250.16,227.83 249.04,228.94 248.76,228.94 248.66,228.84 R2M19.4 ; 279.01,153.55 v1(279.01,153.8)
  LAY8 w0.1: v1(238.5,230.25) 238.22,229.97 238.22,229.42 240.39,227.25 248.71,227.25 249.3,227.84 249.3,228.55 248.9,228.94 248.76,228.94 248.66,228.84 R2M19.4
TP_VCCCORE_PH1_CSP: length 195.1
  TOP w0.1: R2E7.1 279.27,152.65 v1(279.01,152.91)
  LAY3 w0.1: 279.01,153.12 278.72,153.12 278.38,152.78 278.38,152.53 278.51,152.4 279.78,152.4 280.7,153.33 282.95,153.33 283.42,152.86 284.52,152.86 286.66,150.72 286.66,144.01 286.08,143.42 286.08,140.47 286.76,139.78 286.76,95.47 285.82,94.53 285.82,87.29 282.36,83.83 279.85,83.83 279.75,83.73 279.75,83.59 v1(280.03,83.31) ; 279.01,153.12 279.01,153.15 279.11,153.25 279.61,153.25 279.83,153.47 279.83,154.5 274.57,159.76 274.57,165.39 272.56,167.41 272.56,172.16 270.56,174.16 270.56,180.2 268.05,182.7 266.47,182.7 263.65,185.52 263.65,186.4 252.55,197.49 252.55,200.36 247.04,205.87 247.04,218.94 250.06,221.96 250.06,223.36 250.36,223.66 250.36,227.91 249.13,229.15 248.76,229.15 248.66,229.25 R2M19.3 ; 279.01,153.12 v1(279.01,152.91)
  LAY8 w0.1: R2M19.3 248.66,229.25 248.76,229.15 248.99,229.15 249.5,228.63 249.5,227.75 248.8,227.05 240.31,227.05 238.02,229.34 238.02,229.97 v1(237.74,230.25)
TP_VCCCORE_PH1_EAC_CSN: length 3.1
  TOP w0.1: R2E6.2 281.14,153.32 281.5,153.32 281.81,153.63 281.81,154.2 282.21,154.6 282.37,154.6 U1E2.C1
TP_VCCCORE_PH1_EAC_CSP: length 3
  TOP w0.1: R2E7.2 281.14,153.12 281.59,153.12 282.01,153.55 282.01,154.12 282.29,154.4 282.5,154.4 U1E2.D1
TP_VCCCORE_PH2_CSN: length 187.3
  TOP w0.1: R1E21.1 v1(282.95,151)
  LAY3 w0.1: R3M40.4 235.33,228.84 235.43,228.94 238.67,228.94 246.2,221.41 246.2,205.41 251.71,199.9 251.71,197.23 261.82,187.12 261.82,182.56 263.23,181.15 266.23,181.15 267.51,179.87 267.51,178.6 267.86,178.25 267.86,178.25 268.09,178.02 268.09,174.02 271.33,170.79 271.33,166.33 273.07,164.58 273.07,158.25 274.52,156.8 277.58,153.74 277.58,152.08 278.36,151.3 279.83,151.3 280.46,151.94 282.78,151.94 283.23,151.49 283.23,151.28 v1(282.95,151) 283.46,150.49 283.93,150.49 284.52,149.9 284.52,147.88 284.35,147.7 284.35,144.5 285.18,143.66 285.18,140.09 285.92,139.35 285.92,97.58 284.93,96.6 284.93,88.09 282.19,85.34 279.8,85.34 279.55,85.09 279.55,84.86 v1(279.27,84.58)
  LAY8 w0.1: v1(238.5,235.05) 238.22,234.77 238.22,233.87 236.55,232.2 236.55,229.69 235.8,228.94 235.43,228.94 235.33,228.84 R3M40.4
TP_VCCCORE_PH2_CSP: length 186.9
  TOP w0.1: R1E22.1 v1(283.71,151)
  LAY3 w0.1: v1(280.03,84.58) 279.75,84.86 279.75,85 279.89,85.14 282.27,85.14 285.14,88 285.14,96.51 286.13,97.5 286.13,139.44 285.39,140.18 285.39,143.75 284.55,144.58 284.55,147.61 284.73,147.79 284.73,149.99 284.02,150.7 283.81,150.7 283.71,150.8 v1(283.71,151) 283.43,151.28 283.43,151.57 282.86,152.14 280.38,152.14 279.74,151.51 278.45,151.51 277.79,152.17 277.79,153.82 274.72,156.89 273.28,158.33 273.28,164.66 271.53,166.41 271.53,170.87 268.3,174.11 268.3,178.1 267.71,178.69 267.71,179.96 266.31,181.35 263.32,181.35 262.02,182.65 262.02,187.2 251.91,197.31 251.91,199.98 246.4,205.49 246.4,221.49 238.75,229.15 235.43,229.15 235.33,229.25 R3M40.3
  LAY8 w0.1: v1(237.74,235.05) 238.02,234.77 238.02,233.96 236.34,232.28 236.34,229.78 235.71,229.15 235.43,229.15 235.33,229.25 R3M40.3
TP_VCCCORE_PH2_EAC_CSN: length 1.9
  TOP w0.1: U1E2.D2 283.26,154.14 283.26,152.96 R1E21.2
TP_VCCCORE_PH2_EAC_CSP: length 1.8
  TOP w0.1: R1E22.2 283.46,152.91 283.46,154.19 U1E2.D3
TP_VCCCORE_PH3_CSN: length 202
  TOP w0.1: R1E28.1 v1(282.82,149.63)
  LAY3 w0.1: R3M41.4 225.42,228.84 225.52,228.94 226.6,228.94 231.21,224.33 241.12,224.33 245.62,219.83 245.62,205.61 245.11,205.1 245.11,196.72 250.19,191.64 256.25,191.64 259.84,188.05 259.84,183.22 261.79,181.27 261.79,178.98 265.14,175.64 266.57,175.64 267.46,174.75 267.46,173.82 270.67,170.6 270.67,165.98 272.28,164.37 272.28,158.15 276.99,153.44 276.99,151.89 278.34,150.54 279.95,150.54 280.16,150.75 281.39,150.75 282.17,149.97 282.48,149.97 v1(282.82,149.63) 283.29,149.16 283.29,144.64 284.57,143.36 284.57,139.88 285.29,139.17 285.29,97.96 284.17,96.85 284.17,94.94 282.06,92.84 282.06,87.58 281.05,86.56 279.69,86.56 279.55,86.42 279.55,86.13 v1(279.27,85.85)
  LAY8 w0.1: v1(215.01,230.25) 214.73,229.97 214.73,229.64 217.09,227.28 225.59,227.28 226.1,227.79 226.1,228.68 225.88,228.9 225.48,228.9 225.42,228.84 R3M41.4
TP_VCCCORE_PH3_CSP: length 204.3
  TOP w0.1: R1E29.1 v1(283.97,149.63)
  LAY3 w0.1: R3M41.3 225.42,229.25 225.52,229.15 226.69,229.15 231.3,224.53 241.2,224.53 245.82,219.92 245.82,205.53 245.31,205.02 245.31,196.81 250.27,191.85 256.33,191.85 260.04,188.13 260.04,183.31 262,181.35 262,179.07 265.22,175.84 266.65,175.84 267.16,175.34 267.66,174.84 267.66,173.9 270.88,170.69 270.88,166.07 272.49,164.46 272.49,158.24 277.2,153.53 277.2,151.98 278.43,150.75 279.87,150.75 280.07,150.95 281.48,150.95 282.25,150.18 283.08,150.18 283.27,149.99 283.61,149.99 v1(283.97,149.63) 283.5,149.16 283.5,144.73 284.78,143.45 284.78,139.97 285.49,139.25 285.49,97.88 284.38,96.76 284.38,94.86 282.27,92.75 282.27,87.49 281.13,86.36 279.78,86.36 279.75,86.33 279.75,86.13 v1(280.03,85.85)
  LAY8 w0.1: v1(214.24,230.25) 214.52,229.97 214.52,229.55 217,227.07 225.67,227.07 226.31,227.71 226.31,228.76 225.96,229.11 225.56,229.11 225.42,229.25 R3M41.3
TP_VCCCORE_PH3_EAC_CSN: length 2.2
  TOP w0.1: R1E28.2 283.28,147.49 283.28,147.07 283.74,146.61 283.74,146.32 U1E3.A2
TP_VCCCORE_PH3_EAC_CSP: length 2.2
  TOP w0.1: R1E29.2 283.48,147.47 283.48,147.15 283.94,146.69 283.94,146.31 U1E3.A3
TP_VCCCORE_PH4_CSN: length 203.9
  TOP w0.1: v1(280.67,149.6) 280.54,149.48 R1E26.1
  LAY3 w0.1: R3M42.4 212.09,228.84 212.19,228.94 215.39,228.94 220.81,223.52 240.88,223.52 243.33,221.07 243.33,213.36 244.22,212.47 244.22,196.69 250.86,190.04 255.34,190.04 258.36,187.02 258.36,180.89 260.44,178.81 261.16,178.81 265.05,174.93 265.52,174.93 270.06,170.38 270.06,165.75 271.65,164.16 271.65,157.87 276.44,153.08 276.44,151.57 278.41,149.6 279.9,149.6 280.2,149.9 280.38,150.08 280.77,150.08 280.92,149.93 280.92,149.7 280.82,149.6 v1(280.67,149.6) 280.97,149.3 280.97,145.82 283.86,142.93 283.86,139.59 284.65,138.8 284.65,98.47 283.4,97.22 283.4,95.19 281.3,93.09 281.3,88.77 280.41,87.88 279.8,87.88 279.55,87.63 279.55,87.4 v1(279.27,87.12)
  LAY6 w0.115: R3M42.4 212.09,228.81 212.2,228.93 212.74,228.93 213.2,229.39 213.2,232.57 214.74,234.1 214.74,234.78 v1(215.01,235.05)
TP_VCCCORE_PH4_CSP: length 203.9
  TOP w0.1: v1(281.43,149.6) 281.55,149.6 281.68,149.48 R1E27.1
  LAY3 w0.1: v1(280.03,87.12) 279.75,87.4 279.75,87.54 279.89,87.68 280.5,87.68 281.51,88.69 281.51,93 283.6,95.1 283.6,97.13 284.86,98.39 284.86,138.89 284.07,139.68 284.07,143.02 281.17,145.91 281.17,149.35 v1(281.43,149.6) 281.31,149.6 281.12,149.79 281.12,150.02 280.85,150.29 280.29,150.29 279.81,149.81 278.5,149.81 276.65,151.66 276.65,153.17 271.86,157.96 271.86,164.25 270.27,165.84 270.27,170.47 265.6,175.13 265.13,175.13 261.25,179.02 260.52,179.02 258.57,180.97 258.57,187.11 255.43,190.24 250.95,190.24 244.42,196.77 244.42,212.55 243.53,213.44 243.53,221.15 240.96,223.72 220.9,223.72 215.48,229.15 212.19,229.15 212.09,229.25 R3M42.3
  LAY6 w0.115: R3M42.3 212.09,229.27 212.2,229.16 212.64,229.16 212.97,229.49 212.97,232.66 214.51,234.2 214.51,234.78 v1(214.24,235.05)
TP_VCCCORE_PH4_EAC_CSN: length 3.8
  TOP w0.1: U1E3.B1 283.09,145.67 281.69,147.07 281.23,147.07 280.99,147.3 280.99,147.73 280.77,147.95 R1E26.2
TP_VCCCORE_PH4_EAC_CSP: length 3.3
  TOP w0.1: R1E27.2 281.43,147.95 281.19,147.72 281.19,147.39 281.31,147.27 281.77,147.27 282.88,146.16 U1E3.A1
TP_VCCCORE_PH5_CSN: length 172.7
  TOP w0.1: R1E36.1 v1(279.52,144.14)
  LAY3 w0.1: v1(279.52,144.14) 279.52,143.74 279.62,143.64 282.09,143.64 283.45,142.29 283.45,139.29 284.22,138.51 284.22,98.77 282.19,96.73 282.19,95.63 279.47,92.91 279.47,88.97 279.61,88.84 279.79,88.84 v1(280.03,89.08)
  LAY5 w0.115: v1(276.67,164.37) 276.41,164.63 276.07,164.63 275.94,164.5 275.94,164.19 275.08,163.32 268.27,163.32 267.97,163.63 267.97,165.41 266.08,167.29 266.08,173.89 263.29,176.69 263.29,193.77 265.96,196.44 265.96,221.21 265.5,221.67 265.5,223.47 266.64,224.61 266.64,225.05 266.53,225.17 R2N1.4
  LAY8 w0.1: v1(261.62,227.84) 261.34,228.12 261.34,228.26 261.44,228.36 261.82,228.36 264.25,225.93 266.31,225.93 266.66,225.59 266.66,225.27 266.56,225.17 R2N1.4 ; v1(279.52,144.14) 279.52,143.77 279.62,143.67 280.07,143.67 280.41,144.02 280.41,148.74 279.91,149.24 279.91,150.88 280.16,151.13 280.16,156.21 281.94,157.99 281.94,161.89 280.38,163.45 278.25,163.45 277.07,164.63 276.93,164.63 v1(276.67,164.37)
TP_VCCCORE_PH5_CSP: length 173.7
  TOP w0.1: R1E37.1 v1(279.52,143)
  LAY3 w0.1: v1(280.03,88.39) 279.79,88.63 279.52,88.63 279.27,88.89 279.27,93 281.98,95.71 281.98,96.82 284.02,98.85 284.02,138.43 283.24,139.2 283.24,142.2 282.01,143.44 279.62,143.44 279.52,143.34 v1(279.52,143)
  LAY5 w0.115: v1(276.67,165.18) 276.35,164.86 275.98,164.86 275.71,164.59 275.71,164.28 274.98,163.55 268.37,163.55 268.2,163.73 268.2,165.5 266.31,167.38 266.31,173.99 263.52,176.78 263.52,193.67 266.19,196.34 266.19,221.3 265.73,221.76 265.73,223.37 266.87,224.51 266.87,225.05 266.99,225.17 R2N1.3
  LAY8 w0.1: v1(260.85,227.84) 261.13,228.12 261.13,228.34 261.24,228.45 261.35,228.56 261.91,228.56 264.33,226.14 266.4,226.14 266.86,225.67 266.86,225.27 266.96,225.17 R2N1.3 ; v1(279.52,143) 279.52,143.37 279.62,143.47 280.15,143.47 280.62,143.93 280.62,148.83 280.12,149.33 280.12,150.8 280.36,151.04 280.36,156.12 282.14,157.9 282.14,161.97 280.46,163.65 278.34,163.65 277.16,164.83 277.02,164.83 v1(276.67,165.18)
TP_VCCCORE_PH5_EAC_CSN: length 3.1
  TOP w0.1: U1E3.C1 282.94,145.02 282.65,145.02 282.32,144.68 282.32,143.98 282.01,143.67 281.64,143.67 R1E36.2
TP_VCCCORE_PH5_EAC_CSP: length 3.1
  TOP w0.1: U1E3.D1 282.94,144.82 282.74,144.82 282.52,144.59 282.52,143.9 282.09,143.47 281.65,143.47 R1E37.2
TP_VCCCORE_PH6_CSN: length 191.6
  TOP w0.1: v1(287.24,140.27) 286.93,140.58 285.28,140.58 284.69,141.17 284.69,141.64 R1E41.1
  LAY3 w0.1: v1(279.27,82.04) 279.55,82.32 279.55,82.55 279.8,82.8 282.95,82.8 286.38,86.23 286.38,94.23 287.22,95.07 287.22,133.13 288.36,134.27 288.36,140.24 288.03,140.58 287.54,140.58 v1(287.24,140.27) 286.93,140.58 286.7,140.58 286.46,140.82 286.46,141.68 287.14,142.37 287.14,152.4 286.76,152.78 286.76,154.68 284.43,157.02 281.22,157.02 275.58,162.66 275.58,164.99 272.98,167.59 272.98,172.34 270.94,174.38 270.94,180.25 266.62,184.57 266.62,189.14 266.02,189.74 264.54,189.74 255.95,198.32 255.95,201.84 255.18,202.61 253.15,202.61 247.47,208.29 247.47,216.27 259.25,228.05 259.25,228.84 259.15,228.94 258.67,228.94 258.57,228.84 R2M18.4
  LAY8 w0.1: v1(261.62,232.66) 261.34,232.38 261.34,232.09 259.92,230.67 259.92,229.4 259.45,228.94 258.67,228.94 258.57,228.84 R2M18.4
TP_VCCCORE_PH6_CSP: length 191.2
  TOP w0.1: v1(287.24,141.08) 286.93,140.78 285.36,140.78 284.89,141.25 284.89,141.64 R1E42.1
  LAY3 w0.1: R2M18.3 258.57,229.25 258.67,229.15 259.24,229.15 259.46,228.93 259.46,227.96 247.67,216.18 247.67,208.38 253.23,202.82 255.27,202.82 256.15,201.93 256.15,198.41 264.62,189.94 266.11,189.94 266.82,189.23 266.82,184.66 271.14,180.34 271.14,174.46 273.18,172.42 273.18,167.67 275.78,165.07 275.78,162.74 276.75,161.77 281.3,157.22 284.51,157.22 286.97,154.77 286.97,152.86 287.35,152.48 287.35,142.28 286.67,141.6 286.67,140.91 286.79,140.78 286.93,140.78 v1(287.24,141.08) 287.54,140.78 288.11,140.78 288.57,140.33 288.57,134.19 287.42,133.05 287.42,94.99 286.59,94.15 286.59,86.15 283.04,82.6 279.89,82.6 279.75,82.46 279.75,82.32 v1(280.03,82.04)
  LAY8 w0.1: v1(260.85,232.66) 261.13,232.38 261.13,232.18 259.71,230.76 259.71,229.49 259.37,229.15 258.67,229.15 258.57,229.25 R2M18.3
TP_VCCCORE_PH6_EAC_CSN: length 2.6
  TOP w0.1: R1E41.2 284.75,143.53 284.75,143.68 284.51,143.92 284.04,143.92 283.76,144.19 283.76,144.49 U1E3.D2
TP_VCCCORE_PH6_EAC_CSP: length 2.6
  TOP w0.1: R1E42.2 284.95,143.41 284.95,143.76 284.6,144.12 284.12,144.12 283.96,144.28 283.96,144.54 U1E3.D3
TP_VCCCORE_PH7_CSN: length 275.5
  TOP w0.1: R1D12.1 v1(289.56,165.5)
  LAY3 w0.1: R4M28.4 202.31,228.84 202.41,228.94 202.63,228.94 203.15,229.45 203.15,232.7 204.63,234.19 211.2,234.19 212.21,233.17 215.39,233.17 216.4,234.19 234.18,234.19 234.61,234.62 237.15,234.62 237.58,234.19 246.21,234.19 246.71,234.69 249.3,234.69 249.8,234.19 256.15,234.19 258.69,231.65 260.98,231.65 262.38,230.25 262.38,227.11 249.98,214.72 249.98,208.23 252.34,205.87 260.73,205.87 270.08,196.52 277.31,196.52 280.92,192.91 284.35,192.91 290.49,186.77 290.49,167.3 290.02,166.83 290.02,165.6 289.92,165.5 v1(289.56,165.5) 290.02,165.04 290.02,164.72 293.11,161.63 293.11,159.51 295.02,157.61 295.02,116.97 296.54,115.44 296.54,86.74 293.87,84.07 288.19,84.07 287.93,83.82 287.93,83.59 v1(287.65,83.31)
  LAY8 w0.1: R4M28.4 202.31,228.84 202.41,228.94 202.82,228.94 202.94,228.82 202.94,227.58 202.61,227.25 193.75,227.25 191.61,229.39 191.61,229.97 v1(191.89,230.25)
TP_VCCCORE_PH7_CSP: length 276.8
  TOP w0.1: R1D13.1 v1(290.7,165.5)
  LAY3 w0.1: v1(288.41,83.31) 288.13,83.59 288.13,83.73 288.27,83.87 293.96,83.87 296.75,86.65 296.75,115.53 295.22,117.05 295.22,157.69 293.32,159.6 293.32,161.72 290.23,164.81 290.23,165.04 v1(290.7,165.5) 290.33,165.5 290.23,165.6 290.23,166.75 290.7,167.22 290.7,186.85 284.43,193.12 281,193.12 277.4,196.72 270.16,196.72 260.81,206.07 252.43,206.07 250.19,208.31 250.19,214.63 262.58,227.03 262.58,230.33 261.07,231.85 258.78,231.85 256.24,234.39 249.89,234.39 249.38,234.9 246.63,234.9 246.12,234.39 237.66,234.39 237.23,234.82 234.53,234.82 234.1,234.39 216.32,234.39 215.3,233.38 212.3,233.38 211.28,234.39 204.54,234.39 202.94,232.79 202.94,229.54 202.55,229.15 202.41,229.15 202.31,229.25 R4M28.3
  LAY8 w0.1: R4M28.3 202.31,229.25 202.41,229.15 202.9,229.15 203.15,228.9 203.15,227.5 202.7,227.05 193.66,227.05 191.41,229.3 191.41,229.97 v1(191.13,230.25)
TP_VCCCORE_PH7_EAC_CSN: length 2.2
  TOP w0.1: R1D12.2 290.02,163.37 290.02,162.94 290.47,162.48 290.47,162.19 U1E1.A2
TP_VCCCORE_PH7_EAC_CSP: length 2.2
  TOP w0.1: R1D13.2 290.22,163.35 290.22,163.02 290.67,162.57 290.67,162.19 U1E1.A3
TP_VCCCORE_PH8_CSN: length 274.4
  TOP w0.1: R1D10.1 v1(287.27,165.41)
  LAY3 w0.1: R4M27.4 189,230.01 189.2,230.21 189.61,230.21 190.79,229.03 193.08,229.03 194.9,227.2 202.94,227.2 204.08,228.34 204.08,231.27 206.24,233.42 210.82,233.42 212.34,231.9 215.64,231.9 217.17,233.42 234.52,233.42 235,233.9 236.87,233.9 237.35,233.42 246.12,233.42 247.01,232.54 249.17,232.54 250.06,233.42 255.86,233.42 260.01,229.28 260.01,226.87 249.3,216.15 249.3,207.77 251.96,205.1 260.44,205.1 269.96,195.58 277.24,195.58 280.67,192.15 284.09,192.15 287.14,189.1 287.14,177.29 288.16,176.27 288.16,173.48 287.74,173.06 287.74,172.89 287.74,165.61 287.55,165.42 287.28,165.42 v1(287.27,165.41) 287.28,165.41 287.74,164.95 287.74,164.25 290.7,161.29 290.7,160.27 292.79,158.18 292.79,156.15 293.54,155.4 293.54,123.23 294.18,122.6 294.18,116.75 295.07,115.86 295.07,107.1 295.45,106.72 295.45,98.13 294.94,97.62 294.94,87.97 292.31,85.34 288.19,85.34 287.93,85.09 287.93,84.86 v1(287.65,84.58)
  LAY6 w0.115: R4M27.4 189,230.58 189.11,230.7 189.83,230.7 190.22,231.09 190.22,233.08 191.63,234.48 191.63,234.78 v1(191.89,235.05)
TP_VCCCORE_PH8_CSP: length 275.3
  TOP w0.1: R1D11.1 v1(288.41,165.41)
  LAY3 w0.1: v1(288.41,84.58) 288.13,84.86 288.13,85 288.27,85.14 292.4,85.14 295.14,87.88 295.14,97.53 295.65,98.04 295.65,106.81 295.27,107.19 295.27,115.95 294.38,116.84 294.38,122.68 293.75,123.32 293.75,155.48 293,156.23 293,158.26 290.9,160.36 290.9,161.37 287.94,164.33 287.94,165.01 288.34,165.41 v1(288.41,165.41) 288.34,165.48 288.1,165.48 287.94,165.64 287.94,172.98 288.36,173.4 288.36,176.36 287.35,177.38 287.35,189.19 284.18,192.35 280.75,192.35 277.32,195.78 270.05,195.78 260.52,205.31 252.05,205.31 249.5,207.86 249.5,216.07 260.22,226.78 260.22,229.36 255.95,233.63 249.97,233.63 249.08,232.74 247.1,232.74 246.21,233.63 237.43,233.63 236.95,234.11 234.92,234.11 234.44,233.63 217.08,233.63 215.56,232.11 212.42,232.11 210.9,233.63 206.16,233.63 203.88,231.35 203.88,228.43 202.86,227.41 194.99,227.41 193.16,229.23 190.88,229.23 189.69,230.42 189.2,230.42 189,230.62 R4M27.3
  LAY6 w0.115: v1(191.13,235.05) 191.4,234.78 191.4,234.58 189.99,233.17 189.99,231.18 189.73,230.93 189.11,230.93 189,231.04 R4M27.3
TP_VCCCORE_PH8_EAC_CSN: length 3.8
  TOP w0.1: U1E1.B1 289.82,161.54 288.42,162.94 287.96,162.94 287.72,163.18 287.72,163.61 287.5,163.83 R1D10.2
TP_VCCCORE_PH8_EAC_CSP: length 3.3
  TOP w0.1: U1E1.A1 289.61,162.04 288.5,163.14 288.04,163.14 287.92,163.26 287.92,163.59 288.16,163.83 R1D11.2
TP_VCCCORE_VIN_CSN: length 123.1
  TOP w0.1: R1E10.1 282.79,158.97 282.79,159.35 283,159.57 283.87,159.57 284.71,160.41 284.71,160.77 285.87,161.92 285.87,165.23 286.91,166.27 290.22,166.27 290.77,166.82 291.53,166.82 v1(291.84,167.13)
  LAY3 w0.1: v1(275.97,201.41) 275.97,201.58 276.09,201.71 276.32,201.71 276.47,201.55 276.47,198.84 281.55,193.77 284.51,193.77 291.33,186.94 291.33,171.96 292.4,170.89 292.4,166.96 292.26,166.83 292.14,166.83 v1(291.84,167.13)
  LAY5 w0.1: R1B1.4 281.17,258.82 281.47,258.53 281.47,253.91 274.67,247.12 274.67,238.99 275.62,238.03 275.62,223.61 274.61,222.59 274.61,220.25 275.75,219.11 275.75,211.67 276.03,211.39 276.26,211.16 276.26,203.79 275.25,202.78 275.25,201.94 275.48,201.71 275.67,201.71 v1(275.97,201.41)
TP_VCCCORE_VIN_CSP: length 123.1
  TOP w0.1: R1E11.1 282.99,158.97 282.99,159.27 283.09,159.37 283.95,159.37 284.91,160.33 284.91,160.68 286.07,161.84 286.07,165.14 287,166.07 290.3,166.07 290.85,166.62 291.53,166.62 v1(291.84,166.32)
  LAY3 w0.1: v1(291.84,166.32) 292.14,166.62 292.35,166.62 292.6,166.88 292.6,170.98 291.54,172.04 291.54,187.03 284.59,193.97 281.64,193.97 276.68,198.93 276.68,201.63 276.4,201.91 276.28,201.91 v1(275.97,202.23)
  LAY5 w0.1: R1B1.3 281.96,258.82 281.68,258.55 281.68,253.82 274.89,247.03 274.89,239.08 275.84,238.12 275.84,223.52 274.82,222.5 274.82,220.34 275.97,219.2 275.97,211.76 276.47,211.25 276.47,203.7 275.47,202.69 275.47,202.03 275.57,201.93 275.67,201.93 v1(275.97,202.23)
TP_VCCCORE_VIN_EAC_CSN: length 2.2
  TOP w0.1: R1E10.2 282.77,157.15 282.77,156.72 283.23,156.26 283.23,155.96 U1E2.A2
TP_VCCCORE_VIN_EAC_CSP: length 2.2
  TOP w0.1: U1E2.A3 283.43,155.97 283.43,156.34 282.97,156.8 282.97,157.12 R1E11.2
TP_VCCDDQ_EAC_CSN: length 3.1
  TOP w0.1: R4H33.2 200.36,51.47 200.73,51.47 201.04,51.78 201.04,52.48 201.37,52.81 201.66,52.81 U4H2.C1
TP_VCCDDQ_EAC_CSP: length 3.1
  TOP w0.1: U4H2.D1 201.66,52.61 201.46,52.61 201.24,52.39 201.24,51.69 200.81,51.27 200.37,51.27 R4H37.2
TP_VCCGT_PH1_CSN: length 185.7
  TOP w0.1: v1(286.25,159.82) 286.3,159.82 286.51,160.02 R1E5.1
  LAY3 w0.1: 286.25,159.65 286.35,159.55 286.55,159.55 286.89,159.89 286.89,160.65 286.38,161.16 284.69,161.16 284.14,161.71 284.14,164.68 286.81,167.34 286.81,174.92 286.3,175.43 286.3,178.35 285.41,179.24 285.41,182.58 286.18,183.34 286.18,188.89 283.88,191.18 272.87,191.18 271.85,192.2 269.16,192.2 268.81,191.85 268.81,189.02 270.46,187.37 270.46,184.62 270.07,184.24 269.84,184.24 269.74,184.14 R2P3.4 ; 286.25,159.65 286.15,159.55 285.93,159.55 285.54,159.16 285.54,158.41 286.68,157.27 288.87,157.27 290.49,155.65 290.49,141.82 290.11,141.43 290.11,138.09 291,137.2 291,111.04 291.76,110.28 291.76,106.64 291,105.87 291,98.38 290.49,97.87 290.49,88.39 289.99,87.88 288.19,87.88 287.93,87.63 287.93,87.4 v1(287.65,87.12) ; 286.25,159.65 v1(286.25,159.82)
  LAY8 w0.1: v1(287.65,87.12) 287.93,86.84 287.93,86.7 287.83,86.6 287.13,86.6 285.87,85.34 285.87,75.69 284.48,74.29 283.21,74.29 282.32,73.4 282.32,69.34 274.95,61.97 274.95,60.45 273.35,58.85 273.35,54.95 272.05,53.65 272.05,53.06 271.95,52.96 v1(271.52,52.96)
