# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_SHD_IO2: length 2.5
  TOP w0.1: R9F20.1 19.3,107.95 20.02,107.23 U8F6.30
EC_SHD_IO2_R: length 29.6
  TOP w0.1: R9F17.1 R9F20.2 18.03,107.29 v1(18.13,107.19)
  BOTTOM w0.1: R9U4.1 17.65,83.67 17.65,89.41 18.16,89.91 18.16,93.72 21.33,96.9 21.33,105.15 20.57,105.92 19.4,105.92 v1(18.13,107.19)
EC_SHD_IO3: length 5.5
  TOP w0.1: U8F6.31 19.62,106.99 19.43,107.19 18.92,107.19 18.28,106.55 17.52,106.55 R9F19.1
EC_SHD_IO3_R: length 33.8
  TOP w0.1: R9F19.2 R9F16.1 v1(16.07,108.96)
  BOTTOM w0.1: v1(16.07,108.96) 16.84,108.2 18.4,108.2 19.98,106.62 21.42,106.62 22.65,105.39 22.65,95.55 19.97,92.87 19.97,85.5 18.79,84.33 18.79,83.67 R9U1.1
EC_SHD_SCLK: length 40.9
  TOP w0.1: U8F6.32 19.22,104.98 v1(19.3,104.9)
  BOTTOM w0.1: v1(19.3,104.9) 19.22,104.9 18.41,104.09 18.41,103.12 14.85,99.57 14.85,94.14 11.27,90.55 11.27,83.06 16.28,78.05 16.28,74.14 18.16,72.26 R9U20.1
EC_SHD_SCLK_AIC: length 160.6
  TOP w0.1: J6J2.140 v1(132.66,16.97)
  LAY3 w0.1: v1(132.66,16.97) 131.95,16.25 130,16.25 129.54,15.79 120.22,15.79 119.5,16.51 115.82,16.51 114.58,17.75 113.54,17.75 112.78,18.51 111.57,18.51 109.77,20.31 103.84,20.31 101.28,22.88 99.7,22.88 98.97,22.15 98.2,22.15 97.6,22.76 89.07,22.76 88.33,23.49 81.79,23.49 80.87,22.57 75.79,22.57 75.44,22.22 65.12,22.22 64.87,22.47 63.89,22.47 62.99,23.37 61.87,23.37 59.11,26.12 55.98,26.12 53.4,28.7 52.07,28.7 50.89,29.88 47.34,29.88 47.05,29.59 33.91,29.59 30.14,33.36 27.34,33.36 24.63,36.07 24.63,39.75 23.74,40.64 23.74,42.84 22.57,44.01 22.57,45.53 22.04,46.07 21.27,46.07 19.52,47.82 19.52,68.18 20.82,69.47 20.82,70.57 21.41,71.17 21.41,71.8 v1(20.95,72.26)
  BOTTOM w0.1: R9U19.1 20.19,71.5 v1(20.95,72.26)
EC_SHD_SCLK_R: length 12.1
  TOP w0.1: v1(21.71,73.28) 22.22,73.79 22.22,74.42 22.28,74.48 22.28,77.11 21.97,77.43 21.97,79.55 v1(21.69,79.83)
  BOTTOM w0.1: v1(21.71,73.28) 21.2,72.77 20.32,72.77 R9U20.2 ; v1(21.69,79.83) 21.69,80.69 R9U9.1
EC_SLP_S0_CS_N: length 201.3
  TOP w0.089: U6E1.Y48 104.51,135.18 104.56,135.13 104.56,129.89 104.25,129.59 104.25,128.97
  TOP w0.1: v1(105.31,104.77) 105.53,105 105.53,105.94 105.31,106.17 105.31,108.24 106.24,109.17 106.24,111.57 106.03,111.77 106.03,113.83 106.72,114.52 106.72,120.5 105.43,121.8 105.43,124.59 104.97,125.05 104.97,127.87 104.25,128.58 104.25,128.97 ; v1(20.32,103) 19.93,103.38 19.05,103.38 18.7,103.73 18.7,104.88 16.14,107.44 14.73,107.44 14.47,107.19 R9F22.1
  LAY5 w0.125: v1(105.31,104.77) 104.14,103.6 104.14,92.86 103.22,91.95 102.44,91.95 98.31,87.82 98.31,87.12 92.82,81.63 91.95,81.63 90.41,80.1 86.29,80.1 84.19,78 83.45,78 81.39,75.93 81.39,74.88 80.26,73.75 80.26,72.66 78.84,71.25 75.92,71.25 71.96,67.29 60.41,67.29 59.66,66.54 59.66,65.28 59.78,65.16 59.78,64.54 59.05,63.82 54.65,63.82 53.7,64.77 52.04,64.77 51.79,64.52 49.39,64.52 49.14,64.26 48,64.26 45.58,61.84 45.58,61.33 41.66,57.4 28.57,57.4 25.52,60.45 22.86,60.45 20.7,62.6 20.7,70.48 20.19,71 20.19,79.88 21.46,81.15 21.46,83.76 20.36,84.86 20.36,90.56 21,91.21 21,94.01 21.79,94.79 21.79,101.9 20.7,103 v1(20.32,103)
EC_SMI_N: length 250.8
  TOP w0.1: R8F17.1 28.82,118.49 32.25,115.06 v1(32.38,115.06) CR8F6.1 ; R8F26.2 32.76,108.08 32,107.31 v1(31.87,107.31) 31.62,107.06 U8F6.1 ; J7J1.24 106.29,33.53 v1(107.44,34.67) ; J6J2.224 v1(145.87,10.54)
  LAY5 w0.125: v1(142.62,37.46) 142.11,36.96 133.09,36.96 132.71,36.57 131.31,36.57 131.19,36.7 131.19,37.26 130.14,38.31 127.16,38.31 126.87,38.02 126.87,35.05 125.72,33.9 122.59,33.9 121.88,34.61 107.5,34.61 v1(107.44,34.67) 106.7,35.41 105.79,35.41 105.78,35.42 102.29,35.42 101.15,34.28 63.23,34.28 61.96,33 50.66,33 50.24,33.42 47.78,33.42 45.77,35.43 39.27,35.43 38.75,34.92 34.02,34.92 v1(33.14,34.03)
  LAY6 w0.125: v1(142.62,37.46) 143.38,36.7 143.38,19.43 145.84,16.97 145.84,15.82 146.43,15.24 146.43,11.09 v1(145.87,10.54) ; v1(33.14,34.03) 33.14,36.07 34.03,36.96 34.03,46.94 37.72,50.63 37.72,56.53 36.7,57.55 36.7,65.3 34.92,67.08 34.92,67.67 33.62,68.97 33.62,71.36 34.46,72.2 35.27,72.2 35.69,72.62 35.69,74.06 33.75,76 33.75,89.31 33.26,89.79 33.26,92.83 33.48,93.05 33.48,105.7 v1(31.87,107.31) 32,107.31 32.51,107.82 32.51,109.35 31.75,110.11 31.75,114.43 v1(32.38,115.06)
EC_SMI_R_N: length 125.6
  TOP w0.089: U6E1.AL15 98.95,151.15 v1(98.95,150.49)
  TOP w0.1: v1(36.95,115.06) CR8F6.2 ; R8F26.1 33.65,109.85 v1(34.41,110.62)
  LAY5 w0.125: v1(34.41,110.62) 34.41,112.52 v1(36.95,115.06) 37.4,115.51 37.4,120.93 32.51,125.83 32.51,128.4 27.49,133.41 27.49,144.08 32.51,149.1 v1(33.78,149.1)
  BOTTOM w0.1: v1(33.78,149.1) 33.97,149.1 35.59,147.48 35.93,147.48 37.69,145.72 44.17,145.72 47.88,149.43 52.24,149.43 52.81,148.86 53.83,148.86 54.4,149.43 55.87,149.43 58.41,146.89 63.95,146.89 64.17,147.11 78.33,147.11 78.61,147.39 81.22,147.39 82.14,148.31 82.67,148.31 83.92,147.06 86.74,147.06 87.37,147.7 91.31,147.7 91.93,148.32 98.28,148.32 98.67,148.71 98.67,150.21 v1(98.95,150.49)
EC_SPI_CS_N: length 82.3
  TOP w0.1: J9E9.2 9.14,137.03 11.16,137.03 13.57,139.44 15.49,139.44 15.62,139.57 R9E29.2 EU9E1.1 19.05,138.17 v1(19.05,134.62)
  BOTTOM w0.1: v1(19.05,134.62) 20.06,133.6 20.06,133.09 20.32,132.84 20.82,132.84 21.71,131.95 21.71,130.55 22.6,129.67 22.6,124.08 19.43,120.9 18.41,120.9 16.38,118.87 16.38,111.31 17.84,109.85 19.08,109.85 20.67,108.27 22.15,108.27 24.3,106.11 24.3,94.18 24.51,93.98 24.51,89.8 25.43,88.88 25.43,84.18 R9U8.2
EC_SPI_HOLD_N: length 117.3
  TOP w0.1: v1(19.05,133.88) 21.74,133.88 24.13,136.27 24.13,137.86 EU9E1.7 25.65,138.68 25.9,138.94 R8E45.2
  BOTTOM w0.1: R9U2.2 20.32,85.01 20.32,87.64 20.42,87.74 21.1,87.74 21.2,87.84 21.2,88.04 21.1,88.14 20.42,88.14 20.32,88.24 20.32,92.64 20.42,92.74 20.62,92.74 20.72,92.64 20.72,90.09 20.82,89.99 21.02,89.99 21.12,90.09 21.12,90.22 21.22,90.32 22.25,90.32 22.35,90.42 22.35,90.62 22.25,90.72 21.22,90.72 21.12,90.82 21.12,91.02 21.22,91.12 22.25,91.12 22.35,91.22 22.35,91.42 22.25,91.52 21.22,91.52 21.12,91.62 21.12,93.51 23,95.4 23,105.57 21.61,106.97 20.13,106.97 18.54,108.55 17.3,108.55 13.97,111.89 13.97,113.19 13.55,113.61 13.55,117.22 13.29,117.47 10.54,117.47 10.41,117.6 10.41,117.87 10.51,117.97 13.36,117.97 13.46,118.07 13.46,118.27 13.36,118.37 10.51,118.37 10.41,118.47 10.41,118.67 10.51,118.77 13.36,118.77 13.46,118.87 13.46,119.07 13.36,119.17 10.51,119.17 10.41,119.27 10.41,119.47 10.51,119.57 13.36,119.57 13.46,119.67 13.46,119.87 13.36,119.97 9.87,119.97 9.77,120.07 9.77,120.27 9.87,120.37 13.36,120.37 13.46,120.47 13.46,120.67 13.36,120.77 10.51,120.77 10.41,120.87 10.41,121.09 10.51,121.19 11.83,121.19 11.93,121.29 11.93,121.49 11.83,121.59 10.51,121.59 10.41,121.69 10.41,132.21 11.05,132.84 18.01,132.84 v1(19.05,133.88)
EC_SPI_MISO: length 112.9
  TOP w0.1: v1(17.14,134.11) 18.38,135.35 18.38,136.41 17.9,136.89 17.9,138.05 EU9E1.2 R9E30.2 15.62,138.3 15.36,138.05 13.97,138.05 13.39,137.48 13.39,136.21 J9E9.10
  BOTTOM w0.1: v1(17.14,134.11) 15.4,134.11 14.83,133.54 10,133.54 9.56,133.09 8.38,133.09 8.12,132.84 8.12,131.89 8.22,131.79 8.79,131.79 8.89,131.69 8.89,131.49 8.79,131.39 8.22,131.39 8.12,131.29 8.12,130.96 8.22,130.86 8.79,130.86 8.89,130.76 8.89,130.56 8.79,130.46 8.22,130.46 8.12,130.36 8.12,130.16 8.22,130.06 8.79,130.06 8.89,129.96 8.89,129.76 8.79,129.66 8.22,129.66 8.12,129.56 8.12,129.36 8.22,129.26 8.79,129.26 8.89,129.16 8.89,128.96 8.79,128.86 8.22,128.86 8.12,128.76 8.12,128.56 8.22,128.46 8.79,128.46 8.89,128.36 8.89,128.16 8.79,128.06 8.22,128.06 8.12,127.96 8.12,127.76 8.22,127.66 8.79,127.66 8.89,127.56 8.89,127.36 8.79,127.26 8.22,127.26 8.12,127.16 8.12,126.96 8.22,126.86 8.79,126.86 8.89,126.76 8.89,126.56 8.79,126.46 8.22,126.46 8.12,126.36 8.12,126.16 8.22,126.06 8.79,126.06 8.89,125.96 8.89,125.76 8.79,125.66 8.22,125.66 8.12,125.56 8.12,125.36 8.22,125.26 8.79,125.26 8.89,125.16 8.89,124.96 8.79,124.86 8.22,124.86 8.12,124.76 8.12,124.56 8.22,124.46 8.79,124.46 8.89,124.36 8.89,124.16 8.79,124.06 8.22,124.06 8.12,123.96 8.12,123.76 8.22,123.66 8.79,123.66 8.89,123.56 8.89,123.36 8.79,123.26 8.22,123.26 8.12,123.16 8.12,122.96 8.22,122.86 8.79,122.86 8.89,122.76 8.89,122.56 8.79,122.46 8.22,122.46 8.12,122.36 8.12,122.16 8.22,122.06 8.79,122.06 8.89,121.96 8.89,121.76 8.79,121.66 8.22,121.66 8.12,121.56 8.12,121.36 8.22,121.26 8.79,121.26 8.89,121.16 8.89,120.96 8.79,120.86 8.22,120.86 8.12,120.76 8.12,120.52 9.52,119.12 9.52,116.65 10.66,115.51 10.66,115.37 9.88,114.59 9.88,114.45 10.02,114.31 10.16,114.31 10.94,115.09 11.08,115.09 11.22,114.94 11.22,114.8 10.44,114.02 10.44,113.88 10.59,113.74 10.73,113.74 11.51,114.52 11.65,114.52 11.79,114.38 11.79,114.24 11.01,113.46 11.01,113.32 11.15,113.18 11.29,113.18 12.07,113.95 12.21,113.95 13.27,112.9 13.27,110.43 18.16,105.54 20.44,105.54 20.95,105.03 20.95,97.92 16.76,93.72 16.76,86.49 15.64,85.37 R9U5.2
EC_SPI_MOSI: length 107
  TOP w0.1: EU9E1.5 24.95,135.7 22.09,132.84 19.68,132.84 v1(19.43,133.09) 19.11,133.41 13.14,133.41 8.25,128.52 J9E9.12
  BOTTOM w0.1: v1(19.43,133.09) 18.75,133.09 18.15,132.49 11.19,132.49 10.76,132.06 10.76,124.93 13.14,122.55 13.14,122.41 12.62,121.88 12.62,121.74 12.76,121.6 12.9,121.6 13.42,122.12 13.56,122.12 13.9,121.79 13.9,113.86 14,113.76 14.2,113.76 14.3,113.86 14.3,121.56 14.4,121.66 14.6,121.66 14.7,121.56 14.7,111.65 17.44,108.9 18.69,108.9 20.27,107.32 21.75,107.32 23.35,105.72 23.35,94.87 22.86,94.37 22.86,89.08 23.65,88.29 23.65,85.95 22.86,85.16 22.86,83.89 R9U11.2
EC_SPI_OE_N: length 48.6
  TOP w0.1: v1(77.39,86.82) 77.52,86.95 77.52,89.13 v1(77.62,89.23) 78.33,89.23 80.1,91 80.64,91 81.26,91.62 83.38,91.62 83.56,91.79 R7G2.1 R7G1.1 ; v1(77.85,82.42) v1(77.85,80.9) 77.21,80.26 76.76,80.26 v1(76.07,79.57)
  BOTTOM w0.1: 74.67,86.17 75.37,86.17 77.62,88.42 v1(77.62,89.23) ; U7U2.10 v1(76.07,79.57) ; v1(77.62,89.23) 76.53,89.23 75.42,88.12 U7U1.13 72.78,88.12 72.77,88.14 R7U31.2 R7U32.2 ; v1(77.62,89.23) 78.4,89.23 78.86,88.77 U7U1.1 ; v1(77.39,86.82) U7U1.4 81.19,86.82 81.91,86.1 81.91,85.6 82.42,85.09 82.42,84.59 82.22,84.4 79.82,84.4 v1(77.85,82.42) ; 74.67,81.52 75.69,81.52 75.83,81.38 77.14,81.38 77.62,80.9 v1(77.85,80.9) 78.53,80.22 U7U2.4
EC_SPI_OE_RC_N: length 2.5
  TOP w0.1: Q7G1.1 C7G1.1 R7G1.2
EC_SPI_SCLK: length 113.5
  TOP w0.1: EU9E1.6 25.55,137.41 25.75,137.21 25.75,135.74 22.38,132.37 v1(20.57,132.37) 19.43,132.37 18.86,132.93 13.55,132.93 9.65,129.03 9.65,123.06 7.11,120.52 5.46,120.52 4.69,121.28 4.69,130.05 J9E9.7
  BOTTOM w0.1: v1(20.57,132.37) 21.24,131.7 21.24,130.36 22.13,129.47 22.13,124.27 19.39,121.54 17.01,121.54 15.9,120.43 15.9,117.37 15.8,117.27 15.27,117.27 15.17,117.17 15.17,116.97 15.27,116.87 15.8,116.87 15.9,116.77 15.9,116.57 15.8,116.47 15.27,116.47 15.17,116.37 15.17,116.17 15.27,116.07 15.8,116.07 15.9,115.97 15.9,115.77 15.8,115.67 15.27,115.67 15.17,115.57 15.17,115.37 15.27,115.27 15.8,115.27 15.9,115.17 15.9,114.97 15.8,114.87 15.27,114.87 15.17,114.77 15.17,114.57 15.27,114.47 15.8,114.47 15.9,114.37 15.9,114.17 15.8,114.07 15.27,114.07 15.17,113.97 15.17,113.77 15.27,113.67 15.8,113.67 15.9,113.57 15.9,113.37 15.8,113.27 15.27,113.27 15.17,113.17 15.17,112.97 15.27,112.87 15.8,112.87 15.9,112.77 15.9,112.57 15.8,112.47 15.27,112.47 15.17,112.37 15.17,111.85 17.64,109.38 18.88,109.38 20.47,107.79 21.95,107.79 23.83,105.91 23.83,94.67 23.33,94.17 23.33,89.28 24.13,88.48 24.13,85.76 23.33,84.96 23.33,83.23 R9U10.2
EC_SPI_WP_N: length 124
  TOP w0.1: v1(17.14,134.87) 18.03,135.76 18.03,136.27 17.27,137.03 EU9E1.3 R9E31.2
  BOTTOM w0.1: v1(17.14,134.87) 17.65,134.36 17.65,133.73 17.51,133.6 15.38,133.6 14.97,133.19 10.25,133.19 9.81,132.74 8.79,132.74 8.63,132.59 8.63,132.33 8.76,132.21 9.14,132.21 9.27,132.08 9.27,131.94 9.37,131.84 9.8,131.84 9.9,131.74 9.9,131.54 9.8,131.44 9.37,131.44 9.27,131.34 9.27,131.14 9.37,131.04 9.8,131.04 9.9,130.94 9.9,130.74 9.8,130.64 9.37,130.64 9.27,130.54 9.27,130.34 9.37,130.24 9.8,130.24 9.9,130.14 9.9,129.94 9.8,129.84 9.37,129.84 9.27,129.74 9.27,129.54 9.37,129.44 9.8,129.44 9.9,129.34 9.9,129.14 9.8,129.04 9.37,129.04 9.27,128.94 9.27,128.74 9.37,128.64 9.8,128.64 9.9,128.54 9.9,128.34 9.8,128.24 9.37,128.24 9.27,128.14 9.27,127.94 9.37,127.84 9.8,127.84 9.9,127.74 9.9,127.54 9.8,127.44 9.37,127.44 9.27,127.34 9.27,127.14 9.37,127.04 9.8,127.04 9.9,126.94 9.9,126.74 9.8,126.64 9.37,126.64 9.27,126.54 9.27,126.34 9.37,126.24 9.8,126.24 9.9,126.14 9.9,125.94 9.8,125.84 9.37,125.84 9.27,125.74 9.27,125.54 9.37,125.44 9.8,125.44 9.9,125.34 9.9,125.14 9.8,125.04 9.37,125.04 9.27,124.94 9.27,124.74 9.37,124.64 9.8,124.64 9.9,124.54 9.9,124.34 9.8,124.24 9.37,124.24 9.27,124.14 9.27,123.94 9.37,123.84 9.8,123.84 9.9,123.74 9.9,123.54 9.8,123.44 9.37,123.44 9.27,123.34 9.27,123.14 9.37,123.04 9.8,123.04 9.9,122.94 9.9,122.74 9.8,122.64 9.37,122.64 9.27,122.54 9.27,122.34 9.37,122.24 9.8,122.24 9.9,122.14 9.9,121.94 9.8,121.84 9.37,121.84 9.27,121.74 9.27,121.54 9.37,121.44 9.8,121.44 9.9,121.34 9.9,121.14 9.8,121.04 9.37,121.04 9.27,120.94 9.27,120.01 9.87,119.41 9.87,116.79 10.03,116.63 10.17,116.63 10.45,116.91 10.59,116.91 10.73,116.77 10.73,116.63 10.45,116.35 10.45,116.21 10.6,116.07 10.74,116.07 11.4,116.72 11.54,116.72 11.68,116.58 11.68,116.44 11.02,115.78 11.02,115.64 11.16,115.5 11.3,115.5 11.9,116.1 12.04,116.1 12.18,115.95 12.18,115.81 11.59,115.22 11.59,115.08 11.73,114.93 11.87,114.93 12.15,115.21 12.29,115.21 12.43,115.07 12.43,114.93 12.15,114.65 12.15,114.51 12.29,114.37 12.43,114.37 12.71,114.65 12.85,114.65 13,114.51 13,114.36 12.72,114.09 12.72,113.94 13.62,113.05 13.62,110.71 13.78,110.55 13.92,110.55 14.29,110.92 14.43,110.92 14.57,110.78 14.57,110.64 14.2,110.27 14.2,110.13 14.34,109.99 14.48,109.99 14.86,110.36 15,110.36 15.14,110.22 15.14,110.08 14.77,109.7 14.77,109.56 14.91,109.42 15.05,109.42 15.42,109.79 15.56,109.79 15.7,109.65 15.7,109.51 15.33,109.14 15.33,109 16.63,107.69 18.41,107.69 19.84,106.27 21.16,106.27 22.3,105.13 22.3,96.83 18.82,93.34 18.82,88.35 18.72,88.25 18.51,88.25 18.41,88.15 18.41,87.95 18.51,87.85 18.72,87.85 18.82,87.75 18.82,87.55 18.72,87.45 18.13,87.45 18.03,87.35 18.03,87.15 18.13,87.05 18.72,87.05 18.82,86.95 18.82,85.83 18.92,85.73 19.12,85.73 19.22,85.83 19.22,93.18 21.98,95.94 22.12,95.94 22.26,95.8 22.26,95.66 19.62,93.01 19.62,85.65 18.18,84.21 R9U4.2
EC_SUS_CLK: length 43.5
  TOP w0.1: v1(35.53,103.38) 35.53,103.73 35.56,103.76 R8F42.1 R8F39.1 ; v1(67.05,112.9) 67.05,114.93 R7F17.2
  BOTTOM w0.1: v1(35.53,103.38) 38.55,103.38 41.57,106.4 45.55,106.4 50.72,111.56 65.71,111.56 v1(67.05,112.9)
EC_SUS_CLK_AIC: length 199
  TOP w0.1: R8F39.2 v1(37.21,105.03) ; J6J2.236 v1(148.93,16.97)
  LAY3 w0.1: v1(148.93,16.97) 149.4,17.44 149.4,24.38 143.3,30.48 131.69,30.48 131.54,30.32 129.81,30.32 128.18,31.95 119.88,31.95 118.46,33.37 116.28,33.37 115.13,34.52 109.22,34.52 108.85,34.16 107.06,34.16 106.15,35.07 68.19,35.07 67.95,35.31 65.37,35.31 61.85,38.82 60.21,38.82 59.19,39.85 55.45,39.85 52.98,42.32 50.81,42.32 49.8,43.34 47.64,43.34 47.07,42.77 45.72,42.77 45.63,42.85 42.58,42.85 41.8,42.07 40.21,42.07 39.65,42.63 39.65,44.59 46.25,51.2 46.25,53.83 45.49,54.59 45.49,57.16 41.69,60.96 39.87,60.96 39.62,61.21 39.62,64.68 37.56,66.74 37.56,68.09 37.36,68.29 37.36,77.7 36.01,79.05 36.01,89.09 36.19,89.28 36.19,93.98 36.06,94.11 36.06,103.88 v1(37.21,105.03)
EC_THERM_STRAP: length 34.5
  TOP w0.1: J9E7.2 10.03,142.62 10.03,139.73 10.79,138.96 12.6,138.96 13.33,139.7 13.33,140.59 R9E28.1 15.24,142.49 17.78,142.49 19.81,144.52 v1(22.47,144.52) ; v1(22.73,147.19) 22.73,147.7 23.62,148.59 23.62,149.66 22.6,150.67 22.6,153.16 24.53,155.09 U8E3.11
  LAY6 w0.125: v1(22.73,147.19) 22.47,146.94 v1(22.47,144.52)
EC_THERM_STRAP_PU: length 10.1
  TOP w0.1: R9E24.2 14.09,146.3 7.62,146.3 J9E7.1
EC_UART_CTS_N: length 207
  TOP w0.1: v1(63.75,75.89) 63.28,75.43 R7G28.2 ; U8F6.108 31.32,96.69 30.98,97.03 v1(30.98,97.15) ; v1(151.63,11.17) 151.38,11.43 150.62,11.43 150.36,11.17 150.36,9.14 R5J17.2
  LAY3 w0.1: v1(151.63,11.17) 151.89,11.17 152.7,11.98 152.7,27.59 146.61,33.67 121.42,33.67 118.35,36.74 108.65,36.74 107.79,37.59 103.53,37.59 102.5,38.62 92.59,38.62 v1(91.56,37.59)
  LAY6 w0.125: v1(63.75,75.89) 63.75,76.58 62.46,77.87 62.46,81.81 62.1,82.17 62.1,91.69 61.97,91.82 61.97,94.97 62.63,95.63 65.78,95.63 v1(66.99,96.84)
  LAY8 w0.1: v1(91.56,37.59) 90.8,38.35 90.8,41.21 82.57,49.43 82.57,60.86 70.83,72.61 69.69,72.61 68.48,73.81 65.83,73.81 v1(63.75,75.89)
  BOTTOM w0.1: v1(30.98,97.15) 31.49,96.65 34.03,96.65 36.83,93.85 38.06,93.85 38.27,93.64 43.81,93.64 44.01,93.85 46.48,96.31 63.68,96.31 64.2,96.84 v1(66.99,96.84)
EC_UART_CTS_TTK: length 2.9
  TOP w0.17: R7G28.1 J7G1.4
EC_UART_RTS_N: length 206
  TOP w0.1: U8F6.107 31.84,96.29 v1(31.75,96.19) ; R7G29.2 v1(64.55,75.89) ; R5J15.2 148.2,8.63 148.94,7.9 150.32,7.9 150.82,8.39 150.82,9.6 152.14,10.92 152.14,11.68 151,12.83 v1(151,12.95)
  LAY3 w0.1: v1(93.19,37.46) 93.66,37.94 102.22,37.94 103.24,36.91 107.51,36.91 108.36,36.06 118.07,36.06 121.14,32.99 146.32,32.99 152.01,27.3 152.01,13.97 v1(151,12.95)
  LAY6 w0.125: v1(64.55,75.89) 64.55,76.29 62.71,78.12 62.71,81.91 62.35,82.27 62.35,88.32 63.09,89.06 63.09,91.06 62.23,91.92 62.23,94.87 62.73,95.38 66.23,95.38 v1(66.99,96.14)
  LAY8 w0.1: v1(64.55,75.89) 66.41,74.04 68.58,74.04 69.78,72.83 70.92,72.83 82.8,60.96 82.8,49.53 93.19,39.14 v1(93.19,37.46)
  BOTTOM w0.1: v1(31.75,96.19) 31.82,96.19 33.52,94.49 35.87,94.49 36.73,93.62 37.97,93.62 38.25,93.34 44.19,93.34 46.93,96.09 66.94,96.09 v1(66.99,96.14)
EC_UART_RTS_TTK: length 2.9
  TOP w0.17: R7G29.1 J7G1.6
EC_UART_RX: length 167.1
  TOP w0.1: U8F6.80 25.22,92.4 v1(25.78,92.96) ; R9B15.2 v1(13.58,243.97)
  LAY6 w0.125: v1(22.86,185.04) 23.36,184.53 23.36,180.85 24.38,179.83 24.38,168.83 24.88,168.33 24.88,165.97 25.38,165.47 25.38,158.25 24.99,157.86 24.99,132.44 26.41,131.02 26.41,124.2 26.03,123.82 26.03,114.17 24.63,112.77 24.63,109.88 23.48,108.73 23.48,95.25 v1(25.78,92.96)
  BOTTOM w0.1: v1(13.58,243.97) 13.05,243.43 13.05,242.47 11.14,240.57 11.14,230.24 11.83,229.55 11.83,217.13 9.87,215.17 9.87,212.12 11.12,210.87 11.12,205.88 10.59,205.35 10.59,204.6 11.12,204.07 11.12,200.53 11.76,199.89 11.76,194.26 20.99,185.04 v1(22.86,185.04)
EC_UART_RX_AIC: length 410.5
  TOP w0.1: J6J2.212 v1(145.12,16.97) ; 13.58,246.51 v1(13.58,247.27)
  LAY3 w0.1: v1(145.12,16.97) 145.26,16.97 149.5,12.73 149.5,10.76 148.77,10.03 144.01,10.03 142.72,11.33 133.02,11.33 130.68,8.99 128.53,8.99 128.06,8.52 128.06,6.7 127.22,5.85 115.75,5.85 114.7,6.9 110.13,6.9 108.04,8.99 106.42,8.99 105.04,10.36 102.13,10.36 98.47,6.7 83.21,6.7 82.29,5.78 71.88,5.78 71.34,6.32 69.85,6.32 65.96,10.21 41.22,10.21 40.84,10.59 17.67,10.59 16.09,12.16 14.82,12.16 12.44,14.54 12.44,17.27 8.81,20.9 8.81,33.29 7.71,34.39 4.03,34.39 2.38,36.03 2.38,106.2 4.79,108.61 9.36,108.61 10.33,109.58 10.33,171.13 3.24,178.22 3.24,213.11 11.68,221.55 11.68,230.56 13.05,231.93 13.05,246.73 v1(13.58,247.27)
EC_UART_RX_HDR: length 9.8
  TOP w0.1: R9B25.1 13.33,239.77 13.08,239.52 13.08,239.14 12.7,238.76 8.12,238.76 7.49,238.12 7.49,237.74 7.74,237.49 J9B6.1
EC_UART_RX_R: length 5.4
  TOP w0.1: R9B15.1 13.05,245.08 13.05,242.09 R9B21.2 R9B25.2
EC_UART_RX_TTK: length 243.8
  TOP w0.1: R9B21.1 v1(13.58,243.2) ; v1(66.29,73.33) 65.82,72.86 J7G1.8
  LAY5 w0.125: v1(13.58,243.2) 14.22,242.57 14.22,235.18 16.76,232.64 16.76,218.59 18.29,217.06 18.29,209.27 16.5,207.49 16.5,200.25 17.65,199.11 17.65,179.88 18.36,179.17 18.36,169.98 18.54,169.8 18.54,168.58 17.65,167.69 17.65,160.19 25,152.84 25,131.7 26.23,130.46 26.23,124.68 25.76,124.21 25.76,115.12 27.69,113.2 27.69,111.77 26.79,110.87 26.79,109.75 25.9,108.86 25.9,106.68 26.42,106.17 26.42,102.32 26.27,102.17 26.27,91.46 25.4,90.59 25.4,84.08 25.01,83.69 25.01,80.61 25.65,79.96 25.65,75.87 23.75,73.97 23.75,66.08 27.89,61.94 32.73,61.94 33.42,61.25 37.44,61.25 40.3,64.12 43.95,64.12 44.7,64.87 44.7,66.85 45.01,67.16 45.44,67.16 45.97,67.69 45.97,69.27 46.79,70.09 50.96,70.09 52.11,71.25 54.48,71.25 55.88,69.84 56.52,69.84 57.06,70.38 58.74,70.38 61.69,73.33 v1(66.29,73.33)
EC_UART_TX: length 171
  TOP w0.1: v1(25.78,92.07) 25.62,91.92 U8F6.81 25.62,90.01 24,88.39 R9G18.2 R8G20.2 ; R9B12.2 v1(12.31,243.97)
  LAY6 w0.125: v1(22.86,184.28) 22.86,178.81 24.13,177.54 24.13,168.73 24.63,168.23 24.63,165.87 25.12,165.37 25.12,158.36 24.73,157.97 24.73,132.34 26.16,130.91 26.16,124.31 25.78,123.93 25.78,114.28 24.38,112.88 24.38,109.98 23.23,108.83 23.23,95.15 25.27,93.11 25.27,92.58 v1(25.78,92.07)
  BOTTOM w0.1: v1(12.31,243.97) 12.82,243.46 12.82,242.57 10.92,240.66 10.92,230.15 11.61,229.46 11.61,217.22 9.65,215.26 9.65,212.02 10.89,210.77 10.89,205.98 10.36,205.44 10.36,204.51 10.89,203.98 10.89,200.43 11.53,199.79 11.53,194.17 21.43,184.28 v1(22.86,184.28)
EC_UART_TX_AIC: length 410.7
  TOP w0.1: 12.31,246.51 v1(12.31,247.27) ; J6J2.220 v1(146.39,16.97)
  LAY3 w0.1: v1(12.31,247.27) 12.82,246.76 12.82,232.03 11.45,230.66 11.45,221.64 3.01,213.2 3.01,178.13 10.11,171.03 10.11,109.68 9.27,108.84 4.69,108.84 2.15,106.3 2.15,35.94 3.93,34.16 7.62,34.16 8.58,33.2 8.58,20.81 12.22,17.17 12.22,14.45 14.73,11.94 16,11.94 17.57,10.36 40.75,10.36 41.12,9.98 65.86,9.98 69.75,6.09 71.24,6.09 71.78,5.56 82.39,5.56 83.31,6.48 98.56,6.48 102.22,10.14 104.95,10.14 106.32,8.76 107.95,8.76 110.03,6.68 114.61,6.68 115.66,5.63 127.32,5.63 128.29,6.6 128.29,8.43 128.62,8.76 130.77,8.76 133.11,11.1 142.62,11.1 143.92,9.8 148.87,9.8 149.73,10.67 149.73,12.83 146.39,16.17 v1(146.39,16.97)
EC_UART_TX_HDR: length 9.6
  TOP w0.1: R9B24.1 12.59,239.77 12.84,239.52 12.84,239.23 12.6,238.99 8.03,238.99 7.26,238.22 7.26,237.77 6.98,237.49 J9B5.1
EC_UART_TX_R: length 5.4
  TOP w0.1: R9B24.2 R9B20.2 12.82,242.06 12.82,245.11 R9B13.1
EC_UART_TX_TTK: length 244.9
  TOP w0.1: v1(67.31,73.33) 67.09,73.12 J7G1.10 ; R9B20.1 v1(12.31,243.2)
  LAY5 w0.125: v1(12.31,243.2) 12.31,236.73 16.51,232.54 16.51,218.49 17.14,217.85 17.14,208.91 16.25,208.02 16.25,200.15 17.01,199.39 17.01,179.96 16.1,179.04 16.1,169.89 16.76,169.23 16.76,168.53 16.47,168.24 16.47,160.3 21.2,155.56 21.2,153.94 24.75,150.4 24.75,131.59 25.98,130.36 25.98,124.78 25.51,124.31 25.51,114.56 26.54,113.54 26.54,109.85 24.76,108.08 24.76,105.91 26.16,104.51 26.16,102.42 25.65,101.91 25.65,96.77 25.27,96.39 25.27,90.82 25.15,90.7 25.15,84.18 24.76,83.8 24.76,80.5 25.4,79.86 25.4,75.97 23.5,74.07 23.5,65.97 27.78,61.69 32.63,61.69 33.32,61 37.54,61 40.41,63.87 44.05,63.87 45.46,65.27 45.46,65.99 46.22,66.75 46.22,69.17 46.89,69.84 51.06,69.84 52.21,70.99 54.37,70.99 55.78,69.59 56.62,69.59 57.17,70.13 58.85,70.13 60.98,72.26 66.24,72.26 v1(67.31,73.33)
EC_V5S_MONITOR: length 5.6
  TOP w0.1: R6J18.1 R6J29.2 123.69,13.24 J6J2.78
EC_WAKE_CLK_R: length 217.9
  TOP w0.1: U8F6.85 27.22,93.13 v1(27.81,93.72) ; R9F1.2 21.71,121.54 R8F13.2 23.74,121.92 24.13,122.3 25.03,122.3 25.83,123.09 27.21,123.09 v1(27.68,123.57) ; J6J2.30 v1(114.88,14.43)
  LAY3 w0.1: v1(27.81,93.72) 26.79,92.71 26.79,92.43 25.68,91.31 23.03,91.31 21.84,90.12 21.84,88.26 22.7,87.4 22.7,86.74 22.6,86.64 22.6,85.95 22.7,85.85 22.7,84.81 19.87,81.97 19.87,74.21 17.62,71.96 17.62,62.36 14.03,58.77 14.03,52.26 15.62,50.67 15.62,49.66 16.85,48.43 16.85,45.79 17.14,45.5 20.16,45.5 21.08,44.58 21.08,42.54 22.79,40.83 22.79,35.92 26.29,32.42 29.74,32.42 35.11,27.05 47.02,27.05 47.31,27.34 50.47,27.34 50.76,27.05 53.71,27.05 57.04,23.71 59.15,23.71 60.86,22 62.02,22 62.5,21.52 64.48,21.52 64.72,21.27 75.84,21.27 76.19,21.62 81.27,21.62 82.19,22.54 87.94,22.54 88.68,21.81 97.06,21.81 98.38,20.49 98.94,20.49 99.55,19.87 100.61,19.87 101.12,19.36 107.28,19.36 110.7,15.94 112.7,15.94 114.21,14.43 v1(114.88,14.43)
  LAY5 w0.125: v1(27.81,93.72) 27.32,94.21 27.32,95.04 28.19,95.91 28.19,105.41 28.57,105.79 28.57,109.98 28.96,110.37 28.96,111.37 28.71,111.62 28.71,113.62 26.77,115.57 26.77,122.65 v1(27.68,123.57)
ECDBG_CLK_HDR: length 13
  TOP w0.1: J9F5.5 5.96,96.65 5.96,99.53 6.82,100.39 6.82,101.53 8,102.7 R9F30.2 8.5,103.25 9.52,103.25 10.41,104.14 R9F28.1
ECDBG_DATA_HDR: length 10.7
  TOP w0.1: J9F5.4 4.95,99.19 6.35,100.58 6.35,101.73 7.11,102.49 7.11,103.88 R9F27.2 8.5,105.28 9.9,105.28 R9F24.1
ECDBG_ICSP_CLK: length 45.6
  TOP w0.1: U8F6.101 31.67,93.89 v1(31.07,94.49) ; R9F28.2 11.93,105.41 11.93,107.52 15.36,110.95 15.36,113.54 17.14,115.31 v1(19.93,115.31)
  BOTTOM w0.1: v1(19.93,115.31) 20.57,115.31 23.87,112.01 23.87,109.85 26.12,107.6 26.12,96.33 27.04,95.42 30.14,95.42 v1(31.07,94.49)
ECDBG_ICSP_DAT: length 47
  TOP w0.1: v1(31.84,94.49) 32.03,94.29 U8F6.102 ; v1(19.93,116.08) 19.81,115.95 17.28,115.95 14.83,113.5 14.83,111.09 11.3,107.56 R9F24.2
  BOTTOM w0.1: v1(31.84,94.49) 31.33,93.98 30.6,93.98 30.35,94.23 27.55,94.23 25.65,96.13 25.65,106.6 22.33,109.92 22.33,111.78 20.57,113.54 20.06,113.54 19.43,114.17 19.43,115.57 v1(19.93,116.08)
ECDBG_ICSP_MCLR: length 72.5
  TOP w0.1: R9F23.2 8,106.68 R9F21.2 7.11,107.69 7.11,111 4.54,113.56 4.54,115.67 5.33,116.46 10.54,116.46 11.37,117.29 14.28,117.29 17.19,120.21 19.4,120.21 22.51,123.32 25.38,123.32 25.63,123.57 v1(26.97,123.57) ; v1(27.81,92.2) 28.02,91.99 U8F6.87
  LAY5 w0.125: v1(26.97,123.57) 26.27,122.87 26.27,115.36 28.19,113.43 28.19,111.51 27.68,111 27.68,110.11 27.94,109.86 27.94,106.17 26.92,105.15 26.92,101.98 26.77,101.83 26.77,93.24 v1(27.81,92.2)
ECDBG_MCLR_HDR: length 3
  TOP w0.1: J9F5.1 R9F23.1
EDP_ALS_INT_R_N: length 545.5
  TOP w0.1: v1(293.24,69.59) 292.22,70.61 288.67,70.61 288.07,70.02 287.35,70.02 286,71.37 R1D2.2 283.71,72.77 J1D2.2 ; v1(106.17,100.84) 106.96,101.63 106.96,102.23 106.8,102.39 106.8,104.01 106.29,104.52 ; J1B2.43 300.39,247.61 300.73,247.27 300.73,246.38 301.62,245.49 302.51,245.49 303.4,244.6 303.4,134.62 301.87,133.09 295.91,133.09 292.98,130.17 292.98,124.71 296.79,120.9 298.7,120.9 v1(300.35,119.25)
  LAY5 w0.125: v1(294.64,62.99) 294.64,62.74 293.75,61.85 288.41,61.85 284.98,58.42 282.26,58.42 281.11,57.26 281.11,55.41 275.78,50.08 273.52,50.08 273.26,50.34 254.31,50.34 251.85,47.88 234.51,47.88 232.78,46.14 219.94,46.14 216.15,49.94 216.15,51.71 214.36,53.5 212.58,53.5 210.93,55.15 202.96,55.15 201.8,54 201.8,53.57 194.83,46.6 186.03,46.6 183.71,44.29 170.79,44.29 153.83,27.33 150.64,27.33 149.94,26.64 148.25,26.64 147.29,27.59 138.28,27.59 136.52,25.83 136.52,21.74 131.95,17.17 131.95,16.89 131.31,16.25 121.03,16.25 119.38,17.91 117.98,17.91 117.85,18.03 110.71,18.03 109.92,17.24 107.37,17.24 v1(106.73,16.6) ; v1(293.24,69.59) 297.17,73.52 297.17,80.2 301.12,84.16 301.12,93.44 301.83,94.15 301.83,105.1 300.86,106.07 300.86,117.35 300.35,117.85 v1(300.35,119.25)
  LAY6 w0.125: v1(106.17,100.84) 105.66,100.32 105.66,97.29 106.67,96.27 106.67,82.14 107.59,81.22 111.79,81.22 113.02,79.99 113.02,79.14 112.26,78.38 112.26,77.88 116.83,73.31 116.83,59.87 119.99,56.72 119.99,44.98 120.65,44.32 120.65,39.62 116.58,35.56 116.58,34.8 116.07,34.29 114.65,34.29 113,32.64 113,27.92 112.64,27.56 112.64,24.67 106.42,18.44 106.42,16.91 v1(106.73,16.6)
  BOTTOM w0.1: v1(293.24,69.59) 295.14,67.69 295.14,63.5 v1(294.64,62.99)
EDP_C_TX0_DN: length 1.9
  TOP w0.1: C1B14.2 293.18,237.56 294.29,237.56 R1B30.1
EDP_C_TX0_DP: length 1.9
  TOP w0.1: C1B13.2 293.22,237.76 294.4,237.76 R1B27.2
EDP_C_TX1_DN: length 1.9
  TOP w0.1: R1B33.1 294.29,235.78 293.18,235.78 C1B17.2
EDP_C_TX1_DP: length 1.9
  TOP w0.1: C1B15.2 293.22,235.98 294.4,235.98 R1B32.2
EDP_C_TX2_DN: length 1.9
  TOP w0.1: C1B19.2 293.18,234 294.29,234 R1B37.1
EDP_C_TX2_DP: length 1.9
  TOP w0.1: R1B35.2 294.4,234.2 293.22,234.2 C1B18.2
EDP_C_TX3_DN: length 1.9
  TOP w0.1: R1B41.1 294.29,232.22 293.18,232.22 C1B21.2
EDP_C_TX3_DP: length 1.9
  TOP w0.1: C1B20.2 293.22,232.42 294.4,232.42 R1B38.2
EDP_D_TX0_DN: length 3
  TOP w0.1: J1B2.23 296.56,237.61 296.43,237.74 296.24,237.74 296.04,237.54 295.35,237.54 R1B30.2
EDP_D_TX0_DP: length 3
  TOP w0.1: R1B27.1 295.27,237.74 295.96,237.74 296.16,237.94 296.44,237.94 296.61,238.11 J1B2.24
EDP_D_TX1_DN: length 3.1
  TOP w0.1: J1B2.20 296.65,236.11 296.5,236.26 296.34,236.26 295.82,235.74 295.32,235.74 R1B33.2
EDP_D_TX1_DP: length 3.1
  TOP w0.1: J1B2.21 296.7,236.61 296.55,236.46 296.26,236.46 295.74,235.94 295.3,235.94 R1B32.1
EDP_D_TX2_DN: length 3.5
  TOP w0.1: R1B37.2 295.32,233.96 295.82,233.96 296.03,234.17 296.03,234.62 296.19,234.78 296.38,234.78 296.55,234.61 J1B2.17
EDP_D_TX2_DP: length 3.5
  TOP w0.1: R1B35.1 295.3,234.16 295.73,234.16 295.83,234.26 295.83,234.7 296.11,234.98 296.39,234.98 296.53,235.11 J1B2.18
EDP_D_TX3_DN: length 3.7
  TOP w0.1: R1B41.2 295.35,232.21 295.83,232.21 296.16,232.53 296.16,233.11 296.29,233.24 296.47,233.24 296.6,233.11 J1B2.14
EDP_D_TX3_DP: length 3.7
  TOP w0.1: R1B38.1 295.27,232.41 295.75,232.41 295.96,232.62 295.96,233.19 296.2,233.44 296.43,233.44 296.6,233.61 J1B2.15
EDP_HPD_PD: length 383.8
  TOP w0.089: U6E1.AN6 v1(97.87,155.98)
  TOP w0.1: v1(301.39,223.14) 302.26,223.14 302.64,222.76 Q1C2.2
  LAY5 w0.125: v1(103.25,258.14) 103.48,257.91 107.52,257.91 110.09,260.48 115.68,260.48 116.1,260.06 122.11,260.06 123.8,261.75 126.34,261.75 130.61,266.02 130.61,266.53 134.01,269.93 134.01,271.32 134.62,271.93 134.62,274.12 139,278.5 141.48,278.5 142.75,277.23 143.93,277.23 146.69,274.47 162.54,274.47 163.57,273.43 176.3,273.43 177.69,274.82 180.21,274.82 180.21,274.83 180.64,274.41 192.75,274.41 197.2,269.96 199.81,269.96 201.29,268.48 201.85,268.48 203.02,267.31 204.21,267.31 204.77,267.87 207.79,267.87 209.89,269.97 219.94,269.97 220.68,269.23 224.63,269.23 226.06,270.65 226.06,272.03 226.56,272.54 228.68,272.54 230.03,273.88 243.29,273.88 244.15,274.74 250.34,274.74 253.45,271.63 272.08,271.63 272.33,271.37 273.36,271.37 274.13,270.6 281.01,270.6 282.12,269.49 297.68,269.49 298.32,268.86 299.59,268.86 300.73,267.71 300.73,266.95 301.37,266.31 301.37,256.25 301.76,255.86 301.76,223.53 301.39,223.16 v1(301.39,223.14)
  BOTTOM w0.089: 97.08,160.98 97.4,160.65 97.4,158.25 98,157.66 98,156.11 v1(97.87,155.98)
  BOTTOM w0.1: v1(103.25,258.14) 103.93,258.14 104.86,257.21 104.86,253.7 103.63,252.47 103.63,251.56 104.64,250.55 104.64,246.54 103.88,245.78 103.88,242.55 98.77,237.45 98.77,233.91 100.67,232.01 100.67,221.94 99.75,221.02 99.75,217.35 98.93,216.53 98.93,212.68 97.24,210.99 97.24,203.99 96.7,203.45 96.7,192.53 95.99,191.82 95.99,185.93 95.08,185.02 95.08,179.92 94.61,179.45 94.61,172.47 96.39,170.69 96.39,165.99 R7P9.1 96.46,165.04 96.46,162.49 97.08,161.87 97.08,160.98
EDP_TX0_DN: length 117
  TOP w0.1: v1(215.84,188.49) 215.95,188.6 215.95,188.87 215.85,188.97 215.41,188.97 J3D1.M14 ; C1B14.1 292.12,237.23 292.22,237.33 292.22,237.57 292.12,237.67 291.29,237.67 291.1,237.48 v1(291.1,237.27)
  LAY6 w0.089: v1(215.84,188.49) 215.94,188.59 216.11,188.59 216.36,188.34 216.36,188.12 216.25,188.01 215.47,188.01 215.31,187.85 215.31,187.4 215.69,187.02 219.87,187.02 220.59,187.74 220.59,197.9 220.9,198.2 220.9,198.75 220.89,198.77 220.89,198.83 220.87,198.84 220.87,198.86
  LAY6 w0.115: 220.87,198.86 220.87,199.36 222.02,200.51 243.1,200.51 247.95,205.36 256.21,205.36 262.03,211.17 263.72,211.17 277.89,225.34 278.86,225.34 279.63,226.11 289.66,226.11 291.08,227.53 291.08,228.6 292.86,230.38 292.86,236.22 291.43,237.64 291.27,237.64 291.1,237.47 v1(291.1,237.27)
EDP_TX0_DP: length 117
  TOP w0.1: C1B13.1 291.71,237.87 291.32,237.87 v1(291.1,238.09) ; v1(216.75,188.49) J3D1.M15
  LAY6 w0.089: v1(216.75,188.49) 216.51,188.49 216.09,188.9 215.66,188.9 215.39,188.63 215.39,188.21 215.11,187.93 215.11,187.31 215.61,186.82 219.96,186.82 220.8,187.65 220.8,197.81 221.1,198.12 221.1,198.86
  LAY6 w0.115: 221.1,198.86 221.1,199.26 222.12,200.28 243.2,200.28 248.05,205.13 256.31,205.13 262.12,210.94 263.82,210.94 277.98,225.11 278.95,225.11 279.72,225.88 289.76,225.88 291.31,227.43 291.31,228.5 293.09,230.28 293.09,236.31 291.53,237.87 291.32,237.87 v1(291.1,238.09)
EDP_TX1_DN: length 109.9
  TOP w0.1: v1(291.1,235.49) 291.33,235.72 291.7,235.72 C1B17.1 ; J3D1.N14 215.84,187.58 v1(215.87,187.58)
  LAY6 w0.089: v1(215.87,187.58) 216.15,187.58 216.63,188.06 216.95,188.06 217.05,188.16 218.61,188.16 218.82,187.96 219.71,187.96 219.98,188.24 219.98,198.63
  LAY6 w0.115: v1(291.1,235.49) 291.4,235.79 291.77,235.79 292.1,235.46 292.1,230.7 290.28,228.88 290.28,227.84 289.28,226.85 279.27,226.85 278.49,226.06 277.57,226.06 263.41,211.91 261.69,211.91 255.88,206.1 247.42,206.1 243.49,202.16 221.51,202.16 219.98,200.63 219.98,198.63
EDP_TX1_DP: length 109.9
  TOP w0.1: v1(216.75,187.58) J3D1.N15 ; v1(291.1,236.31) 291.49,235.92 291.78,235.92 291.97,236.11 C1B15.1
  LAY6 w0.089: v1(216.75,187.58) 217.13,187.96 218.53,187.96 218.73,187.75 219.79,187.75 220.19,188.15 220.19,198.6 220.21,198.63
  LAY6 w0.115: 220.21,198.63 220.21,200.53 221.61,201.93 243.58,201.93 247.52,205.87 255.97,205.87 261.78,211.68 263.51,211.68 277.66,225.83 278.58,225.83 279.37,226.62 289.38,226.62 290.51,227.75 290.51,228.79 292.33,230.61 292.33,235.55 291.86,236.02 291.4,236.02 v1(291.1,236.31)
EDP_TX2_DN: length 107.1
  TOP w0.1: J3D1.L15 216.29,189.57 216.45,189.41 v1(216.75,189.41) ; v1(290.84,233.71) 290.84,233.93 291.03,234.11 292.12,234.11 292.22,234.01 292.22,233.78 292.12,233.68 C1B19.1
  LAY6 w0.089: 217.29,197.67 217.29,197.66 217.31,197.64 217.31,197.58 217.32,197.57 217.32,197.29 217.1,197.07 217.1,189.95 217.01,189.86 216.43,189.86 216.29,189.72 216.29,189.5 216.44,189.36 216.7,189.36 v1(216.75,189.41)
  LAY6 w0.115: 217.29,197.67 217.29,201.24 219.72,203.67 243.92,203.67 247.24,206.98 253.39,206.98 254.76,208.35 254.76,208.53 255.29,209.06 255.29,209.64 258.29,212.65 263.11,212.65 278.05,227.58 288.92,227.58 289.48,228.14 289.48,229.16 291.36,231.04 291.36,233.93 291.28,234.01 291.14,234.01 v1(290.84,233.71)
EDP_TX2_DP: length 107.1
  TOP w0.1: v1(290.84,234.54) 291.07,234.31 291.71,234.31 C1B18.1 ; v1(215.84,189.41) J3D1.L14
  LAY6 w0.089: v1(215.84,189.41) 216.1,189.41 216.53,188.97 216.91,188.97 217.3,189.37 217.3,196.99 217.52,197.21 217.52,197.67
  LAY6 w0.115: v1(290.84,234.54) 291.14,234.24 291.37,234.24 291.59,234.02 291.59,230.94 289.71,229.06 289.71,228.05 289.02,227.35 278.15,227.35 263.21,212.42 258.39,212.42 255.52,209.55 255.52,208.97 254.99,208.44 254.99,208.25 253.49,206.75 247.34,206.75 244.02,203.44 219.82,203.44 217.52,201.14 217.52,197.67
EDP_TX3_DN: length 104.2
  TOP w0.1: v1(214.87,190.32) 214.87,190.37 J3D1.K13 ; C1B21.1 292.12,231.9 292.22,232 292.22,232.24 292.12,232.34 291.03,232.34 290.84,232.15 v1(290.84,231.93)
  LAY6 w0.089: v1(214.87,190.32) 214.87,190.12 214.98,190.02 215.29,190.02 215.4,190.13 215.4,190.85 215.48,190.92 215.48,194.27 215.62,194.41 215.62,195.58
  LAY6 w0.115: v1(290.84,231.93) 290.55,232.23 290.46,232.23 290.32,232.08 290.32,230.76 289.07,229.51 288.38,229.51 286.96,228.09 277.74,228.09 262.81,213.15 257.22,213.15 251.58,207.52 247.01,207.52 243.71,204.21 218.44,204.21 215.26,201.04 215.26,198.7 215.62,198.34 215.62,195.58
EDP_TX3_DP: length 104.2
  TOP w0.1: C1B20.1 291.71,232.54 291.07,232.54 v1(290.84,232.76) ; v1(214.86,189.43) 214.86,189.48 214.48,189.86 J3D1.L13
  LAY6 w0.089: v1(214.86,189.43) 214.45,189.85 214.45,190.5 214.7,190.75 215.02,190.75 215.2,190.93 215.28,191.01 215.28,194.36 215.41,194.5 215.41,195.55 215.39,195.58
  LAY6 w0.115: 215.39,195.58 215.39,198.25 215.03,198.6 215.03,201.13 218.34,204.44 243.61,204.44 246.91,207.75 251.49,207.75 257.12,213.38 262.71,213.38 277.65,228.32 286.86,228.32 288.29,229.74 288.98,229.74 290.09,230.85 290.09,232.18 290.37,232.46 290.55,232.46 v1(290.84,232.76)
EMB_AUXN: length 5.3
  TOP w0.1: J1B2.27 296.47,239.61 296.34,239.48 296.13,239.48 295.96,239.65 295.45,239.65 295.27,239.82 R1B22.2 294.81,239.7 293.95,239.7 C1B11.2
EMB_AUXP: length 5.3
  TOP w0.1: C1B12.2 293.98,239.5 294.79,239.5 R1B23.1 295.27,239.35 295.37,239.45 295.87,239.45 296.04,239.28 296.31,239.28 296.48,239.11 J1B2.26
EMB_HPD: length 14.6
  TOP w0.1: Q1C2.3 300.48,223.2 300.48,230.63 300,231.11 J1B2.10 295.5,231.11 R1B42.1
EMB_VDDEN_D_N: length 7.5
  TOP w0.1: R1C33.2 298.06,217.42 296.54,217.42 295.65,218.31 C1C10.2 294.76,220.6 Q1C1.1
EMB_VDDEN_N: length 10.2
  TOP w0.1: R1C21.2 299.33,219.71 300.73,218.31 Q1C3.3 301.68,217.55 302,217.23 302,215.9 301.24,215.14 300.35,215.14 299.59,215.9 R1C33.1
EN_FET_GLITCH_SLP: length 195.4
  TOP w0.1: v1(59.81,147.57) 59.92,147.47 59.92,141.43 61.14,140.21 61.14,135.49 63.32,133.31 63.32,126.09 65.97,123.44 68.19,123.44 69.5,122.14 Q7F1.3
  LAY5 w0.125: J9E5.1 15.6,46.48 21.59,52.47 21.59,57.45 17.42,61.62 17.42,66.29 15.97,67.74 15.97,71.6 16.25,71.88 16.25,81.53 17.14,82.42 17.14,85.22 16.23,86.12 16.23,92.76 17.04,93.57 17.04,101.84 16.56,102.32 16.56,109.41 15.72,110.25 15.72,117.99 13.04,120.68 13.04,139.02 13.2,139.19 13.2,146.05 12.06,147.19 v1(12.06,147.32)
  BOTTOM w0.1: v1(59.81,147.57) 58.05,147.57 55.96,149.66 54.31,149.66 53.74,149.09 52.91,149.09 52.34,149.66 47.79,149.66 44.08,145.95 37.78,145.95 36.03,147.7 35.93,147.7 34.03,149.6 32.54,149.6 30.99,148.05 21.78,148.05 20.84,148.99 18.08,148.99 17.17,148.08 12.82,148.08 v1(12.06,147.32)
EN_FET_GLITCH_SLP_HDR: length 42
  TOP w0.1: v1(48.51,45.21) 48.51,45.49 48.41,45.59 Q8H4.1 47.11,45.59 47.01,45.49 47.01,44.29 47.11,44.19 47.24,44.19 Q8H6.1 47.37,43.31 47.21,43.31 47.11,43.21 47.11,42.29 Q8H7.1 R8H56.1
  LAY5 w0.125: J9E5.2 20.06,48.64 22.35,48.64 26.41,44.58 30.14,44.58 30.9,43.82 35.92,43.82 36.55,44.45 42.79,44.45 43.05,44.19 45.67,44.19 46.1,44.62 47.92,44.62 v1(48.51,45.21)
EQ_ADDR0: length 3.1
  TOP w0.1: EU2A7.5 259.55,265.33 259.71,265.17 260.85,265.17 R2A45.2 R2A43.1
EXP_A_RX_0_DN: length 89.7
  TOP w0.1: v1(214.01,192.15) J3D1.H12
  BOTTOM w0.089: v1(214.01,192.15) 214.01,192.27 213.74,192.54 213.55,192.54 213.29,192.8 213.29,193.37 213.46,193.54 213.46,194.42 213.54,194.5 213.54,195.14 213.54,195.14
  BOTTOM w0.1: 213.54,195.14 213.54,198.04 212.95,198.63 212.56,198.63 205.65,205.54 204.03,205.54 201.67,207.9 198.12,207.9 191.74,214.28 182.68,214.28 177.36,219.6 173.14,219.6 173.05,219.51 169.84,219.51 168.31,221.03 162.5,221.03 161.16,222.38 159.76,222.38 158.44,223.7 154.98,223.7 150.11,228.57 145.08,228.57 144.77,228.88 144.01,228.88 J5B2.A17
EXP_A_RX_0_DP: length 89.7
  TOP w0.1: v1(214.01,193.06) J3D1.G12
  BOTTOM w0.089: v1(214.01,193.06) 214.01,193.01 213.74,192.73 213.63,192.73 213.48,192.88 213.48,193.29 213.65,193.46 213.65,194.34 213.73,194.43 213.73,195.2 213.74,195.2 213.74,195.21
  BOTTOM w0.1: 213.74,195.21 213.74,198.12 213.03,198.83 212.65,198.83 205.74,205.74 204.11,205.74 201.75,208.1 198.2,208.1 191.82,214.48 182.76,214.48 177.44,219.8 173.06,219.8 172.97,219.71 169.92,219.71 168.4,221.23 162.58,221.23 161.24,222.58 159.84,222.58 158.52,223.9 155.06,223.9 150.19,228.77 145.16,228.77 144.93,229 144.93,229.35 145.23,229.65 J5B2.A16
EXP_A_RX_1_DN: length 85.9
  TOP w0.1: J3D1.G11 v1(213.03,193.98)
  BOTTOM w0.089: v1(213.03,193.98) 212.99,193.98 212.55,194.41 212.55,194.41 212.4,194.56 212.4,196.08 212.61,196.29 212.61,197.09 212.21,197.48 211.94,197.48 210.75,198.68 210.75,199.47 210.57,199.65
  BOTTOM w0.1: 210.57,199.65 205.45,204.78 203.75,204.78 201.42,207.1 195.2,207.1 193.8,208.5 193.8,209.77 190.64,212.93 182.12,212.93 176.81,218.24 174.04,218.24 173.91,218.11 169.2,218.11 168.57,218.75 162.76,218.75 160.65,220.85 159.25,220.85 157.86,222.25 153.64,222.25 151.37,224.51 145.12,224.51 144.88,224.28 144.88,224 145.23,223.65 J5B2.A22
EXP_A_RX_1_DP: length 85.9
  TOP w0.089: J3D1.F11 v1(213.03,194.89)
  BOTTOM w0.089: v1(213.03,194.89) 213.03,194.76 212.82,194.55 212.69,194.55 212.59,194.64 212.59,196.01 212.8,196.21 212.8,197.17 212.29,197.67 212.02,197.67 210.94,198.75 210.94,199.55 210.77,199.73 210.77,199.73 210.73,199.78 210.73,199.78 210.71,199.8
  BOTTOM w0.1: J5B2.A21 144.05,224.38 144.71,224.38 145.03,224.71 151.46,224.71 153.72,222.45 157.94,222.45 159.34,221.05 160.73,221.05 162.84,218.95 168.65,218.95 169.29,218.31 173.83,218.31 173.96,218.44 176.89,218.44 182.2,213.13 190.73,213.13 194,209.86 194,208.59 195.28,207.3 201.51,207.3 203.83,204.98 205.53,204.98 210.71,199.8
EXP_A_RX_2_DN: length 85.3
  TOP w0.1: v1(212.18,192.15) J3D1.H10
  BOTTOM w0.089: v1(212.18,192.15) 212.18,192.17 211.85,192.5 211.85,192.51 211.63,192.72 211.63,194.49 211.74,194.6 211.74,196.09 211.45,196.38 211.45,197.11 209.84,198.72 209.84,199.43 209.22,200.06 209.2,200.06
  BOTTOM w0.1: 209.2,200.06 205.18,204.09 203.45,204.09 201.29,206.25 194.94,206.25 194.12,207.06 193.08,207.06 191.64,208.5 191.64,208.76 188.82,211.58 181.56,211.58 176.25,216.89 174.85,216.89 174.55,216.59 172.75,216.59 172.31,216.15 166.34,216.15 165.89,216.6 162.92,216.6 161.46,218.06 159.89,218.06 157.09,220.85 150.11,220.85 149.77,220.51 145.07,220.51 144.81,220.25 144.81,219.95 145.11,219.65 J5B2.A26
EXP_A_RX_2_DP: length 85.3
  TOP w0.1: J3D1.G10 v1(212.24,193.06)
  BOTTOM w0.089: v1(212.24,193.06) 212.24,192.85 212.09,192.69 211.92,192.69 211.82,192.8 211.82,194.41 211.93,194.52 211.93,196.17 211.64,196.46 211.64,197.19 210.03,198.79 210.03,199.51 209.29,200.26
  BOTTOM w0.1: J5B2.A25 144.05,220.38 144.66,220.38 144.98,220.71 149.69,220.71 150.03,221.05 157.18,221.05 159.97,218.26 161.55,218.26 163.01,216.8 165.97,216.8 166.42,216.35 172.23,216.35 172.66,216.79 174.46,216.79 174.76,217.09 176.33,217.09 181.64,211.78 188.9,211.78 191.84,208.84 191.84,208.59 193.16,207.26 194.21,207.26 195.02,206.45 201.37,206.45 203.53,204.29 205.26,204.29 209.29,200.26
EXP_A_RX_3_DN: length 80
  TOP w0.1: J3D1.G9 210.81,193.52 v1(211.2,193.98)
  BOTTOM w0.089: v1(211.2,193.98) 210.78,194.4 210.78,195.22 210.63,195.37 210.63,196.2 210.78,196.36 210.78,196.94 208.35,199.36 208.35,199.97 208.04,200.28 208.02,200.28
  BOTTOM w0.1: 208.02,200.28 204.97,203.33 203.2,203.33 201.1,205.42 194.75,205.42 193.8,206.37 192.78,206.37 191.13,208.02 189.62,208.02 187.43,210.21 181.01,210.21 177.7,213.53 175.53,213.53 174.35,214.71 160.88,214.71 158.34,217.25 152.73,217.25 151.99,216.51 145.29,216.51 145,216.22 145,215.92 145.27,215.65 J5B2.A30
EXP_A_RX_3_DP: length 80
  TOP w0.1: J3D1.F9 210.81,194.44 v1(211.2,194.89)
  BOTTOM w0.089: 208.11,200.47 208.54,200.04 208.54,199.44 210.97,197.01 210.97,196.28 210.82,196.13 210.82,195.45 211.2,195.06 v1(211.2,194.89)
  BOTTOM w0.1: 208.11,200.47 205.06,203.53 203.28,203.53 201.18,205.62 194.83,205.62 193.88,206.57 192.86,206.57 191.21,208.22 189.7,208.22 187.51,210.41 181.1,210.41 177.78,213.73 175.61,213.73 174.43,214.91 160.96,214.91 158.42,217.45 152.65,217.45 151.91,216.71 145.21,216.71 144.8,216.3 144.8,216.17 144.67,216.04 144.13,216.04 143.78,216.38 J5B2.A29
EXP_A_RX_4_DN: length 82.5
  TOP w0.089: v1(211.27,190.32) J3D1.K9
  BOTTOM w0.089: 207.37,199.76 207.39,199.76 207.77,199.38 207.77,198.99 208.56,198.2 208.56,197.49 209.86,196.18 209.86,191.72 210.7,190.89 v1(211.27,190.32)
  BOTTOM w0.1: 207.37,199.76 204.51,202.62 202.73,202.62 200.83,204.52 191.86,204.52 190.65,205.74 189.99,205.74 186.89,208.84 180.48,208.84 177.94,211.38 177.3,211.38 176.5,212.18 174.97,212.18 174.48,212.67 162.88,212.67 162.56,212.34 160.96,212.34 159.81,211.2 157.86,211.2 157.35,211.71 150.77,211.71 149.58,210.51 145.04,210.51 144.76,210.23 144.76,210 145.11,209.65 J5B2.A36
EXP_A_RX_4_DP: length 82.5
  TOP w0.089: v1(211.27,191.23) J3D1.J9
  BOTTOM w0.089: v1(211.27,191.23) 211.27,190.87 211.18,190.79 211.06,190.79 210.05,191.8 210.05,196.26 208.75,197.57 208.75,198.28 207.96,199.07 207.96,199.45 207.46,199.95
  BOTTOM w0.1: 207.46,199.95 204.59,202.82 202.81,202.82 200.91,204.72 191.95,204.72 190.73,205.94 190.08,205.94 186.98,209.04 180.56,209.04 178.02,211.58 177.38,211.58 176.58,212.38 175.05,212.38 174.56,212.87 162.8,212.87 162.47,212.54 160.87,212.54 159.73,211.4 157.94,211.4 157.43,211.91 150.69,211.91 149.49,210.71 144.96,210.71 144.63,210.38 144.05,210.38 J5B2.A35
EXP_A_RX_5_DN: length 75.6
  TOP w0.1: v1(208.52,195.74) 208.06,195.35 J3D1.E6
  BOTTOM w0.089: 204.4,196.23 206.08,196.23 206.27,196.04 207.09,196.04 207.21,196.17 208.74,196.17 208.96,195.95 208.96,195.83 208.88,195.74 v1(208.52,195.74)
  BOTTOM w0.1: 204.4,196.23 204.22,196.23 202.69,197.76 202.69,198.63 197.53,203.79 194.77,203.79 193.8,202.82 190.98,202.82 186.33,207.47 179.92,207.47 178.4,208.99 177.08,208.99 175.89,210.18 162.02,210.18 161.84,210.36 160.96,210.36 159.63,209.04 156.62,209.04 154.09,206.51 145.12,206.51 144.91,206.3 144.91,206 145.26,205.65 J5B2.A40
EXP_A_RX_5_DP: length 75.6
  TOP w0.1: v1(209.44,195.74) 208.98,195.35 J3D1.E7
  BOTTOM w0.088: 204.4,196.43 204.45,196.43 204.47,196.42
  BOTTOM w0.089: 204.47,196.42 206.16,196.42 206.35,196.23 207.01,196.23 207.14,196.36 208.82,196.36 v1(209.44,195.74)
  BOTTOM w0.1: J5B2.A39 144.05,206.38 144.71,206.38 145.03,206.71 154,206.71 156.53,209.24 159.55,209.24 160.88,210.56 161.92,210.56 162.1,210.38 175.97,210.38 177.16,209.19 178.48,209.19 180.01,207.67 186.41,207.67 191.06,203.02 193.71,203.02 194.68,203.99 197.61,203.99 202.89,198.71 202.89,197.85 204.3,196.43 204.4,196.43
EXP_A_RX_6_DN: length 74.9
  TOP w0.1: v1(206.69,194.96) 207.15,194.44 J3D1.F5
  BOTTOM w0.088: 205.15,195.19 205.17,195.19 205.23,195.19 205.38,195.34 206.26,195.34 206.32,195.4 206.51,195.4
  BOTTOM w0.089: v1(206.69,194.96) 207.08,194.96 207.15,195.03 207.15,195.16 206.91,195.4 206.51,195.4 ; 203.07,195.71 203.08,195.72 203.68,195.72 204.21,195.19 205.15,195.19
  BOTTOM w0.1: 203.07,195.71 202.81,195.71 200.66,197.86 200.66,199.64 198.45,201.85 195.93,201.85 195.47,201.4 190.47,201.4 187.27,204.6 185.97,204.6 184.47,206.1 179.39,206.1 178.62,206.86 177.89,206.86 177.24,207.52 176.53,207.52 176.29,207.75 174.39,207.75 173.55,208.59 170.34,208.59 169.5,207.75 168.7,207.75 168.55,207.9 163.95,207.9 163.32,207.26 156.87,207.26 154.2,204.6 152.01,204.6 151.51,204.09 151.51,203.83 150.23,202.56 145.17,202.56 144.91,202.3 144.91,202.03 145.28,201.65 J5B2.A44
EXP_A_RX_6_DP: length 74.9
  TOP w0.1: J3D1.F6 208.06,194.44 v1(207.61,194.96)
  BOTTOM w0.088: 206.51,195.59 206.49,195.59 206.44,195.59 206.44,195.59 206.24,195.59 206.18,195.53 205.3,195.53 205.15,195.38
  BOTTOM w0.089: 203,195.91 203.76,195.91 204.29,195.38 205.15,195.38 ; 206.51,195.59 206.98,195.59 207.34,195.23 207.34,195.22 v1(207.61,194.96)
  BOTTOM w0.1: J5B2.A43 144.05,202.38 144.71,202.38 145.08,202.76 150.15,202.76 151.31,203.92 151.31,204.17 151.93,204.8 154.12,204.8 156.79,207.46 163.23,207.46 163.87,208.1 168.63,208.1 168.78,207.95 169.41,207.95 170.25,208.79 173.63,208.79 174.47,207.95 176.38,207.95 176.61,207.72 177.32,207.72 177.97,207.06 178.7,207.06 179.47,206.3 184.55,206.3 186.06,204.8 187.35,204.8 190.55,201.6 195.39,201.6 195.85,202.05 198.53,202.05 200.86,199.73 200.86,197.95 202.9,195.91 203,195.91
EXP_A_RX_7_DN: length 76.8
  TOP w0.1: J3D1.G6 v1(208.52,193.91)
  BOTTOM w0.089: v1(208.52,193.91) 208.88,193.91 208.96,194 208.96,194.12 208.74,194.34 206.34,194.34 206.27,194.41 203.84,194.41 203.38,194.87 202.87,194.87
  BOTTOM w0.1: J5B2.A48 145.28,197.65 144.91,198.03 144.91,198.3 145.12,198.51 149.18,198.51 151.58,200.91 152.9,200.91 153.67,201.67 155.22,201.67 156.53,202.99 156.53,203.75 157.58,204.8 158.47,204.8 158.8,205.13 165.56,205.13 166.04,205.61 169.06,205.61 169.62,206.17 170.38,206.17 171.09,206.88 172.99,206.88 174.39,205.48 178.08,205.48 179.31,204.26 181.56,204.26 181.86,203.96 184.66,203.96 185.91,202.7 187.23,202.7 189.91,200.02 199.13,200.02 199.88,199.28 199.88,197.6 202.6,194.87 202.87,194.87
EXP_A_RX_7_DP: length 76.9
  TOP w0.1: J3D1.G7 v1(209.44,193.91)
  BOTTOM w0.089: v1(209.44,193.91) 208.82,194.53 206.42,194.53 206.35,194.6 203.92,194.6 203.46,195.06 202.95,195.06 202.95,195.06 202.89,195.06 202.88,195.07 202.87,195.07
  BOTTOM w0.1: J5B2.A47 144.05,198.38 144.71,198.38 145.03,198.71 149.1,198.71 151.5,201.11 152.82,201.11 153.58,201.87 155.14,201.87 156.33,203.07 156.33,203.83 157.5,205 158.39,205 158.72,205.33 165.48,205.33 165.96,205.81 168.98,205.81 169.54,206.37 170.3,206.37 171.01,207.08 173.07,207.08 174.47,205.68 178.17,205.68 179.39,204.46 181.64,204.46 181.94,204.16 184.74,204.16 186,202.9 187.31,202.9 189.99,200.22 199.21,200.22 200.08,199.36 200.08,197.68 202.69,195.07 202.87,195.07
EXP_A_RX_8_DN: length 75.7
  TOP w0.1: J3D1.H6 v1(207.61,193.13)
  BOTTOM w0.088: 205.1,193.55 205.24,193.68 205.99,193.68 206.06,193.76 206.26,193.76
  BOTTOM w0.089: 206.26,193.76 206.98,193.76 v1(207.61,193.13) ; 205.1,193.55 203.97,193.55 203.53,193.99 202.44,193.99 202.43,194
  BOTTOM w0.1: 202.43,194 202.13,194 201.49,194.65 201.49,195.29 199.96,196.83 199.66,196.83 198.93,197.56 198.66,197.56 197.46,198.75 189.53,198.75 186.76,201.52 185.31,201.52 184.05,202.79 181.28,202.79 180.96,203.11 178.16,203.11 177.4,203.88 173.75,203.88 172.74,202.87 172.06,202.87 171.43,203.5 163.62,203.5 163.06,202.94 159.86,202.94 159.42,202.51 158.54,202.51 156.38,200.35 155.18,200.35 153.79,198.95 152.31,198.95 150.93,197.57 150.93,196.6 149.09,194.76 145.07,194.76 144.27,193.96 144.27,193.14 J5B2.A53
EXP_A_RX_8_DP: length 75.7
  TOP w0.1: v1(206.69,193.13) 207.15,192.61 J3D1.H5
  BOTTOM w0.088: 206.26,193.57 206.14,193.57 206.07,193.5 205.32,193.5 205.18,193.36
  BOTTOM w0.089: 205.18,193.36 203.89,193.36 203.45,193.8 202.36,193.8 ; 206.26,193.57 206.9,193.57 207.15,193.32 207.15,193.2 207.08,193.13 v1(206.69,193.13)
  BOTTOM w0.1: J5B2.A52 145.55,193.42 144.65,193.42 144.47,193.6 144.47,193.87 145.16,194.56 149.17,194.56 151.13,196.52 151.13,197.48 152.4,198.75 153.87,198.75 155.27,200.15 156.46,200.15 158.62,202.31 159.51,202.31 159.94,202.74 163.15,202.74 163.7,203.3 171.34,203.3 171.98,202.67 172.82,202.67 173.83,203.68 177.31,203.68 178.08,202.91 180.87,202.91 181.2,202.59 183.96,202.59 185.23,201.32 186.68,201.32 189.45,198.55 197.38,198.55 198.57,197.36 198.85,197.36 199.58,196.63 199.87,196.63 201.29,195.21 201.29,194.56 202.05,193.8 202.36,193.8
EXP_A_RX_9_DN: length 78.2
  TOP w0.1: J3D1.J7 v1(209.37,192.15)
  BOTTOM w0.089: v1(209.37,192.15) 208.82,192.7 205.32,192.7 205.18,192.85 203.65,192.85 203.27,193.23 202.48,193.23 202.41,193.15 202.08,193.15 202.07,193.17 202.05,193.17
  BOTTOM w0.1: 202.05,193.17 201.54,193.17 200.07,194.64 199.09,194.64 198.06,195.66 198.06,196.17 196.93,197.3 188.9,197.3 187.07,199.13 185.7,199.13 183.41,201.42 180.59,201.42 180.25,201.76 177.45,201.76 177.24,201.98 173.86,201.98 173.37,201.49 171.4,201.49 170.77,202.13 164.76,202.13 163.54,200.91 159.73,200.91 157.07,198.25 156.43,198.25 154.73,196.54 153.71,196.54 151.76,194.59 151.76,192.79 151.19,192.22 150.46,192.22 149.37,191.13 147.7,191.13 147.33,190.76 145.07,190.76 144.29,189.98 144.29,189.16 J5B2.A57
