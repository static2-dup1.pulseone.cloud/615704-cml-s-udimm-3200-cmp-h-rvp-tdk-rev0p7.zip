# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIEX16_PRSNT2_R_N: length 8.7
  TOP w0.1: R5C5.1 R5C4.1 ; R5C5.1 134.74,221.49 130.68,221.49 129.41,220.22 Q6C1.2 ; R5C5.1 R5C6.2
PCON_RESET: length 27.9
  TOP w0.1: R3A23.2 v1(236.22,271.65) 236.47,271.91 236.47,278.51 237.08,279.12 237.08,280.06 236.85,280.29 v1(235.33,280.29) 234.82,279.78 R3A4.2
  TOP w0.305: v1(238.01,265.18) 237.61,265.59 U3A5.B8
  LAY6 w0.125: v1(236.22,271.65) 234.06,271.65 233.17,270.76 233.17,264.54 233.55,264.16 234.31,264.16 235.33,265.18 v1(238.01,265.18)
PCON_RESET_R: length 2.9
  TOP w0.1: R3A4.1 R3A5.1 v1(235.83,278) 235.83,278 U3A4.4
PCON_V1P2_EN: length 68.7
  TOP w0.1: R3A25.2 R3A24.1 233.56,269.87 232.92,270.51 231.01,270.51 230.5,271.02 v1(229.75,271.02) ; R2A71.1 274.82,265.05 v1(274.32,265.05)
  LAY6 w0.125: v1(274.32,265.05) 274.57,264.79 274.57,259.71 273.76,258.89 273.76,257.94 273.38,257.55 257.17,257.55 256.15,258.57 245.61,258.57 242.82,261.36 234.06,261.36 233.68,261.75 233.68,262.76 231.77,264.67 230.37,264.67 229.48,265.56 229.48,270.74 229.75,271.01 v1(229.75,271.02)
PCON_V1P2_EN_R: length 2.4
  TOP w0.1: U3A5.G8 236.95,269.59 236.34,268.98 R3A25.1
PD_988_HRESET: length 204.6
  TOP w0.1: R5A25.2 147.49,274.06 ; 147.49,274.06 R5A24.2 ; 147.49,274.06 147.49,272.34 146.81,271.65 v1(146.81,271.4) ; R6F14.1 112.39,111 112.39,110.77 v1(112.42,110.74)
  LAY5 w0.125: v1(124.99,213.97) 125.6,213.36 125.6,213.26 127.08,211.78 128.07,211.78 129.04,210.8 129.04,198.29 131.41,195.92 131.41,193.12 130.88,192.59 130.88,191.69 129.93,190.74 129.93,188.97 129.03,188.07 129.03,185.55 128.8,185.32 128.8,179.31 129.1,179.01 129.1,176.73 128.14,175.76 128.14,173.92 131.72,170.34 131.72,165.36 130.93,164.58 130.93,159.58 138.04,152.46 138.04,138.35 131.26,131.57 128.42,131.57 126,129.15 126,125.56 121.22,120.78 119.1,120.78 112.42,114.09 v1(112.42,110.74)
  LAY6 w0.125: v1(124.99,213.97) 125.22,214.2 125.22,216.15 123.84,217.53 123.84,224.6 121.14,227.3 121.14,233.02 119.34,234.83 119.34,236.93 121.3,238.89 121.3,239.97 127.78,246.45 127.78,248.14 130.54,250.9 131.26,250.9 141.35,260.99 142.08,260.99 142.98,261.88 144.76,261.88 146.55,263.67 146.55,270.4 146.81,270.66 v1(146.81,271.4)
PD_COMP_N: length 4
  TOP w0.1: R6A70.2 115.95,267.33 115.82,267.46 115.82,268.35 115.69,268.48 R6A66.1 115.18,268.6 U6A4.1
PD_COMP_OUT: length 16.5
  TOP w0.1: Q6A1.5 121.01,266.18 120.9,266.06 118.61,266.06 118.28,266.39 118.28,267.16 117.98,267.46 117.98,269.75 117.29,270.43 115.51,270.43 R6A58.2 114.8,271.14 111.82,271.14 U6A4.4 110.54,271.14 R6A57.2
PD_COMP_P: length 5.7
  TOP w0.1: R6A65.2 R6A59.1 116.91,270.05 115.62,270.05 R6A58.1 114.55,270.5 U6A4.3
PD_DRAIN1: length 6.8
  TOP w0.1: EU5A1.15 139.76,265.13 EU5A1.58 ; EU5A1.8 139.64,267.13 v3(139.95,266.83) 140.49,266.29 EU5A1.58 ; EU5A1.58 141.36,264.98 EU5A1.19
  vias: v3(139.95,265.81) v3(139.95,264.92) v3(140.97,266.83) v3(140.97,265.81) v3(140.97,264.92)
PD_DRAIN2: length 5.7
  TOP w0.1: EU5A1.52 141.36,269.66 140.49,268.78 139.76,269.51 EU5A1.56 ; EU5A1.7 139.64,267.53 v3(139.95,267.84)
  vias: v3(139.95,269.75) v3(139.95,268.73) v3(140.97,269.75) v3(140.97,268.73) v3(140.97,267.84)
PD_EC_I2C_GATE: length 8.4
  TOP w0.1: Q8G2.1 Q8G3.1 45.08,89.66 45.97,90.55 45.97,91.44 45.21,92.2 R8G11.2
PD_GPIO1: length 2.5
  TOP w0.1: R5A51.1 140.46,263.27 140.56,263.37 EU5A1.17
PD_HRESET_AIC_R: length 93.5
  TOP w0.1: R6H37.2 118.11,32.8 J6J1.2 ; R6F19.1 111.12,108.33 111.12,107.06 110.36,106.3 v1(110.36,106.17)
  LAY6 w0.125: J6J1.2 116.2,31.27 123.82,38.89 123.82,48.74 122.93,49.64 122.93,56.49 122.12,57.3 122.12,57.73 118.99,60.86 118.99,69.7 121.03,71.73 121.03,77.05 119.04,79.03 119.04,82.53 113.67,87.9 113.67,98.8 111,101.47 111,105.53 v1(110.36,106.17)
PD_HRESET_EC: length 325.5
  TOP w0.1: R5J9.2 140.71,8.38 v1(140.71,7.87) ; U8F6.38 19.61,102.69 v1(20.32,101.98) ; R6F17.2 110.87,107.39 109.88,106.39 109.88,105.89 v1(110.36,105.41)
  LAY3 w0.1: v1(108.56,38.4) 109.54,37.42 120.28,37.42 123.35,34.36 146.89,34.36 153.38,27.87 153.38,22.75 154.25,21.87 154.25,19.38 153.38,18.51 153.38,9.21 152.29,8.13 141.22,8.13 140.97,7.87 v1(140.71,7.87)
  LAY5 w0.125: v1(110.36,105.41) 109.85,104.9 109.85,99.59 108.83,98.58 108.83,93.91 94.8,79.88 92.77,79.88 89.98,77.09 89.4,77.09 88.13,75.82 88.13,73.61 82.08,67.56 75.84,67.56 72.68,64.4 71.25,64.4 71,64.14 69.61,64.14 68.97,63.51 67.33,63.51 65.38,61.56 51.97,61.56 51.53,62 49.12,62 47.87,60.75 47.87,59.71 46.71,58.55 44.94,58.55 41.51,55.12 33.55,55.12 33.29,54.86 28.06,54.86 27.81,55.12 24.25,55.12 24,55.37 24,58.24 19.95,62.29 19.95,70.17 19.43,70.68 19.43,81.3 19.55,81.42 19.55,92.7 19.81,92.96 19.81,101.47 v1(20.32,101.98)
  LAY8 w0.1: v1(108.56,38.4) 108.07,38.89 108.07,65.53 105.41,68.2 105.41,74.8 106.17,75.56 106.17,78.36 105.53,78.99 105.53,80.01 107.69,82.17 107.69,84.07 110.99,87.37 110.99,104.77 v1(110.36,105.41)
PD_HRESET_OPTION: length 2.7
  TOP w0.1: R6F17.1 R6F15.1 R6F14.2 111.76,109.85
PD_HRESET_PCH: length 25.7
  TOP w0.089: U6E1.N48 108.23,135.31 108.13,135.21 108.1,135.18 108.1,131.28 110.89,128.48 110.89,128.31
  TOP w0.1: R6F15.2 111.37,112.14 111.37,117.47 111.58,117.68 111.58,119.32 110.89,120.01 110.89,128.31
PD_INT_EC_ISOLATION_G: length 9
  TOP w0.1: v1(26.79,76.58) Q8G8.1 R9G24.2 ; Q9G4.1 26.79,74.04 v1(26.79,74.8)
  BOTTOM w0.1: v1(26.79,76.58) v1(26.79,74.8)
PD_INT_PCH_ISOLATION_G: length 8.2
  BOTTOM w0.1: 108.33,101.98 108.96,101.34 Q6T1.1 108.33,100.71 107.69,100.07 107.69,99.31 107.56,99.19 105.91,99.19 105.28,99.82 105.28,100.2 104.77,100.71 Q6T2.1
PD_PCH_I2C_GATE: length 9.2
  TOP w0.1: R8E65.2 40.13,130.68 38.97,131.84 37.98,131.84 Q8E10.1 36.7,131.19 36.44,131.44 36.44,133.09 37.33,133.98 Q8E9.1
PD_SX_ACK_G2: length 228.9
  TOP w0.1: v1(12.06,113.16) 16.85,117.95 18.89,117.95 v1(19.93,119) ; R6H41.1 128.77,35.43 129.15,35.81 R6H40.1 129.15,37.21 v1(128.52,37.84) ; R8F21.2 v1(26.03,112.27)
  LAY5 w0.125: v1(12.06,113.16) 12.06,105.03 13.18,103.91 13.18,96.54 13.46,96.26 13.46,92.58 12.55,91.67 12.55,82.82 13.84,81.53 13.84,70.71 14.22,70.33 14.22,61.85 11.3,58.93 11.3,39.62 14.85,36.07 18.79,36.07 19.93,34.93 25.44,34.93 25.69,35.18 27.45,35.18 27.7,34.93 28.19,34.93 29.85,33.26 33.56,33.26 34.71,34.41 38.98,34.41 39.49,34.93 45.56,34.93 47.57,32.92 50.03,32.92 50.45,32.5 62.17,32.5 63.44,33.77 101.62,33.77 102.64,34.8 105.86,34.8 106.76,33.9 112.86,33.9 113.07,34.11 121.67,34.11 122.38,33.4 127.38,33.4 129.15,35.17 129.15,37.21 v1(128.52,37.84)
  BOTTOM w0.1: v1(19.93,119) 20.82,118.11 20.82,115.82 24.38,112.27 v1(26.03,112.27)
PD_SX_ACK_G2_AIC: length 10.1
  TOP w0.1: R6H41.2 128.52,31.62 128.9,31.24 128.9,28.95 128.52,28.57 126.14,28.57 J6J1.15
PD_SX_ACK_G2_BP: length 288.3
  TOP w0.1: R6H40.2 128.27,36.83 v1(128.52,37.08) ; v1(146.09,271.4) 146.09,271.32 146.68,270.73 146.68,269.62 146.19,269.13 EU5A1.40
  LAY5 w0.125: v1(118.69,90.29) 117.83,91.16 117.83,106.7 115.06,109.47 115.06,112.97 119.96,117.87 128.85,117.87 134.85,123.87 134.85,131.6 140.77,137.51 140.77,157.12 134.44,163.45 134.44,167.94 134.96,168.46 134.96,170.96 133.91,172.01 133.91,177.06 132.2,178.76 132.2,180.14 133.37,181.31 133.37,185.47 132.9,185.94 132.9,191.75 133.6,192.46 133.6,203.07 132.76,203.91 132.76,210.67 128.03,215.39 127.12,215.39 126.61,215.9 v1(124.71,215.9)
  LAY6 w0.125: v1(118.69,90.29) 121.15,87.83 121.15,84.2 121.59,83.76 121.59,80.2 123.91,77.88 123.91,70.61 123.03,69.73 123.03,64.76 122.68,64.41 122.68,62.84 130.55,54.97 130.55,41.14 129.03,39.62 129.03,37.59 v1(128.52,37.08) ; v1(146.09,271.4) 146.3,271.19 146.3,263.78 144.65,262.13 142.87,262.13 141.98,261.24 141.24,261.24 131.16,251.15 130.43,251.15 127.52,248.24 127.52,246.55 121.05,240.08 121.05,238.99 119.09,237.03 119.09,234.72 120.89,232.92 120.89,227.19 123.59,224.5 123.59,217.02 v1(124.71,215.9)
PD_SX_ACK_G2_EC: length 242.7
  TOP w0.1: U8F6.15 26.02,106.83 26.19,107 26.19,107.71 24.94,108.96 R8F23.2 25.32,109.4 25.32,110.72 v1(25.29,110.74) 25.29,110.97 R8F21.1 ; R5J18.1 v1(135.12,7.62)
  LAY3 w0.1: v1(78.38,39.42) 78.81,39.85 87.83,39.85 88.78,40.8 89.42,40.8 90.01,41.4 104.11,41.4 105.25,40.26 109.07,40.26 109.78,39.55 115.01,39.55 115.77,38.78 122.63,38.78 124.84,36.57 124.84,36.04 125.16,35.72 147.45,35.72 154.74,28.43 154.74,23.31 156.26,21.79 156.26,5.51 152.04,1.3 138.9,1.3 135.12,5.08 v1(135.12,7.62)
  LAY8 w0.1: v1(78.38,39.42) 77.67,40.13 76.2,40.13 73.02,43.31 71.35,43.31 61.98,52.68 59.5,52.68 55.95,56.22 55.95,59.87 50.79,65.03 49.4,65.03 48.46,65.97 48.46,68.77 46.27,70.95 46.27,78.99 45.48,79.78 45.48,80.54 43.32,82.7 43.32,84.33 42.41,85.23 42.41,91.82 41.54,92.69 41.54,95.5 38.5,98.55 38.5,105.46 37.77,106.19 37.29,106.19 34.13,109.35 26.69,109.35 v1(25.29,110.74)
PD_SX_ACK_G2_PCH: length 208.3
  TOP w0.089: U6E1.P47 107.81,136.05 107.81,135.43 107.72,135.34 107.72,131.12 110.38,128.45 110.38,128.06
  TOP w0.1: R8F20.1 v1(26.03,113.16) ; v1(110.36,104.65) 109.54,105.46 109.54,106.39 110.38,107.23 110.38,113.56 R6F11.2 110.38,114.53 110.38,128.06
  LAY5 w0.125: v1(27.55,54.61) 33.4,54.61 33.65,54.86 41.61,54.86 45.05,58.3 47.35,58.3 49.12,60.07 52.72,60.07 53.96,61.31 65.48,61.31 67.43,63.26 69.07,63.26 69.71,63.89 71.11,63.89 71.36,64.14 72.78,64.14 75.94,67.31 82.19,67.31 88.4,73.52 89.27,73.52 91.65,75.91 91.65,77.42 93.86,79.62 94.9,79.62 110.87,95.59 110.87,104.14 v1(110.36,104.65)
  LAY6 w0.125: v1(26.03,113.16) 26.54,112.65 26.54,109.98 27.94,108.58 27.94,107.37 26.15,105.59 26.15,96.19 27.07,95.28 27.07,91.16 25.9,89.99 25.9,85.09 26.36,84.63 26.36,83.16 27.17,82.35 27.17,78.87 27.88,78.16 27.88,71.45 26.64,70.21 26.64,66.7 27.94,65.4 27.94,54.99 v1(27.55,54.61)
PECI_EC: length 172.6
  TOP w0.1: U8F6.94 30.82,89.32 31.24,88.9 v1(31.24,88.67) R8G24.2 ; J6J2.87 v1(124.8,12.14)
  LAY3 w0.1: v1(31.24,88.67) 31.24,88.14 30.73,87.63 30.73,75.75 31.51,74.97 31.51,73.87 29.1,71.46 29.1,68.47 28.45,67.82 28.45,63.23 25.4,60.17 25.4,53.72 26.8,52.32 26.8,48.31 29.2,45.91 30.92,45.91 32.13,44.7 32.13,43.88 39.15,36.85 45.99,36.85 47.94,38.79 50.03,38.79 52.99,35.83 60.61,35.83 64.95,31.49 67.53,31.49 69.14,29.88 73.81,29.88 74.11,30.18 75.38,30.18 75.56,30.36 77.54,30.36 78.42,29.48 80.19,29.48 80.89,30.18 95.82,30.18 96.1,30.46 98.35,30.46 98.89,29.93 100.79,29.93 102.52,28.19 109.56,28.19 111.4,26.35 114.77,26.35 114.82,26.31 121.9,26.31 v1(123.19,25.02)
  LAY8 w0.1: v1(124.8,12.14) 123.19,13.75 123.19,17.14 123.69,17.65 123.89,17.65 124.94,18.71 124.94,23.89 123.82,25.02 v1(123.19,25.02)
PECI_MUX_CTRL_ER_INT: length 219.6
  TOP w0.1: R5J23.1 139.19,8.25 138.93,8 v1(138.93,7.62) ; U8F6.76 23.62,91.69 23.49,91.82 23.49,92.99 v1(24,93.5)
  LAY3 w0.1: v1(138.93,7.62) 139.95,6.6 139.95,3.94 140.71,3.17 143.51,3.17 144.01,3.68 144.01,6.73 144.78,7.49 152.3,7.49 153.83,9.03 153.83,18.32 154.71,19.2 154.71,22.06 153.83,22.93 153.83,28.06 147.08,34.81 123.54,34.81 120.47,37.88 110.07,37.88 108.6,39.35 103.77,39.35 103.5,39.62 103.5,40.06 103.07,40.49 98.32,40.49 97.41,39.58 93.17,39.58 92.26,40.49 90.51,40.49 89.91,39.9 89.16,39.9 88.21,38.95 81.4,38.95 80.62,38.17 74.49,38.17 v1(73.15,36.83)
  LAY8 w0.1: v1(24,93.5) 23.49,92.99 23.49,91.82 27.81,87.5 27.81,82.68 30.86,79.63 35.17,79.63 37.64,77.16 37.64,68.28 42.6,63.32 46.14,63.32 49.14,60.32 49.14,59.19 51.94,56.39 51.94,55.5 54.04,53.4 54.04,53.14 55.95,51.23 55.95,50.35 56.2,50.1 56.2,48.82 58.92,46.1 63.62,46.1 72.89,36.83 v1(73.15,36.83)
PEG_RESET_JUMPER: length 6.2
  TOP w0.1: R9E11.1 9.9,153.41 7.49,153.41 6.22,152.14 J9E3.1
PEG_RST_R_N: length 220.9
  TOP w0.1: v1(31.04,128.14) U8F2.2 31.04,133.16 R8E60.1 ; v1(88.9,103.5) 88.9,103.63 88.39,104.14 88.39,106.42 89.42,107.46 89.42,113.71 90.31,114.6 90.31,115.79 90.93,116.41 R7F25.2
  LAY5 w0.125: v1(88.9,103.5) 88.78,103.5 88.39,103.12 88.39,98.55 88.78,98.17 88.78,90.51 87.11,88.84 85.86,88.84 84.83,87.81 84.83,87.25 84.45,86.87 82.6,86.87 81.96,86.23 81.15,86.23 79.24,84.33 73.94,84.33 73.53,83.92 68.37,83.92 67.27,82.82 65.69,82.82 64.01,81.14 60.18,81.14 58.96,79.92 55.26,79.92 54.77,79.43 52.16,79.43 49.92,77.18 46.12,77.18 45.75,76.81 43.53,76.81 39.88,73.17 39.88,71.95 37.21,69.27 37.21,66.93 35.72,65.45 33.32,65.45 32.84,65.93 28.86,65.93 27.56,67.23 27.56,70.62 29.48,72.53 29.48,74.75 29.85,75.13 29.85,80.64 29.21,81.28 29.21,84.33 28.98,84.56 28.98,87.58 33.03,91.63 33.03,112.27 31.68,113.61 31.68,115.62 29.55,117.75 29.55,122.01 30.48,122.93 30.48,127.57 v1(31.04,128.14)
  LAY6 w0.125: v1(31.04,128.14) 31.04,134.76 29.17,136.63 29.17,141.1 29.72,141.65 29.72,145.04 30.6,145.92 v1(30.6,148.97)
  BOTTOM w0.1: J9E3.2 8.5,152.4 12.06,152.4 13.2,151.26 26.67,151.26 27.17,151.76 27.91,151.76 30.6,149.07 v1(30.6,148.97)
PEG_SLOT_PWREN_R: length 37.1
  TOP w0.1: EU6B3.2 121.66,236.73 v1(121.53,236.6) ; R6B12.1 113.54,251.21 EU6B1.2 ; R6B12.1 113.77,250.71 EU6B1.3 ; R6B12.1 111.37,251.08 110.99,251.46 v1(110.99,251.84)
  LAY5 w0.125: v1(107.82,237.11) 108.14,237.43 118.38,237.43 118.49,237.54 120.9,237.54 121.53,236.9 v1(121.53,236.6)
  LAY6 w0.125: v1(110.99,251.84) 110.99,249.71 107.44,246.15 107.44,237.62 107.82,237.23 v1(107.82,237.11)
PEG_SLOT_RST_N: length 279.7
  TOP w0.1: v1(26.21,137.54) 28.7,137.54 R8E53.1 R8E60.2 R8E61.2
  LAY5 w0.125: J5B2.A11 143.29,237.15 141.85,237.15 141.6,237.39 140.87,237.39 137.99,234.52 137.99,228.42 137.54,227.96 136.03,227.96 134.34,226.27 125.3,226.27 122.3,223.26 120.01,223.26 119.12,224.15 117.22,224.15 116.96,223.9 116.96,221.99 117.47,221.49 117.47,217.98 115.32,215.83 108.4,215.83 101.6,222.63 86.85,222.63 83.31,226.17 83.31,229.74 80.64,232.41 72.46,232.41 68.28,236.59 67.49,236.59 65.27,238.8 65.27,240.28 65.02,240.54 64.13,240.54 62.99,241.68 62.09,241.68 61.71,242.06 61.71,243.21 61.16,243.76 59.66,243.76 58.57,244.85 57.66,244.85 57.21,245.3 57.21,245.81 56.89,246.12 55.11,246.12 52.19,243.2 46.73,243.2 46.1,242.57 43.56,242.57 42.67,241.68 39.24,241.68 38.35,242.57 33.4,242.57 31.87,244.09 v1(31.87,245.87)
  LAY6 w0.125: v1(31.87,245.87) 31.87,245.07 30.48,243.68 30.48,242.06 27.45,239.04 27.45,238.23 28.83,236.85 28.83,234.67 28.19,234.02 28.19,230.76 28.11,230.68 28.11,226.11 28.96,225.27 28.96,222.09 29.62,221.43 29.62,219.38 28.83,218.59 28.83,217.39 30.04,216.18 30.04,212.06 29.8,211.82 29.8,209.44 31.49,207.75 31.49,206.8 33.4,204.9 33.4,204.6 34.17,203.82 34.17,198.13 34.03,197.99 34.03,186.15 32.28,184.4 29.54,184.4 27.92,182.78 27.92,179.29 26.91,178.28 26.91,176.68 27.58,176.02 27.81,176.02 28.06,175.77 28.06,173.35 27.55,172.85 27.3,172.85 26.67,172.21 26.67,162.56 27.17,162.05 27.17,158.63 25.99,157.45 25.99,137.76 v1(26.21,137.54)
PEG_SLOT_RST_R_N: length 1.7
  TOP w0.1: R8E61.1 31.99,133.22 U8F2.4
PEG_SR: length 1.6
  TOP w0.1: C6B5.1 121.66,239.52 121.66,238.62 EU6B3.7
PERST_N_M2_SLOTB_N: length 24.3
  TOP w0.1: R5C10.2 R5C11.2 170.43,235.46 170.43,234.57 169.83,233.97 167.85,233.97 v1(167.28,233.4) ; R5C8.1 162.68,219.68 v1(163.27,220.27) 164.03,221.03 J5B3.50
  LAY6 w0.125: v1(167.28,233.4) 166.24,232.36 166.24,230.7 167.01,229.93 167.01,228.66 163.27,224.92 v1(163.27,220.27)
PERST_N_M2_SLOTB_R: length 1.6
  TOP w0.1: R5C10.1 169.74,237.56 U5C1.4
PERST_SLTA_L: length 38.6
  TOP w0.1: v1(136.14,40) 136.27,39.88 136.27,31.62 136.9,30.99 J5J1.3 ; R6H34.2 110.87,38.5 v1(110.77,38.4)
  LAY5 w0.125: v1(110.77,38.4) 111.35,38.99 115.69,38.99 115.95,38.73 119.88,38.73 120.64,39.49 125.8,39.49 126.03,39.71 133.12,39.71 133.35,39.49 135.62,39.49 v1(136.14,40)
  BOTTOM w0.1: R5V4.2 v1(136.14,40)
PERST_SLTB_L: length 60.7
  TOP w0.1: J5J1.4 136.9,39.88 137.54,40.51 138.31,40.51 v1(138.81,40) ; R6H8.2 106.04,52.45 105.53,52.96 v1(105.53,52.98) ; v1(142.24,40) 142.36,39.88 R5H12.2
  LAY5 w0.125: v1(138.81,40) 138.81,39.42 139.24,38.99 141.22,38.99 v1(142.24,40)
  BOTTOM w0.1: R5V3.2 138.81,40 v1(138.81,40) 131.58,47.24 124.96,47.24 120.21,51.99 120.21,56.06 120.01,56.26 119.03,56.26 116.36,53.59 106.17,53.59 105.56,52.98 v1(105.53,52.98)
PERST_SLTC_L: length 49.8
  TOP w0.1: v1(141.47,40) 141.35,39.88 141.35,31.75 141.98,31.11 J5J1.11 ; R6H2.2 v1(113.79,56.51)
  BOTTOM w0.1: R5V7.2 v1(141.47,40) 140.93,40.54 139.48,40.54 131.98,48.04 125.49,48.04 120.95,52.58 120.95,56.4 120.27,57.09 117.65,57.09 116.44,55.88 114.42,55.88 v1(113.79,56.51)
PERST_SLTD_L: length 4.7
  TOP w0.1: R5H12.1 142.36,37.97 v1(141.85,37.46) 141.98,37.34 J5J1.12
PH_EXTEND: length 3.4
  TOP w0.2: R1B47.1 R1B45.1 287.07,229.05 EU1B1.45
PHYSLP_LED: length 1.1
  TOP w0.1: CR8H1.1 R8H32.1
PHYSLP_LED_R: length 2.6
  TOP w0.1: CR8H1.2 46.03,47.24 Q8H2.3
PINSET_TSENC: length 56.2
  TOP w0.2: RT3B1.2 240.39,240.65 240.08,240.34 239.75,240.34 238.9,239.5 238.26,239.5 236.14,237.38 236.14,233.61 v1(235.83,233.3) ; R2B33.1 R2B35.2 R2B36.2 273.71,236.19 R2B37.1 274.42,236.14 275.05,235.51 v1(275.08,235.51)
  LAY6 w0.2: v1(235.83,233.3) 236.42,233.88 245.86,233.88 247.26,235.28 249.94,235.28 251.34,233.88 256.8,233.88 256.92,233.75 262.77,233.75 263.02,233.5 270.26,233.5 270.77,232.99 273.04,232.99 273.86,233.81 273.86,234.49 274.87,235.51 v1(275.08,235.51)
PINSET_TSENG: length 51.2
  TOP w0.2: v1(279.16,188.35) 279.28,188.23 RT2D2.2 ; v1(275.33,221.23) 275.35,221.26 275.35,221.86 274.95,222.27 274.95,223.26 R2C13.2 R2C10.1 R2C7.2 R2C8.1
  LAY6 w0.2: v1(275.33,221.23) 275.59,221.23 275.99,220.83 275.99,219.81 275.26,219.08 275.26,210.36 270.12,205.23 270.12,201.12 268.22,199.22 268.22,193.08 269.15,192.15 271.27,192.15 273.44,189.98 277.42,189.98 278.61,188.79 278.72,188.79 v1(279.16,188.35)
PINTSENC_H: length 1.8
  TOP w0.2: 271.14,236.35 271.52,236.73 272.28,236.73 R2B36.1
PINTSENC_L: length 0.9
  TOP w0.2: R2B33.2 R2B30.1
PINTSENG_H: length 1
  TOP w0.2: R2C18.2 274.32,222.12 274.32,222.76 R2C13.1
PINTSENG_L: length 0.9
  TOP w0.2: R2C12.1 273.55,222.88
PIRQ_ESPI_ALRT0_N: length 79.7
  TOP w0.089: U6E1.BA36 v1(94.51,140.9)
  BOTTOM w0.1: v1(94.51,140.9) 94.44,140.97 93.57,140.97 93.31,140.71 92.2,140.71 91.53,140.05 88.99,140.05 87.25,138.3 86.48,138.3 82.26,134.08 80.32,134.08 79.43,133.19 78.01,133.19 77.66,133.53 75.43,133.53 75.14,133.82 73.5,133.82 73.09,133.41 73.09,131.67 71.24,129.82 71.24,127.89 70.1,126.75 70.1,124.16 69.4,123.46 69.4,113.7 72.53,110.58 72.53,103.94 73.34,103.13 73.34,101.96 76.16,99.14 76.16,97.97 78.42,95.71 78.76,95.71 79.36,95.11 81.9,95.11 82.44,95.65 84.24,95.65 84.66,96.08 86.67,96.08 87.24,95.5 R7U2.1 87.5,95.25 87.75,95.5 R7U1.1
PIRQ_N: length 75.7
  TOP w0.1: v1(101.21,35.53) J7J1.20
  LAY8 w0.1: v1(90.29,95.5) 89.91,95.5 89.4,94.99 89.4,90.68 90.42,89.66 90.67,89.66 94.1,86.23 94.1,77.98 95.25,76.83 95.25,61.34 97.02,59.56 97.02,58.55 97.4,58.16 97.91,58.16 99.04,57.03 99.04,54.43 95.57,50.96 95.57,39.13 95.81,38.89 95.81,37.34 98.1,35.05 100.73,35.05 v1(101.21,35.53)
  BOTTOM w0.1: R7U1.2 v1(90.29,95.5) ; R6V1.2 v1(101.21,35.53)
PLN_DELAY_EN: length 5.4
  TOP w0.2: U8H5.4 R8H38.2 35.43,46.61 35.16,46.33 Q8H3.3 34.29,45.99 R8H43.1 R8H47.2
PLT_RST_LAN_N_FOX: length 37.8
  TOP w0.1: EU7A3.13 96.68,256.27 97.79,255.17 97.79,254.38 100.4,251.76 102.31,251.76 103.53,250.54 103.53,247.24 106.17,244.6 106.17,241.04 105.35,240.23 99.03,240.23 97.15,238.35 97.15,235.46 96.85,235.15 96.06,235.15 R7B60.2 R7B64.1 R7B63.2
PLTRST_CPU_N: length 235.4
  TOP w0.089: U6E1.AG5 101.04,156.84 101.08,156.88 101.08,156.99 101.17,157.08 101.17,157.63 101.2,157.66 101.2,158.08 101.26,158.15 101.38,158.26 101.38,160.54 101.27,160.66 101.27,164.03 100.96,164.34
  TOP w0.1: v1(134.62,214.25) 130.04,214.25 129.08,213.28 126.45,213.28 125.22,214.52 124.6,214.52 124.31,214.23 122.53,214.23 121.65,213.35 102.01,213.35 95.25,206.59 95.25,192.12 94.59,191.45 94.59,187.72 95.13,187.17 95.13,181.03 96.04,180.12 96.04,174.55 99.84,170.75 99.84,165.94 100.58,165.2 100.58,164.72 100.96,164.34 ; J3D1.T7 208.43,185.83 207,185.83 206.78,186.05 206.78,186.53 206.68,186.64 202.69,186.64 201.98,187.35 197.22,187.35 195.09,189.48 194.69,189.48 194.37,189.8 194.37,190.44 193.92,190.88 193.7,190.88 190.11,194.46 190.11,204.98 185.13,209.96 182.98,209.96 178.82,214.12 174.11,214.12 172.69,215.54 172.69,225.32 172.08,225.93 168.91,225.93 167.95,226.89 167.95,229.68 168.78,230.5 v1(168.78,231.65)
  BOTTOM w0.1: v1(134.62,214.25) 135.92,215.55 135.92,233.31 138.08,235.47 138.08,238.19 138.74,238.85 139.63,238.85 140.64,239.87 143.72,239.87 145.35,238.85 146.14,238.85 148.48,241.19 152.5,241.19 157.7,235.99 160.97,235.99 161.66,235.3 166.25,235.3 168.29,233.27 168.29,232.14 v1(168.78,231.65)
PLTRST_EC_N: length 196.4
  TOP w0.1: J6J2.54 v1(118.69,14.43) ; R9G7.1 16,93.72 16,95.12 16.36,95.49 v1(16.51,95.49) U8F6.56
  LAY3 w0.1: v1(16.51,95.49) 10.79,89.77 10.79,71.3 9.08,69.59 9.08,50.74 11.06,48.76 11.06,38.22 12.99,36.29 12.99,25.37 13.47,24.88 13.47,23.48 14.22,22.73 14.22,20.28 14.94,19.56 18.54,19.56 19.17,18.92 19.17,17.65 21.59,15.24 22.35,15.24 24.75,12.83 41.77,12.83 42.15,12.46 70.75,12.46 71.62,13.33 82.93,13.33 83.31,12.95 84.45,12.95 85.21,13.71 86.23,13.71 86.92,14.4 105.76,14.4 107.18,12.98 v1(107.18,12.83)
  LAY6 w0.125: v1(107.18,12.83) 108.58,12.83 109.7,13.94 115.16,13.94 115.65,14.43 v1(118.69,14.43)
PLTRST_FOX_N: length 124.7
  TOP w0.1: v1(78.46,141.6) 78.46,141.58 77.97,141.1 77.21,141.1 R7E30.2 ; R7B55.2 R7B60.1 95.37,236.47 94.74,237.11 v1(93.09,237.11) 92.83,237.36 91.76,237.36 U7B2.2
  LAY8 w0.1: v1(93.09,237.11) 91.66,235.68 84.74,235.68 82.83,233.78 81.18,233.78 76.35,228.95 76.35,223.61 71.14,218.41 71.14,190.53 83.59,178.09 83.59,175.1 81.81,173.32 81.81,160.49 80.03,158.72 80.03,149.7 79.14,148.81 79.14,142.29 v1(78.46,141.6)
PLTRST_FOX_R_N: length 2.1
  TOP w0.1: U7B2.4 94.04,235.39 R7B63.1
PLTRST_J15EV: length 6
  TOP w0.1: J9F2.1 6.73,117.35 10.41,117.35 R9F4.1
PLTRST_LAN_N: length 39.6
  TOP w0.1: EU4B1.36 183.79,256.94 183.64,256.79 183.64,255.65 182.24,254.25 182.24,253.12 182.14,253.02 180.61,253.02 178.73,251.14 168.57,251.14 167.97,251.74 162.25,251.74 161.08,252.91 157.01,252.91 156.9,252.8 156.9,249.75 155.43,248.28 J5B1.5 155.19,246.89 R5B26.1
PLTRST_N: length 542.8
  TOP w0.1: R9F4.2 TP9F1.1 14.47,117.98 17.01,120.52 v1(17.01,120.68) 19.21,120.68 22.73,124.2 R8F9.1 25.65,124.2 26.16,124.71 U8F5.1 26.54,125.47 26.67,125.6 27.3,125.6 27.49,125.41 27.49,124.71 ; R5G26.1 v1(157.6,78.99) ; EU8H2.6 59.7,45.73 v1(59.56,45.59) ; R5B26.2 152.88,246.12 v1(152.78,246.02) ; v1(157.98,226.56) 158.48,226.06 166.49,226.06 167.13,226.69 167.13,231.77 165.98,232.92 165.98,234.44 166.49,234.95 U5C1.1
  LAY5 w0.125: v1(157.6,78.99) 157.1,78.49 154.38,78.49 153.7,77.81 141.56,77.81 140.89,77.14 138.78,77.14 138.75,77.16 v1(138.73,77.16) 138.73,77.14 134.87,73.28 132.58,73.28 131.44,72.13 128.01,72.13 126.87,73.28 121.66,73.28 v1(121.53,73.15) 120.82,72.44 98.96,72.44 97.51,70.99 97.51,66.98 94.91,64.38 91.1,64.38 90.38,63.65 90.38,62.74 90.08,62.44 90.08,58.74 89.82,58.48 89.82,56.54 89.4,56.12 89.4,55.67 89.01,55.27 87.29,55.27 85.04,57.52 82.85,57.52 79.93,54.6 77.13,54.6 76.37,53.84 74.81,53.84 74.3,54.34 61.58,54.34 v1(61.08,53.85) 60.55,54.38 54.76,54.38 54.26,53.88 51.27,53.88 49.56,52.18 48.49,52.18 45.92,49.61 42.78,49.61 41.98,48.81 35.61,48.81 34.95,48.15 26.9,48.15 22.22,52.84 22.22,57.89 18.17,61.93 18.17,67.01 17.51,67.67 17.51,69.67 17.14,70.05 17.14,81.14 17.64,81.64 17.64,85.42 16.8,86.27 16.8,88.92 18.04,90.17 18.04,102.26 17.56,102.73 17.56,111.97 16.72,112.81 16.72,116.71 17.53,117.52 17.53,120.17 v1(17.01,120.68)
  LAY6 w0.125: v1(138.73,77.16) 138.73,82.5 136.53,84.7 136.53,98.8 134.36,100.96 134.36,103.2 133.98,103.58 133.98,107.57 135.61,109.2 135.61,112.37 135.76,112.52 136.37,112.52 138.6,114.75 139.39,114.75 139.75,115.11 141.27,115.11 141.73,115.57 141.73,116.71 141.85,116.84 143.51,116.84 147.32,120.66 147.32,132.98 147.57,133.22 147.57,143.17 157.22,152.83 157.22,154.73 157.5,155.01 157.5,155.55 156.83,156.21 156.83,158.74 157.6,159.51 157.6,164.2 157.08,164.72 157.08,165.48 159.44,167.84 159.44,170.71 160.07,171.34 160.07,175.63 160.25,175.8 160.25,178.44 162.12,180.31 162.76,180.31 164.79,182.34 164.79,187.61 163.29,189.1 163.29,190.19 162.05,191.44 162.05,194.84 160.66,196.22 160.66,198.11 163.7,201.15 163.7,202.82 163.44,203.07 162.43,203.07 162.3,203.2 162.3,204.6 161.29,205.61 159.5,205.61 158.48,206.63 158.48,207 160.53,209.04 160.53,210.19 160.9,210.56 161.29,210.56 162.43,211.71 162.43,214.37 157.98,218.82 v1(157.98,226.56) 157.88,226.66 157.88,231.16 158.62,231.9 158.62,232.92 158.33,233.2 158.33,234.85 157.48,235.71 154.17,235.71 152.27,237.62 148.29,237.62 147.66,238.25 147.66,240.43 148.08,240.85 148.08,244.66 149.93,246.52 152.28,246.52 v1(152.78,246.02) ; v1(59.56,45.59) 61.97,45.59 63.11,46.73 63.11,50.29 62.54,50.86 62.03,50.86 61.08,51.81 v1(61.08,53.85) ; v1(121.53,73.15) 121.53,77.07 119.42,79.19 119.42,82.69 114.05,88.06 114.05,98.95 111.37,101.63 111.37,105.66 v1(111.88,106.17)
  BOTTOM w0.1: v1(111.88,106.17) 111.88,110.12 110.18,111.82 109.66,111.82 R6T9.2
PLTRST_N_1P8V: length 421.2
  TOP w0.1: R7H3.1 93.13,65.53 v1(93.72,65.53) ; U7H1.4 98.2,49.88 v1(98.8,49.27) ; R8A27.1 R8A28.2 28.95,267.84 28.95,270.38 27.24,272.09 18.48,272.09 17.02,273.55 13.21,273.55 v1(9.27,277.49)
  LAY5 w0.125: v1(98.8,49.27) 98.7,49.17 95.56,49.17 94.89,48.5 92.95,48.5 89.29,44.84 86.56,44.84 86.17,44.44 83.05,44.44 82.53,43.92 73.89,43.92 73.27,43.31 72.18,43.31 71.8,43.69 60.85,43.69 59.87,42.7 49.11,42.7 48.89,42.92 48.13,42.92 47.71,42.51 42.89,42.51 42.28,41.9 40.7,41.9 40.08,41.27 37.23,41.27 36.14,42.36 30.15,42.36 28.57,43.94 26.03,43.94 21.97,48 20.57,48 19.17,46.61 19.17,45.85 18.79,45.46 14.85,45.46 13.7,46.61 13.7,59.17 16.52,61.99 16.52,62.75 15.47,63.8 15.47,70.85 15.09,71.23 15.09,81.32 15.86,82.09 15.86,85.21 14.98,86.1 14.98,87.11 15.73,87.87 15.73,99.99 16.4,100.65 16.4,101.78 15.48,102.69 15.48,104.07 14.97,104.58 14.97,117.68 11.26,121.39 11.26,132.54 11.9,133.18 11.9,138 10.27,139.63 10.27,152.14 10.4,152.27 10.4,172.88 9.26,174.02 9.26,203.83 10.4,204.98 10.4,209.94 8.89,211.45 8.89,227.07 9.52,227.71 9.52,229.74 8.5,230.76 8.5,246.89 3.55,251.84 3.55,276.22 4.44,277.11 8.89,277.11 v1(9.27,277.49)
  LAY6 w0.125: v1(98.8,49.27) 98.2,49.27 96.89,50.58 96.89,52.71 96.41,53.19 96.41,54.33 96.33,54.42 96.33,56.46 93.72,59.07 v1(93.72,65.53)
  BOTTOM w0.1: R7W3.1 85.21,29.72 88.32,32.83 92.26,32.83 95.63,36.19 95.63,37.98 100.33,42.68 100.33,47.75 v1(98.8,49.27)
PLTRST_N_BUF: length 981.9
  TOP w0.1: v1(157.35,82.93) 160.64,82.93 161.27,82.29 U5G2.1 ; v1(22.22,203.33) 24.25,203.33 24.51,203.58 U9C2.1 ; v1(96.64,46.99) 97.15,46.99 97.55,47.38 97.55,53.96 v1(96.9,54.61) ; U7B3.1 88.9,235.71 88.39,236.22 88.39,236.98 v1(88.13,237.23) 88.13,237.74 88.77,238.38 U7B2.1 ; R3A23.1 234.56,273.18 233.93,273.81 U3A4.1 v1(233.93,275.72) ; v1(94.61,65.53) 94.61,65.24 R7H18.1 ; v1(13.58,131.95) 13.97,131.95 14.47,132.46 18.66,132.46 19.3,131.82 22.51,131.82 25.43,134.75 26.79,134.75 27.07,134.47 27.07,130.43 26.54,129.9 U8F1.1 26.54,128.4 27.87,127.07 U8F5.4 29.66,127.07 R8F6.1 30.09,127.51 U8F2.1 ; R1C44.1 v1(282.44,210.69) ; U8G1.1 36.27,79.5 v1(36.83,79.5)
  LAY5 w0.125: v1(282.44,210.69) 282.44,212.85 282.96,213.37 282.96,219.48 286.23,222.75 286.23,231.62 288.45,233.84 288.45,235.52 287.66,236.32 287.66,240.58 286.88,241.36 286.88,243.93 286.82,243.99 286.82,252.56 288.13,253.86 288.13,256.26 289.48,257.62 289.48,263.69 288.79,264.38 284.95,264.38 v1(284.86,264.29) ; v1(157.35,82.93) 156.08,82.93 155.24,82.09 149.1,82.09 148.83,81.82 138.42,81.82 137.81,81.21 134.6,81.21 133.14,82.67 123.21,82.67 123.02,82.48 101.83,82.48 95.86,76.5 v1(94.74,76.5) 94.74,76.45 94.57,76.29 94.57,74.97 84.24,64.64 78.47,64.64 76.19,62.36 75.12,62.36 73.54,60.78 71.94,60.78 71.23,60.07 67.12,60.07 65.54,58.49 62.62,58.49 62.14,58.01 53.76,58.01 52.94,57.19 49.45,57.19 48.6,56.34 48.6,55.38 47.05,53.83 47.05,53.52 46.23,52.7 44.83,52.7 v1(44.7,52.83) ; v1(58.8,27.81) 59.38,27.23 64.93,27.23 65.15,27.01 71.7,27.01 72.56,26.15 77.71,26.15 78.1,26.54 83.21,26.54 v1(83.99,25.75) 86.06,25.75 88.7,23.11 v1(98.57,23.11) ; v1(284.98,270) 282.08,270 281.09,270.99 275.61,270.99 273.42,273.19 268.56,273.19 267.33,271.96 253.6,271.96 249.57,275.98 239.33,275.98 239.08,276.23 234.45,276.23 v1(233.93,275.72) 229.19,275.72 228.93,275.97 226.81,275.97 225.3,274.46 225.3,270.73 224.38,269.8 220.93,269.8 220.19,270.54 209.57,270.54 208.77,269.75 207.03,269.75 206.88,269.9 205.97,269.9 205.34,270.53 197.45,270.53 192.83,275.16 180.95,275.16 180.64,275.46 177.5,275.46 176.17,274.13 169.73,274.13 166.62,277.24 165.22,277.24 164.84,276.86 163.54,276.86 161.72,275.04 147.2,275.04 143.16,279.08 135.91,279.08 134.42,277.59 134.42,274.92 134.04,274.54 134.04,272.17 133.44,271.56 133.44,270.17 129.39,266.12 121.98,266.12 121.34,265.48 112.33,265.48 110.23,263.39 110.23,262.51 109.6,261.87 106.8,261.87 103.88,258.95 103.12,258.95 99.23,262.84 91.64,262.84 90.7,261.9 90.01,261.9 87.75,264.16 86.1,264.16 85.53,264.73 81.21,264.73 79.5,266.44 v1(72.51,266.44) 68.78,266.44 68.46,266.13 65.88,266.13 65.06,266.95 60.45,266.95 59.86,266.36 50.17,266.36 49.36,265.55 47.1,265.55 45.96,264.41 44.95,264.41 41.27,268.1 v1(41.27,269.42)
  LAY6 w0.125: v1(96.9,54.61) 96.7,54.8 96.7,56.62 94.61,58.71 v1(94.61,65.53) 94.61,67.31 92.96,68.96 92.96,72.9 94.48,74.42 94.48,76.2 94.74,76.45 v1(94.74,76.5) ; J8J13.34 57.52,11.68 58.16,12.32 58.16,23.75 58.8,24.38 v1(58.8,27.81) ; v1(41.27,269.42) 40.71,268.86 38.2,268.86 34.76,265.42 30.74,265.42 29.46,264.14 27.87,264.14 25.02,261.29 25.02,244.98 23.18,243.14 23.18,241.57 23.56,241.19 23.56,239.89 22.74,239.07 21.73,239.07 21.15,238.5 21.15,233.86 21.53,233.48 21.53,225.05 23.62,222.96 23.62,217.94 24.19,217.37 24.19,213.11 23.49,212.42 23.49,204.6 v1(22.22,203.33) 21.33,202.44 21.33,197.26 16.63,192.56 16.63,188.68 15.24,187.29 15.24,180.5 16.1,179.64 16.1,174.39 16.76,173.73 16.76,159.84 17.01,159.59 17.01,145.78 17.37,145.43 17.37,139.09 15.47,137.19 15.47,136.62 14.82,135.96 14.82,133.19 v1(13.58,131.95) 13.08,131.44 13.08,121.33 14.73,119.68 14.73,110.75 13.19,109.21 13.19,107.95 14.19,106.94 14.19,104.49 12.87,103.17 12.87,96.66 11.9,95.68 11.9,82.11 14.38,79.63 14.38,74.55 12.67,72.84 12.67,69.24 v1(13.2,68.71) ; v1(98.57,23.11) 98.57,27.53 96.13,29.97 96.13,46.61 96.52,46.99 v1(96.64,46.99) ; v1(36.83,79.5) 36.96,79.37 36.96,78.28 39.63,75.61 39.63,70.11 v1(38.22,68.71) 38.22,67.18 41.76,63.64 41.76,61.27 42.86,60.17 42.86,55.28 44.7,53.44 v1(44.7,52.83) ; v1(284.98,270) 284.86,269.87 v1(284.86,264.29)
  BOTTOM w0.1: v1(38.22,68.71) 37.97,68.96 37.97,69.98 36.7,71.25 30.98,71.25 29.11,69.37 27.97,69.37 24.63,66.04 22.6,66.04 18.41,61.85 15.62,61.85 14.6,62.86 14.6,67.31 v1(13.2,68.71) ; R7W4.1 83.82,26.92 83.82,25.93 v1(83.99,25.75) ; v1(88.13,237.23) 86.86,238.5 86.86,246.11 79.66,253.31 79.34,253.31 73.4,259.25 73.4,260.96 71.94,262.42 71.94,265.88 v1(72.51,266.44)
PLTRST_N_U2: length 13.7
  TOP w0.1: R5G25.2 R5G26.2 ; R5G25.2 156.46,69.98 v1(157.35,69.09) ; R5G25.2 R5G24.2
  BOTTOM w0.1: v1(157.35,69.09) 157.35,66.81 J5H1.B1
PLTRST_R_N: length 107.3
  TOP w0.089: U6E1.AV29 v1(95.96,144.13)
  TOP w0.1: R8F9.2 v1(24.38,125.09)
  LAY6 w0.125: v1(24.38,125.09) 21.84,127.63 21.84,139.98 v1(21.2,140.61)
  BOTTOM w0.1: v1(21.2,140.61) 21.71,140.1 21.71,139.41 22.09,139.03 23.14,139.03 24.04,138.13 24.04,133.6 25.15,132.49 29.1,132.49 29.1,132.49 29.64,132.49 30.33,131.8 37.4,131.8 38.98,133.38 42,133.38 42.54,132.84 43.18,132.84 44.7,134.36 47.46,134.36 48.19,133.64 54.08,133.64 57.97,137.52 62.8,137.52 64.73,139.44 66.42,139.44 R7R50.1 67.24,139.26 70.35,139.26 71.06,139.97 73.04,139.97 73.54,139.48 74.89,139.48 75.31,139.06 76.06,139.06 76.84,139.84 81.54,139.84 84.7,143.01 85.09,143.01 85.56,143.48 88.99,143.48 89.23,143.71 91.64,143.71 92.48,144.55 95.54,144.55 v1(95.96,144.13)
PLTRST_SPI_TPM: length 4.6
  TOP w0.1: J7G1.49 92.49,66.33 91.98,65.82 91.98,64.22 92.2,64.01 R7H3.2
PLTRST_TBT_RST_BUF_N: length 2.2
  TOP w0.1: R5G21.1 166.87,80.39 U5G2.4
PLTRST_TBT_RST_N: length 292.2
  TOP w0.089: 162.47,265.13 162.47,265.16 v2(162.17,265.46)
  TOP w0.1: v1(117.47,87.02) 118.33,87.02 119.5,85.85 128.65,85.85 133.47,81.02 154.17,81.02 156.14,79.06 156.14,78.55 R5G25.1 156.46,82.7 157.32,83.56 160.75,83.56 160.94,83.37 168.08,83.37 R5G18.2 169.16,82.29 169.16,81.02 R5G20.1 R5G21.2
  LAY5 w0.125: v1(128.14,216.15) 133.66,210.63 133.66,205.53 134.49,204.71 134.49,192.51 133.47,191.49 133.47,186.19 133.95,185.72 133.95,180.69 132.81,179.55 132.81,178.98 134.48,177.31 134.48,172.26 135.53,171.21 135.53,168.17 135.25,167.89 135.25,163.47 141.34,157.37 141.34,135.38 135.43,129.46 135.43,123.63 129.08,117.28 120.2,117.28 116.58,113.66 116.58,108.95 118.43,107.1 118.43,91.99 119.18,91.25 119.18,88.73 v1(117.47,87.02)
  LAY6 w0.125: v1(128.14,216.15) 128.14,217.3 126.61,218.82 126.61,226.31 125.73,227.2 125.73,235.87 125.13,236.47 125.13,237.79 125.98,238.64 125.98,239.91 131.82,245.75 131.82,247.89 138.22,254.3 141.32,254.3 142.99,255.97 142.99,256.66 144.21,257.88 145.85,257.88 146.49,258.52 149.19,258.52 150.45,259.78 155.05,259.78 155.88,260.6 157.48,260.6 162.17,265.29 v2(162.17,265.46)
PLTRST_TBT_RST_R_N: length 77.6
  TOP w0.1: v1(156.97,82.17) 160.65,82.17 160.9,81.91 R5G19.2 160.97,81.34 U5G2.2 164.17,81.34 164.78,81.95 164.78,82.61 165.1,82.93 R5G18.1 ; R6H4.2 v1(116.84,57.53)
  LAY5 w0.125: v1(117.78,79.32) 118.12,78.99 126.23,78.99 128.84,81.59 133.68,81.59 134.44,80.83 137.96,80.83 138.45,81.32 148.86,81.32 149.25,81.71 156.51,81.71 v1(156.97,82.17)
  BOTTOM w0.1: v1(117.78,79.32) 117.78,58.48 v1(116.84,57.53)
PLX_SX_ENTRY_AIC: length 12.6
  TOP w0.1: R6H42.2 130.68,34.16 130.68,30.35 128.65,28.32 125.12,28.32 J6J1.13
PLX_SX_ENTRY_BP_N: length 278.8
  TOP w0.1: EU5A1.18 v1(140.96,262.96) ; v1(129.66,37.08) 130.04,36.7 R6H43.2
  LAY5 w0.125: v1(118.69,91.06) 118.11,91.64 118.11,106.78 115.32,109.57 115.32,112.86 120.07,117.61 128.96,117.61 135.1,123.76 135.1,131.49 141.02,137.41 141.02,157.23 134.69,163.56 134.69,167.84 135.21,168.35 135.21,171.07 134.16,172.12 134.16,177.16 132.46,178.86 132.46,180.04 133.62,181.2 133.62,185.57 133.15,186.05 133.15,191.64 133.85,192.34 133.85,203.18 133.01,204.01 133.01,210.77 128.14,215.64 127.76,215.64 127.02,216.38 122.78,216.38 v1(121.92,215.52)
  LAY6 w0.125: v1(121.92,215.52) 120.9,216.53 120.52,216.53 117.96,219.1 117.96,221.77 117.09,222.63 117.09,231.77 117.91,232.59 117.91,237.55 119.04,238.68 119.04,239.84 126.37,247.17 126.37,248.74 129.96,252.33 130.68,252.33 140.2,261.85 140.2,262.51 140.66,262.96 v1(140.96,262.96) ; v1(118.69,91.06) 122.17,87.58 122.17,83.56 122.68,83.06 122.68,79.47 124.17,77.98 124.17,70.51 123.28,69.62 123.28,64.66 122.93,64.3 122.93,62.94 131.06,54.81 131.06,41.12 130.3,40.36 130.3,37.72 v1(129.66,37.08)
PLX_SX_ENTRY_EC: length 238.6
  TOP w0.1: R8F30.1 R8F24.2 v1(27.17,108.2) 27.17,108.08 26.42,107.32 U8F6.14 ; R5J19.1 136.01,7.75 v1(135.89,7.62)
  LAY3 w0.1: v1(135.89,7.62) 135.89,4.64 139,1.53 151.95,1.53 156.03,5.6 156.03,21.7 154.51,23.22 154.51,28.34 147.36,35.49 125.07,35.49 124.61,35.95 124.61,36.48 122.53,38.56 115.68,38.56 114.91,39.32 109.68,39.32 108.97,40.03 105.16,40.03 104.02,41.17 98.04,41.17 97.15,40.28 96.52,40.28 95.63,41.17 90.11,41.17 89.51,40.58 88.88,40.58 87.92,39.63 81.11,39.63 80.34,38.85 78.26,38.85 77.77,39.34 77.31,39.34 v1(76.83,38.86)
  LAY8 w0.1: v1(76.83,38.86) 76.32,39.37 75.69,39.37 72.2,42.85 71.16,42.85 62.7,51.31 60.23,51.31 55.5,56.03 55.5,59.68 50.6,64.57 49.21,64.57 48,65.78 48,68.58 45.82,70.76 45.82,78.29 42.87,81.24 42.87,83.78 41.09,85.56 41.09,95.31 38.04,98.36 38.04,105.28 37.58,105.73 37.1,105.73 33.94,108.89 27.86,108.89 v1(27.17,108.2)
PLX_SX_ENTRY_G1_N: length 195.2
  TOP w0.1: R6H42.1 130.55,35.43 130.93,35.81 R6H43.1 130.93,36.57 v1(129.66,37.84) ; R8F22.2 25.55,109.37 25.55,108.69 26.03,108.2 v1(26.41,108.2)
  LAY5 w0.125: v1(129.66,37.84) 130.17,37.34 130.17,35.05 128.27,33.15 122.28,33.15 121.57,33.86 113.17,33.86 112.97,33.65 106.65,33.65 105.76,34.55 102.75,34.55 101.72,33.52 63.54,33.52 62.27,32.25 50.35,32.25 49.93,32.67 47.46,32.67 45.46,34.67 39.62,34.67 39.11,34.16 34.82,34.16 33.67,33.01 28.96,33.01 27.43,34.54 v1(27.43,34.54)
  LAY6 w0.125: v1(27.43,34.54) 27.43,34.54 26.03,35.94 26.03,37.59 25.26,38.36 25.26,43.23 26.41,44.38 26.41,52.96 26.57,53.11 26.57,54.74 27.43,55.6 27.43,65.02 26.13,66.32 26.13,70.42 27.37,71.66 27.37,77.95 26.67,78.66 26.67,81.12 25.01,82.78 25.01,83.88 25.39,84.26 25.39,90.2 26.56,91.37 26.56,95.07 25.65,95.98 25.65,106.3 26.41,107.06 v1(26.41,108.2)
PLX_SX_ENTRY_G1_PCH_N: length 210.5
  TOP w0.089: 110.2,130.71 110.15,130.71 109.12,131.74 109.12,134.59 109.2,134.67 109.2,135.08 109.16,135.12 109.16,136.07 U6E1.L46
  TOP w0.1: v1(114.3,106.68) 114.55,106.93 114.55,109.22 113.91,109.85 113.91,110.88 112.06,112.74 112.06,117.19 112.27,117.39 112.27,129.44 110.99,130.71 110.2,130.71 ; R8F22.1 v1(26.03,111.5)
  LAY5 w0.125: v1(114.3,106.68) 113.63,106.02 113.63,97.64 95.11,79.12 94.07,79.12 92.16,77.21 92.16,75.7 89.48,73.02 88.61,73.02 82.4,66.8 76.15,66.8 72.99,63.64 71.57,63.64 71.32,63.39 69.92,63.39 69.28,62.75 67.64,62.75 65.69,60.8 54.17,60.8 52.93,59.57 49.33,59.57 47.56,57.8 47.1,57.8 45.46,56.16 45.46,55.75 44.32,54.61 33.88,54.61 33.37,54.1 v1(27.05,54.1)
  LAY6 w0.125: v1(27.05,54.1) 27.05,54.86 27.68,55.5 27.68,65.3 26.38,66.6 26.38,70.31 27.63,71.55 27.63,78.06 26.92,78.76 26.92,81.22 26.11,82.04 26.11,84.5 25.65,84.97 25.65,90.09 26.82,91.26 26.82,95.17 25.9,96.09 25.9,105.84 27.68,107.62 27.68,108.48 26.29,109.88 26.29,111.25 v1(26.03,111.5)
PM_BATLOW_N: length 502.1
  TOP w0.1: U8F6.93 30.42,91.89 30.6,92.07 v1(31.11,92.07) ; v1(112.01,254.38) 112.48,253.9 126.23,253.9 127.32,252.82 145.16,252.82 147.48,255.14 152.56,255.14 154.45,257.03 154.45,259.56 CR5A7.1 ; v1(111.22,4.82) 111.25,4.82 112.64,6.22 114.55,6.22 115.57,7.24 117.34,7.24 118.11,8 118.11,9.02 R6J27.2 118.61,10.54 118.61,11.97 J6J2.47
  LAY3 w0.1: J8J13.7 33.29,5.34 58.53,5.34 62.29,1.58 89.08,1.58 91.16,3.65 102.84,3.65 104.53,5.34 110.73,5.34 111.22,4.85 v1(111.22,4.82)
  LAY5 w0.125: v1(112.01,254.38) 111.24,253.61 107.75,253.61 107.23,254.12 104.16,254.12 103.51,253.47 96.72,253.47 96.42,253.16 93.22,253.16 93.04,252.99 83.11,252.99 82.13,253.96 78.26,253.96 73.02,259.21 72.51,259.21 71.62,258.32 62.1,258.32 61.72,257.94 60.7,257.94 60.45,257.68 59.81,257.68 58.54,258.95 54.96,258.95 54.32,258.32 52.69,258.32 51.9,257.53 40.27,257.53 v1(39.62,258.19)
  LAY6 w0.125: J8J13.7 31.52,7.59 30.48,8.63 30.48,9.78 30.86,10.16 30.86,29.21 31.18,29.53 31.18,36.48 30.33,37.32 30.33,39.54 29.95,39.92 29.95,42.55 30.59,43.18 30.59,46.69 32.13,48.23 32.13,51.27 32.64,51.78 32.64,53.85 32.42,54.06 32.42,57.64 32.26,57.81 32.26,59.03 32.55,59.32 32.55,65.35 31.09,66.81 31.09,68.56 31.87,69.33 31.87,71.89 32.55,72.57 32.55,73.93 30.43,76.05 30.43,82.34 29.48,83.29 29.48,88.01 31.11,89.64 v1(31.11,92.07) 30.73,92.45 30.73,93.75 30.22,94.26 30.22,100.57 31.87,102.22 31.87,105.23 31.43,105.67 31.02,105.67 30.23,106.46 30.23,108.99 29.27,109.95 29.27,111.39 28.64,112.02 28.64,116.52 27.81,117.35 27.81,121.92 28.06,122.17 29.1,122.17 29.97,123.04 29.97,124.3 29.05,125.22 29.05,126.49 29.97,127.4 29.97,131.32 27.9,133.39 27.9,136.4 28.39,136.89 28.39,145.09 29.2,145.89 29.2,165.62 30.43,166.86 30.43,176.7 29.46,177.67 29.46,180.24 35.38,186.16 35.38,190.67 34.88,191.18 34.88,196.01 36.19,197.32 36.19,199.14 35.43,199.91 35.43,200.66 36.4,201.63 36.4,205.47 31.46,210.42 31.46,211.78 31.07,212.17 31.07,216.74 30.64,217.16 30.64,222.58 29.76,223.47 29.76,227.47 28.74,228.49 28.74,229.6 29.84,230.7 29.84,235.67 29.54,235.96 29.54,240.08 31.12,241.65 31.12,243.43 32.63,244.95 32.63,246.15 35.68,249.2 35.68,249.43 38.73,252.47 38.73,257.3 v1(39.62,258.19)
PM_DPWROK_R13LH_N: length 6.6
  TOP w0.1: R8D39.2 R8D42.1 45.72,182.24 44.7,181.23 42.79,181.23 42.29,180.72 Q8D10.1
PM_SLP_S0_TTK_N: length 2.9
  TOP w0.1: J7G1.20 R7G30.1
PM_SLP_S3_TTK_N: length 3.1
  TOP w0.1: J7G1.19 73.44,64.9
PM_SLP_S4_TTK_N: length 3.1
  TOP w0.1: J7G1.21 74.71,64.9
PM_SLP_S5_TTK_N: length 2.9
  TOP w0.1: J7G1.26 R7G31.1
PMC_GPIO: length 33.8
  TOP w0.1: J9E2.1 6.73,156.97 9.27,156.97 R9E6.2 ; v1(23.21,150.72) 23.21,153.01 24.64,154.44 U8E3.10
  BOTTOM w0.1: J9E2.1 6.98,154.68 6.98,151.38 7.2,151.16 12.28,151.16 13.2,150.24 15.98,150.24 16.47,150.72 v1(23.21,150.72)
PMC_GPIO_PD: length 3.6
  TOP w0.1: R9E14.1 10.92,154.05 9.01,155.95 J9E2.2
PP_EXT1_BP: length 27
  TOP w0.1: R6A67.1 123.72,268.35 v1(123.06,269.01) ; EU5A1.48 142.96,271.25 v1(142.56,271.65)
  BOTTOM w0.1: v1(123.06,269.01) 123.38,269.01 125.28,267.11 129.44,267.11 130.74,268.41 130.74,269.68 134.23,273.18 141.73,273.18 142.11,272.79 142.11,272.11 v1(142.56,271.65)
PP_EXT1_BP_R: length 10.1
  TOP w0.1: R6A67.2 R6A69.1 ; R6A69.1 125.47,266.95 126.49,266.95 126.73,267.19 Q6A2.2 ; R6A69.1 124.96,267.33 124.58,266.95 122.3,266.95 122.04,267.21 122.04,268.1 121.92,268.22 120.52,268.22 120.36,268.38 Q6A1.3
PPV_BLT_CLK: length 49.8
  TOP w0.1: v1(67.33,19.94) 67.31,19.96 67.31,22.73 66.67,23.37 64,23.37 63.75,23.62 R7J12.1
  LAY5 w0.125: v1(67.33,19.94) 67.31,19.94 66.92,19.56 58.87,19.56 57.86,18.55 56.13,18.55 55.87,18.29 54.42,18.29 53.67,19.04 52.06,19.04 51.31,18.29 51.31,17.3 50.02,16 28.95,16 J8J5.3
PPV_BLT_DATA: length 38.6
  TOP w0.1: R7J14.1 v1(62.86,22.73)
  LAY5 w0.125: J8J5.1 27.94,21.08 29.14,22.29 30.28,22.29 30.73,22.73 38.6,22.73 38.99,22.34 46.25,22.34 46.72,21.87 50.47,21.87 51.66,23.06 53.41,23.06 53.59,23.24 62.35,23.24 v1(62.86,22.73)
PS2_KBCLK: length 212.8
  TOP w0.1: v1(24,89.41) 24.42,89.83 U8F6.78 ; U7H4.4 70.27,31.45 v1(70.28,31.44) ; J6J2.239 v1(148.93,12.14)
  LAY3 w0.1: v1(70.28,31.44) 70.76,30.96 73.05,30.96 74.06,31.98 75.93,31.98 76.45,31.46 77.25,31.46 78.03,32.25 81,32.25 81.78,31.47 84.04,31.47 84.82,32.25 100.64,32.25 102.33,30.56 103.88,30.56 104.71,29.73 110.19,29.73 111.38,28.54 114.75,28.54 115.45,27.84 139.28,27.84 142.29,24.83 142.29,22.93 144.14,21.08 144.14,16.82 144.55,16.41 144.55,13.05 144.9,12.7 148.36,12.7 v1(148.93,12.14)
  LAY5 w0.125: v1(21.33,32.51) 24.63,29.21 26.54,29.21 26.92,29.59 29.43,29.59 29.81,29.97 34.16,29.97 34.54,29.59 36.83,29.59 39.11,27.3 51.18,27.3 52.7,28.82 61.89,28.82 63.06,29.99 68.82,29.99 v1(70.28,31.44)
  LAY6 w0.125: v1(21.33,32.51) 22.73,33.91 22.73,43.56 23.27,44.1 23.27,46.57 25.22,48.52 25.22,51.13 24.5,51.86 24.5,53.13 25.53,54.17 25.53,56.63 26.18,57.28 26.18,63.61 25.1,64.68 25.1,74.89 25.57,75.36 25.57,80.8 24,82.37 24,83.82 23.48,84.34 23.48,85.21 23.92,85.65 23.92,89.33 v1(24,89.41)
PS2_KBDATA: length 205.4
  TOP w0.1: U8F6.79 24.82,91.97 v1(24,92.79) ; v1(140.71,24.26) 142.36,22.6 147.82,22.6 149.47,20.95 149.47,20.06 148.93,19.51 J6J2.234 ; v1(69.46,31.44) 69.62,31.6 U7H4.3
  LAY3 w0.1: v1(69.46,31.44) 70.17,30.74 73.14,30.74 74.16,31.75 75.84,31.75 76.37,31.22 77.44,31.22 78.25,32.02 80.91,32.02 81.71,31.22 84.11,31.22 84.91,32.02 100.55,32.02 102.23,30.33 103.78,30.33 104.62,29.5 110.1,29.5 111.29,28.31 114.66,28.31 115.36,27.61 134.05,27.61 137.41,24.26 v1(140.71,24.26)
  LAY5 w0.125: v1(69.46,31.44) 68.26,30.24 62.95,30.24 61.78,29.08 52.59,29.08 51.07,27.55 39.57,27.55 37.02,30.1 34.79,30.1 34.41,30.48 29.46,30.48 29.08,30.1 27.17,30.1 26.28,30.99 v1(25.65,30.99)
  LAY6 w0.125: v1(25.65,30.99) 25.01,31.62 25.01,33.65 24.76,33.91 24.76,43.44 25.72,44.4 25.72,51.34 25,52.07 25,52.92 26.03,53.96 26.03,54.92 26.93,55.81 26.93,64.81 25.63,66.11 25.63,71.07 26.07,71.51 26.07,81.01 24.51,82.57 24.51,85.03 24.18,85.36 24.18,88.69 24.51,89.03 24.51,92.28 v1(24,92.79)
PS2_MSCLK: length 222.7
  TOP w0.1: v1(20.71,97.03) 20.65,97.09 U8F6.52 ; U7H4.8 v1(72.87,31.44) ; J6J2.215 v1(145.12,13.16)
  LAY3 w0.1: v1(145.12,13.16) 145.79,13.84 145.79,15.49 144.37,16.92 144.37,21.17 142.52,23.03 142.52,24.92 139.37,28.07 115.55,28.07 114.85,28.77 111.48,28.77 110.29,29.96 104.8,29.96 103.97,30.79 102.42,30.79 100.73,32.48 77.94,32.48 77.15,31.69 76.54,31.69 76.03,32.2 73.63,32.2 v1(72.87,31.44)
  LAY5 w0.125: v1(19.3,32.38) 19.3,31.49 21.59,29.21 22.73,29.21 24.89,27.05 28.82,27.05 30.86,25.01 33.39,25.01 35.43,27.05 37.38,27.05 39.92,24.51 41.14,24.51 41.52,24.89 42.29,24.89 42.67,24.51 49.4,24.51 49.65,24.76 50.67,24.76 51.69,25.79 51.69,26.17 52.57,27.05 57.1,27.05 58.37,28.32 62.1,28.32 63.27,29.49 71.14,29.49 72.87,31.22 v1(72.87,31.44)
  LAY6 w0.125: v1(20.71,97.03) 19.88,96.19 19.88,84.53 20.7,83.71 20.7,79.63 20.32,79.25 20.32,78.11 19.42,77.21 19.42,70.36 19.7,70.08 19.7,65.9 20.25,65.35 20.25,57.6 21.2,56.64 21.2,52.83 20.25,51.87 20.25,49.48 19.49,48.72 19.49,40.96 20.18,40.27 20.18,33.39 19.3,32.51 v1(19.3,32.38)
PS2_MSDATA: length 205.9
  TOP w0.1: v1(72.13,31.44) 72.22,31.53 U7H4.7 ; U8F6.88 28.42,92.35 v1(27.81,92.96) ; J6J2.210 v1(145.12,18.49)
  LAY3 w0.1: v1(145.12,18.49) 144.59,19.01 144.59,21.27 142.74,23.12 142.74,25.02 139.47,28.29 115.64,28.29 114.94,28.99 111.57,28.99 110.38,30.18 104.9,30.18 104.07,31.01 102.52,31.01 100.83,32.7 73.39,32.7 v1(72.13,31.44)
  LAY5 w0.125: v1(27.94,27.56) 37.58,27.56 40.13,25.01 40.94,25.01 41.32,25.39 43.38,25.39 43.76,25.01 49.14,25.01 49.91,25.78 50.6,25.78 52.37,27.56 57.25,27.56 58.26,28.57 61.99,28.57 63.16,29.74 70.63,29.74 72.13,31.24 v1(72.13,31.44)
  LAY6 w0.125: v1(27.94,27.56) 27.04,28.45 27.04,32.25 28.32,33.53 28.32,34.54 27.3,35.56 27.3,36.83 26.41,37.72 26.41,43.67 26.91,44.17 26.91,52.54 29.46,55.08 29.46,56.11 28.57,57 28.57,65.53 27.24,66.86 27.24,70.1 28.38,71.24 28.38,79.09 27.43,80.05 27.43,82.45 26.87,83.01 26.87,88.05 26.4,88.52 26.4,90.14 27.32,91.05 27.32,92.47 v1(27.81,92.96)
PS2_OE_N: length 3.1
  TOP w0.1: R7J1.1 68.07,30.99 68.07,31.49 68.32,31.75 U7H4.1
PS_ON_1G97_OUT: length 382.9
  TOP w0.1: CR4J1.1 174.49,4.19 v1(173.48,5.21) R4J8.1 ; U8D9.4 28.76,172.53 29.08,172.85 CR8D2.3 29.52,171.83 30.22,171.13 30.22,169.38 29.97,169.13 28.58,169.13 26.61,171.1 20.03,171.1 19.45,171.68 11.96,171.68 10.16,173.48 6.22,173.48 5.74,173.96 v1(5.74,173.99)
  LAY5 w0.125: v1(5.74,173.99) 5.71,173.99 3.17,171.45 3.17,16.25 5.46,13.97 5.46,6.35 8.29,3.51 21.77,3.51 23.88,1.4 88.85,1.4 89.63,2.18 101.38,2.18 104.51,5.31 111.75,5.31 112.18,5.73 117.02,5.73 117.9,4.85 126.91,4.85 127.95,3.81 138.32,3.81 138.96,3.18 139.72,3.18 140.29,3.74 140.29,4.17 140.97,4.85 146.68,4.85 147.93,6.1 153.13,6.1 155.68,8.65 172.58,8.65 173.48,7.75 v1(173.48,5.21)
PS_ON_B: length 472.6
  TOP w0.1: R8F56.1 43.43,121.79 v1(42.41,122.81) ; R6J11.1 v1(121.79,21.74) ; R4J4.1 175.76,7.75 175.76,22.99 J4J1.2 ; v1(27.55,171.7) 26.41,171.7 R8D72.1 ; R8F51.2 v1(41.02,99.95) ; R8D60.1 v1(39.75,175.64)
  LAY5 w0.125: v1(86.86,2.54) 87.75,1.65 88.75,1.65 89.53,2.43 101.28,2.43 104.41,5.56 111.65,5.56 112.07,5.99 117.12,5.99 118,5.1 127.02,5.1 128.06,4.07 138.42,4.07 139.06,3.43 139.62,3.43 140.04,3.85 140.04,4.28 140.86,5.1 146.58,5.1 147.82,6.35 153.03,6.35 169.92,23.24 172.97,23.24 J4J1.2 ; v1(44.83,74.8) 45.72,73.91 50.46,73.91 51.17,74.62 52.82,74.62 53.25,75.05 53.25,75.73 53.97,76.45 54.98,76.45 56.19,77.66 58.58,77.66 58.86,77.39 71.16,77.39 72.87,79.09 73.7,79.09 76.02,81.41 79.83,81.41 81.63,83.21 82.56,83.21 83.06,83.71 85.35,83.71 92.35,90.72 92.35,93.04 91.85,93.55 91.85,101.38 92.32,101.85 v1(92.32,102.61)
  LAY6 w0.125: v1(92.32,102.61) 92.32,101.79 91.51,100.97 91.51,93.93 92.1,93.34 92.1,88.67 91.43,88 91.43,80.58 92.9,79.11 92.9,74.49 92.13,73.72 92.13,68.37 92.71,67.79 92.71,56.77 93.19,56.28 93.19,46.26 94.68,44.77 94.68,39.9 92.58,37.8 92.58,30.91 v1(92.83,30.66) 92.83,27.69 91.94,26.8 91.94,21.33 88.78,18.17 88.78,4.43 86.89,2.54 v1(86.86,2.54) ; v1(44.83,74.8) 43.69,75.94 43.69,81.14 42.86,81.97 42.86,91.02 41.4,92.49 41.4,98.04 41.65,98.3 41.65,99.31 v1(41.02,99.95) 41.78,100.71 41.78,101.58 41.01,102.34 41.01,104.73 40.49,105.25 40.49,111.18 41.78,112.47 41.78,122.17 v1(42.41,122.81) 41.78,123.44 41.78,133.13 41.42,133.48 41.42,135.2 40.35,136.28 40.35,149.36 40,149.71 40,151.64 38.86,152.78 38.86,162.38 39.66,163.18 39.66,171.84 39.52,171.98 39.52,175.41 v1(39.75,175.64)
  BOTTOM w0.1: v1(121.79,21.74) 121.18,22.35 118.99,22.35 115.69,25.65 112.58,25.65 111.34,24.41 108.05,24.41 106.17,26.29 100.46,26.29 95.64,31.11 93.29,31.11 v1(92.83,30.66) ; v1(39.75,175.64) 38.35,175.64 37.08,174.37 37.08,173.86 36.83,173.61 34.79,173.61 34.54,173.86 31.49,173.86 30.86,174.5 29.21,174.5 27.55,172.85 v1(27.55,171.7) ; v1(92.32,102.61) 91.82,103.12 91.82,103.66 91.1,104.37 91.1,106.28 90.59,106.79 90.59,109.9 92.01,111.32 92.01,114.91 93.21,116.11 R7T9.2
PS_ON_IN_EC_N: length 188
  TOP w0.1: v1(41.02,99.19) 40.76,99.44 39.87,99.44 R8F51.1 38.6,99.95 37.59,100.96 35.12,100.96 34.2,101.89 U8F6.121 ; J6J2.138 v1(132.66,19.51)
  LAY3 w0.1: v1(133.69,30.99) 131.31,30.99 131,30.67 129.95,30.67 128.33,32.3 120.26,32.3 118.5,34.07 116.08,34.07 114.77,35.38 108.08,35.38 107.41,36.05 90.39,36.05 90.1,35.76 87.53,35.76 87.22,36.07 77.08,36.07 76.44,35.42 70.49,35.42 69.72,36.19 68.96,36.19 68.7,35.94 66.67,35.94 63.24,39.37 60.16,39.37 59.34,40.2 55.6,40.2 53.12,42.67 50.96,42.67 49.84,43.79 47.83,43.79 47.65,43.97 44.73,43.97 43.96,43.2 42.44,43.2 41.65,42.42 40.35,42.42 40,42.77 40,44.45 46.6,51.05 46.6,53.97 45.84,54.74 45.84,57.53 42.03,61.34 42.03,62.76 37.91,66.89 37.91,68.23 37.71,68.43 37.71,77.85 37.28,78.27 37.28,90.42 37.08,90.63 37.08,94.74 37.84,95.5 37.84,96.01 v1(41.02,99.19)
  LAY8 w0.1: v1(133.69,30.99) 134.19,30.48 134.19,21.92 133.29,21.02 133.29,20.14 v1(132.66,19.51)
PS_ON_LED: length 1.5
  TOP w0.38: R8F55.2 49.02,117.98 CR8F5.1
PS_ON_LED_GATE: length 1.6
  TOP w0.1: Q8F1.1 43.81,118.62 R8F56.2
PS_ON_LED_R: length 2.7
  TOP w0.38: Q8F1.3 45.66,119.89 CR8F5.2
PS_ON_N: length 275.9
  TOP w0.1: v1(194.18,56.64) 196.08,56.64 R4H5.2 R4H8.1 ; J4J4.1 170.56,15.75 170.56,9.84 171.32,9.08 ; R8G47.1 v1(27.86,78.87) R8G46.1
  LAY5 w0.125: v1(25.78,39.75) 26.03,39.5 30.53,39.5 31.03,38.99 32.89,38.99 33.16,38.72 36.1,38.72 36.36,38.98 38.03,38.98 38.53,38.48 39.49,38.48 39.74,38.73 42.66,38.73 43.43,39.5 44.7,39.5 45.07,39.87 54.1,39.87 54.92,40.69 60,40.69 60.64,40.05 62.66,40.05 63.5,40.89 68.75,40.89 69.59,40.05 76.97,40.05 77.45,40.53 81.58,40.53 82.06,40.05 87.69,40.05 91.73,44.1 121.24,44.1 121.39,44.25 126.53,44.25 127.21,43.57 151.16,43.57 151.33,43.41 154.74,43.41 160.49,49.17 164.27,49.17 167.68,52.58 v1(170.3,52.58) 173.21,52.58 178.92,58.29 185.42,58.29 186.05,57.66 192.27,57.66 192.53,57.91 193.42,57.91 193.67,57.66 193.67,57.15 v1(194.18,56.64)
  LAY6 w0.125: v1(27.86,78.87) 28.13,78.59 28.13,71.35 26.99,70.21 26.99,66.75 28.32,65.42 28.32,56.89 29.21,56.01 29.21,55.19 26.66,52.65 26.66,44.27 26.03,43.64 26.03,40 v1(25.78,39.75)
  BOTTOM w0.1: v1(170.3,52.58) 170.3,52.32 170.76,51.86 170.76,27 170.3,26.54 170.3,18.29 J4J4.1
