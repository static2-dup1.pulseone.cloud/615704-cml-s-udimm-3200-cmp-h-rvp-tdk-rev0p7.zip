# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Nets (continued)
V1P05A_EN: C5G8.1 EU5G3.3 R5G9.2(B) R5G12.2(B) R8E68.1
V1P05A_FB: C5G7.1 EU5G3.4 R5G2.1 R5G4.1
V1P05A_FB_R: C5G7.2(B) R5G4.2(B) R5G6.1 R5G8.1
V1P05A_LG: EU5G3.6 R5G7.1
V1P05A_LG_R: EU5G1.4 R5G7.2(B)
V1P05A_MECC_R: R6J24.1 R6J30.2(B)
V1P05A_PWRGD: EU5G3.1 R5G13.2(B) R8D84.1 R8D89.2(B) U8D14.1
V1P05A_RF: EU5G3.5 R5G1.2(B)
V1P05A_SENSE_EAC_NEG: R4H13.2(B) U4H1.B1
V1P05A_SENSE_EAC_POS: R4H14.2(B) U4H1.A1
V1P05A_SENSE_NEG: R4H13.1 R6F37.4(SENB)
V1P05A_SENSE_POS: R4H14.1 R6F37.3
V1P05A_SNB: C5U1.1 R5U2.2(B)
V1P05A_SW: C5G9.2(B) EU5G1.5 EU5G2.1 EU5G2.2 EU5G2.3(S3) EU5G3.8 L5G1.1 R5U2.1
V1P05A_UG: EU5G3.9 R5G17.1
V1P05A_UG_R: EU5G2.4 R5G17.2(B)
V1P05A_VAL_EN: R8E68.2(B) U8E5.4
V1P05A_VAL_FB: R8E63.1 R8E64.2(B) U8E5.5
V1P05A_VAL_SW: L8E3.1 U8E5.2
V1P05A_VAL_VIN: C8E11.1 C8E14.1 R8E49.2(B) U8E5.3(VIN)
V1P05A_VCC: C5G6.1 EU5G3.7(VCC) R5G5.2(B) R5G11.2(B)
V1P05A_VIN: C5G10.1 C5G11.1 C5G12.1 C5G13.1 EU5G2.5 R5G11.1 R5G14.1
V1P05A_VIN_MIX: R5G14.2 R5G15.2(B) R5G16.2(B)
V1P8_AUD_EN_R: R6A19.2(B) U6A2.2
V1P8_TCHPNLIO_DISCHRG: Q8D8.3 R7D5.2(B)
V1P8_TCHPNLIO_EN: Q8C15.1 Q8E4.1 R8C71.1 SW7C1.7
V1P8_TCHPNLIO_EN_DIPSW: R7C26.2(B) SW7C1.2
V1P8A_EN: C8F14.1 EU8F2.5 R8F37.2(B) R8F44.2(B)
V1P8A_EN_R: CR8F4.1 CR8F4.2 R8F37.1
V1P8A_FB: C8F16.2(B) EU8F2.6 R8F41.2(B) R8F46.1
V1P8A_LX: EU8F2.1 EU8F2.2 EU8F2.3 L8F2.1
V1P8A_PCH_VAL_EN: R8E28.2(B) U8E2.4
V1P8A_PCH_VAL_FB: R8E22.1 R8E23.2(B) U8E2.5
V1P8A_PCH_VAL_SW: L8E1.1 U8E2.2
V1P8A_PCH_VAL_VIN: C8E2.1 C8E5.1 R8E14.2(B) U8E2.3(VIN)
V3DUAL_PCHVIN_NCH: EU8G2.4 R8G41.2(B)
V3P3_AUD_EN_R: R8A9.2(B) U8A1.2
V3P3_AUD_SLEW: C8A3.1 U8A1.7
V3P3_AUX_RST: R8D61.2(B) R8D66.1 U8D5.2
V3P3_DUAL_R: EU8G2.5 Q8G7.3 R8G69.1
V3P3A_AUX_LS: R8B34.1 U8B3.5
V3P3A_FET_CTRL: C8D8.2(B) C8D14.2(B) R6J15.2(B) R7H65.1 R8D24.1 R8D29.2(B) R8G9.1
V3P3A_FET_CTRL_VAL: C7H7.1 Q7H3.1 R7H65.2(B)
V3P3A_PCH_VAL_EN: R8E44.2(B) U8E4.4
V3P3A_PCH_VAL_FB: R8E41.1 R8E42.2(B) U8E4.5
V3P3A_PCH_VAL_SW: L8E2.1 U8E4.2
V3P3A_PCH_VAL_VIN: C8E6.1 C8E9.1 R8E37.2(B) U8E4.3(VIN)
V3P3A_VAL_R: Q7H3.3 R7H70.1
V3P3AUX_EN: R8C5.2(B) U8B3.2
V3P3AUX_EN_R: R8C5.1 U8D5.4(Y)
V3P3AUX_SLEW: C8B35.1 U8B3.7
V3P3DSW_EN: C9G4.1 EU8G1.5 R8G16.2(B) R9G21.1
V3P3DSW_EN_R: J9G5.1 R9G21.2(B)
V3P3DSW_FB: C8G5.2(B) EU8G1.6 R8G15.1 R8G18.2(B)
V3P3DSW_LX: EU8G1.1 EU8G1.2 EU8G1.3 L8G1.1
V3P3DSW_PCH_VAL_EN: R8E5.2(B) U8E1.4
V3P3DSW_PCH_VAL_FB: R8E6.1 R8E7.2(B) U8E1.5
V3P3DSW_PCH_VAL_SW: L8D1.1 U8E1.2
V3P3DSW_PCH_VAL_VIN: C8D32.1 C8E1.1 R8D86.2(B) R8E5.1 U8E1.3(VIN)
V3P3DSW_VAL_EN: C8F22.1 R8F12.2(B) U8F4.4
V3P3DSW_VAL_FB: R8F10.1 R8F11.2(B) U8F4.5
V3P3DSW_VAL_SW: L8F1.1 U8F4.2
V3P3DSW_VAL_VIN: C8F3.1 C8F6.1 R8F3.2(B) R8F12.1 U8F4.3(VIN)
V3P3DUAL_PCH_R: Q8D6.3 R8C83.2(B) R8D5.1 R8D6.1
V3P3DUAL_PCH_R1: Q8D1.6 Q8D6.2(S) R8D5.2(B)
V3P3DUAL_PCHVIN_NCH: Q8D1.3 R8D18.2(B) R8G41.1
V3P3DUAL_PCHVIN_PCH: C8C28.1 R8D6.2(B) R8G44.1
V3P3DX_CPU_SSD2_NCH: C5C42.1 EU5C1.4 EU5C5.4 Q5C3.3 Q5C4.3 R5C48.2(B) R5C69.1
V3P3DX_CPU_SSD2_PCH: C5C20.1 CR5C1.2 Q5C1.4 R5C19.2(B)
V3P3DX_SDCARD_SR_CAP: C8C27.2(B) U8C6.7
V3P3S_DETECT: C8D2.1 Q8D3.3 R8D10.1 R8D16.2(B)
V3P3S_DRAIN: Q4H2.6 R4G23.2(B) R4G24.2(B)
V5.0DX_SSD_SENSE_EAC_NEG: R4H15.2(B) U4H1.A2
V5.0DX_SSD_SENSE_EAC_POS: R4H16.2(B) U4H1.A3
V5.0DX_SSD_SENSE_NEG: R4H15.1 R6J31.4(SENB)
V5.0DX_SSD_SENSE_POS: R4H16.1 R6J31.3
V5_AUD_EN_R: R6A13.2(B) U6A1.2
V5_AUD_SLEW: C6A1.1 U6A1.7
V5A_FET_CTRL: C8D10.2(B) C8D11.2(B) R5J7.2(B) R7H64.1 R8D27.1 R8D28.2(B) R8G42.1
V5A_FET_CTRL_VAL: C7H6.1 Q7H2.1 R7H64.2(B)
V5A_VAL_R: Q7H2.3 R7H71.1
V5DUAL_PCHVIN_NCH: EU4G1.4 Q4G1.3 R4G5.2(B)
V5DUAL_PCHVIN_PCH: C4G6.1 Q4G2.4 R4G7.2(B) R6J13.2(B)
V5DUAL_RC: C4H10.2(B) C4H12.2(B) C4H15.2(B) Q4H4.3 R4H30.1 R4H34.2(B) R4H39.1 R4H49.1
V5DX_SSD_SR_CAP: C6J1.1 U6J1.7
V5S_DRAIN: Q4H2.3 R4G25.2(B) R4H1.2(B) R4H2.2(B)
V10A_CP: CR1B2.2 CR5B2.2 R1B11.2(B)
V10A_CP_R: C1B1.1 CR1B1.3(C) R1B11.1 U1B1.5
V12S_CPU_V10A: CR1B2.1(C) CR1B3.1(C) R1B14.2(B) R1B29.2(B)
V12S_DETECT: C8D4.1 Q8D4.3 R8D13.1 R8D17.2(B)
V12S_DRAIN: Q3G2.3 R3H4.2(B) R3H8.2(B) R3H9.2(B) R3H19.2(B) R3H22.2(B) R3H27.2(B)
V12S_VCCSA_V10A: CR5B2.1(C) CR5B3.1(C) R5B55.2(B) R5B56.2(B)
VCC_1P8A_PWRGD: EU8F2.4 R5G12.1 R8E4.1
VCC_3P3A_PWRGD: Q8D14.3 R8E1.1
VCC_3P3DSW_PWRGD: EU8G1.4 R8D26.1 R8D32.2(B) R8D43.1
VCC_HDLED_PWR: CP9H1.4 J9H1.1 R9H2.2(B) R9H3.2(B)
VCCCORE_SENSE_N: J3D1.C16 R2B24.2(B) TP2B1.1(TP)
VCCCORE_SENSE_P: J3D1.B16 R2B32.2(B) TP2B5.1(TP)
VCCGT_BT_PH1: C1D3.1 EU1D1.5
VCCGT_BT_PH1_R: C1D3.2(B) R1D4.2(B)
VCCGT_BT_PH2: C1D9.1 EU1D2.5
VCCGT_BT_PH2_R: C1D9.2(B) R1D7.2(B)
VCCGT_COMP: C1C1.1 EU1B1.39 R1C3.1
VCCGT_IC_FB: C1C1.2(B) C1C6.1 EU1B1.40 R1C3.2(B) R1C6.1 R1C7.1
VCCGT_IMON: EU1B1.27 R2B56.2(B)
VCCGT_ISEN1N: EU1B1.43 R1B46.2(B)
VCCGT_ISEN1N_R: C1B22.1 C1C4.1 ISO2D1.2(B<0>) R1B46.1 R1C2.1
VCCGT_ISEN1P: C1B22.2(B) EU1B1.44 R1C2.2(B) R1C11.2(B)
VCCGT_ISEN1P_R: ISO2D2.2(B<0>) R1C20.1
VCCGT_ISEN2N: EU1B1.41 R1C1.2(B)
VCCGT_ISEN2N_R: C1C2.1 C1C5.1 ISO2D3.2(B<0>) R1C1.1 R1C5.1
VCCGT_ISEN2P: C1C2.2(B) EU1B1.42 R1C5.2(B) R1C8.2(B)
VCCGT_ISEN2P_R: ISO2D4.2(B<0>) R1C17.1
VCCGT_NTC1N: ISO2C1.2(B<0>) RT2D1.1
VCCGT_NTC1P: R2C9.1 RT2D1.2(B<0>)
VCCGT_PH1: EU1D1.7 R1D4.1
VCCGT_PH1_SNB: C1P2.1 R2P4.2(B)
VCCGT_PH1_VCIN: C1D4.1 EU1D1.3 R1D5.2(B)
VCCGT_PH1_VDRV: C1D5.1 EU1D1.29 R1D6.1
VCCGT_PH2: EU1D2.7 R1D7.1
VCCGT_PH2_SNB: C2P1.1 R2P6.2(B)
VCCGT_PH2_VCIN: C1D10.1 EU1D2.3 R1D8.2(B)
VCCGT_PH2_VDRV: C1D11.1 EU1D2.29 R1D9.1
VCCGT_PWM_PH1: EU1B1.50 R1P2.1
VCCGT_PWM_PH1_R: EU1D1.1 R1P2.2(B)
VCCGT_PWM_PH2: EU1B1.49(PWMA2) R1P3.1
VCCGT_PWM_PH2_R: EU1D2.1 R1P3.2(B)
VCCGT_SENSE: J3D1.AB37 R1C14.2(B) TP1C1.1(TP)
VCCGT_SENSE_IC_N: EU1B1.37 R1C9.1 R1C13.1
VCCGT_SENSE_IC_P: EU1B1.38 R1C4.2(B) R1C10.2(B) R1C14.1
VCCGT_TSEN: EU1B1.30 R2C8.2(B) RT2D2.1
VCCGT_VSWH_PH1: EU1D1.16 EU1D1.24 ISO2D2.1 L2D1.1 R2P4.1
VCCGT_VSWH_PH2: EU1D2.16 EU1D2.24 ISO2D4.1 L2D2.1 R2P6.1
VCCGT_ZCD#_PH1: EU1D1.2(ZCD_EN_N) R1P1.2(B)
VCCGT_ZCD#_PH2: EU1D2.2(ZCD_EN_N) R1P4.2(B)
VCCIO_0_BT: EU5C3.5 R5C59.1
VCCIO_0_BT_R: C5C38.2(B) R5C59.2(B)
VCCIO_0_CS: EU5C3.14 R5C47.1
VCCIO_0_EN: C5E7.1 CR5E1.1 EU5C3.3 R5B24.1 R5E10.2(B) R5E11.2(B) R5E12.2(B) R5E13.2(B) R8D54.1
VCCIO_0_FB: EU5C3.13 R5C38.1 R5C39.1 R5C44.2(B)
VCCIO_0_G0: EU5C3.10 R5C35.2(B) R5C43.1
VCCIO_0_G1: EU5C3.11 Q5E2.3 R5C36.2(B) R5C42.1
VCCIO_0_LG: EU5C3.8 R5C52.2(B)
VCCIO_0_LG_R: EU5C4.5 R5C52.1
VCCIO_0_LPM_N: EU5C3.4 R5C56.1 R5C72.2(B)
VCCIO_0_MODE: EU5C3.1 R5C54.1 R5C58.2(B)
VCCIO_0_PWRGD: Q5D1.2 R5C55.2(B) R5C64.2(B) R5C70.1
VCCIO_0_PWRGD_R: EU5C3.2 R5C55.1
VCCIO_0_RGND: EU5C3.12 R5C40.1 R5C41.1
VCCIO_0_SENSE: J3D1.D5 R5C39.2(B)
VCCIO_0_SNB: C5C41.2(B) R5D1.1
VCCIO_0_UG: EU5C3.6 R5C51.2(B)
VCCIO_0_UG_R: EU5C4.3 R5C51.1
VCCIO_0_VIN: C4C15.1 C4C17.1 C4C18.1 C5C32.1 C5C33.1 EU5C4.1 R4C19.1
VCCIO_0_VSW: C5C38.1 EU5C3.7 EU5C4.6 EU5C4.7 EU5C4.8(VSW_3) L4C1.1 R5D1.2(B)
VCCIO_1_2_AND: R5E58.1 U5E1.4(Y)
VCCIO_1_2_BT: EU5D2.5 R5D31.1
VCCIO_1_2_BT_R: C5D22.2(B) R5D31.2(B)
VCCIO_1_2_CS: EU5D2.14 R5D24.1
VCCIO_1_2_EN: CR5E1.2 EU5D2.3 R4J9.1 R5D34.2(B) R5E58.2(B) R5E59.2(B)
VCCIO_1_2_EN_DIODE: CR4J1.2 R4J9.2(B)
VCCIO_1_2_EN_MIX: C5E5.1 R5E4.2(B) R5E7.2(B) R5E59.1 R7B32.2(B) R7B33.2(B) U5E1.2
VCCIO_1_2_FB: EU5D2.13 R5D19.1 R5D20.1 R5D23.2(B)
VCCIO_1_2_G0: EU5D2.10 R5D17.2(B) R5D22.1
VCCIO_1_2_G1: EU5D2.11 R5D16.2(B) R5D21.1
VCCIO_1_2_LG: EU5D2.8 R5D26.2(B)
VCCIO_1_2_LG_R: EU5D3.5 R5D26.1
VCCIO_1_2_LPM_N: EU5D2.4 R5D30.1 R5D42.2(B)
VCCIO_1_2_MODE: EU5D2.1 R5D28.1 R5D32.2(B)
VCCIO_1_2_PWRGD: Q5E1.2 R5C71.1 R5D33.1 R5D35.2(B)
VCCIO_1_2_PWRGD_R: EU5D2.2 R5D33.2(B)
VCCIO_1_2_SENSE: J3D1.AE4 R5D20.2(B)
VCCIO_1_2_SNB: C5D28.2(B) R5D36.1
VCCIO_1_2_UG: EU5D2.6 R5D25.2(B)
VCCIO_1_2_UG_R: EU5D3.3 R5D25.1
VCCIO_1_2_VIN: C5D19.1 C5D20.1 C5D23.1 C5D24.1 C5D25.1 EU5D3.1 R5D29.1
VCCIO_1_2_VSW: C5D22.1 EU5D2.7 EU5D3.6 EU5D3.7 EU5D3.8(VSW_3) L5D1.1 R5D36.2(B)
VCCIO_EN_DIODE: CR8D2.2 R8D54.2(B)
VCCIO_PWRGD: R5C57.1 R5C60.2(B) R5C70.2(B) R5C71.2(B)
VCCIO_PWRGD_R: Q5D1.3 Q5E1.3 R5C60.1 R5D39.2(B)
VCCMPHY_SENSE: R5G6.2(B) U6E1.K47
VCCPDSW_3P3A_SENSE_EAC_NEG: R4H42.2(B) U4H1.D2
VCCPDSW_3P3A_SENSE_EAC_POS: R4H43.2(B) U4H1.D3
VCCPDSW_3P3A_SENSE_NEG: R4H42.1 R7F1.4(SENB)
VCCPDSW_3P3A_SENSE_POS: R4H43.1 R7F1.3
VCCPGPPA_3P3_1P8_R: R7R43.2(B) R7R44.2(B) R7R45.2(B) R7R46.2(B) R7R48.1
VCCPGPPBC_3P3_1P8_R: R7R29.2(B) R7R30.2(B) R7R31.2(B) R7R32.2(B) R7R37.1
VCCPGPPD_3P3_1P8_R: R7R25.2(B) R7R26.2(B) R7R27.2(B) R7R28.2(B) R7R36.1
VCCPGPPEF_3P3_1P8_R: R7T20.2(B) R7T21.2(B) R7T22.1 R7T23.2(B) R7T24.2(B)
VCCPGPPHK_3P3_1P8_R: R6T8.2(B) R6T10.2(B) R6T12.1 R6T14.2(B) R6T16.2(B)
VCCPRIM_1P8_SENSE_EAC_NEG: R4H40.2(B) U4H1.C1
VCCPRIM_1P8_SENSE_EAC_POS: R4H41.2(B) U4H1.D1
VCCPRIM_1P8_SENSE_NEG: R4H40.1 R7P10.4(SENB)
VCCPRIM_1P8_SENSE_POS: R4H41.1 R7P10.3
VCCPSPI_PCH_3P3_1P8_R: R7R1.2(B) R7T2.2(B) R7T4.1
VCCSA_BG: EU5B1.5 R5B73.2(B)
VCCSA_BG_R: EU5B2.11 R5B73.1
VCCSA_BT: EU5B2.8 R5B88.2(B)
VCCSA_BT_R: C5M3.1 R5B88.1
VCCSA_COMP: C5B43.2(B) EU5B2.23 R5B70.2(B)
VCCSA_EN: C5B17.1 EU5B2.2 R5B24.2(B) R5B27.2(B) R5B91.2(B)
VCCSA_FB: C5B42.2(B) C5B43.1 EU5B2.24 R5B69.1 R5B70.1 R5B71.2(B)
VCCSA_IMON: EU5B2.18 R5B65.1
VCCSA_ISENN: C5M1.1 EU5B2.21 ISO17528.2(B<0>) R5M4.1
VCCSA_ISENP: C5M1.2(B) EU5B2.20 R5M3.2(B) R5M5.1 RT5B1.1
VCCSA_ISENP_L: ISO17599.2(B<0>) R5M1.1
VCCSA_PG: EU5B2.7 R5B80.1
VCCSA_PSYS: EU5B2.19 R5B64.2(B)
VCCSA_PVCC: C5B41.1 EU5B2.12 R5B72.2(B)
VCCSA_RGND: C5B38.2(B) C5B39.1 EU5B2.22 R5B60.1 R5B63.1
VCCSA_SENSE: J3D1.C6 R5B59.2(B)
VCCSA_SET1: EU5B2.28 R5B81.2(B) R5B84.1
VCCSA_SET2: EU5B2.27 Q5M2.2(SRC) R5B77.1 R5B78.2(B) R5B79.1
VCCSA_SET3: EU5B2.26 R5B74.1 R5B75.2(B)
VCCSA_SNB: C5M2.1 R5M2.2(B)
VCCSA_SVID_ALERT_N: EU5B2.5 Q5M4.2(SRC) R5B85.1
VCCSA_SVID_CLK: EU5B2.6 R5B83.1
VCCSA_SVID_DATA: EU5B2.4 R5B87.1
VCCSA_TG: EU5B1.3 R5B90.1
VCCSA_TGR: C5M3.2(B) EU5B1.4 EU5B2.10
VCCSA_TSEN: C5B44.2(B<0>) EU5B2.16 R5B67.2(B)
VCCSA_TSEN_SET: C5B44.1 R5B57.2(B) R5B62.1 R5B67.1
VCCSA_UG: EU5B2.9 R5B90.2(B)
VCCSA_VCC: C5B45.1 EU5B2.1 R5B89.2(B)
VCCSA_VIN: C5B34.1 C5B35.1 CR5B3.2 EU5B1.1 R4B30.1 R5B17.1 R5B54.1 R5B56.1
VCCSA_VIN_IC: C5B40.1 EU5B2.13 R5B55.1
VCCSA_VOUT: ISO17528.1 L4B2.2(INB) R4B41.1
VCCSA_VREF: EU5B2.17 R5B61.1 R5B65.2(B) R5B66.1 R5B76.1 R5M8.1 R5M11.1 R5M12.1
VCCSA_VRHOT: EU5B2.3 R5B82.1
VCCSA_VSEN: C5B36.1 C5B38.1 C5B42.1 EU5B2.25(VSEN) R5B58.2(B) R5B59.1 R5B71.1
VCCSA_VSW: EU5B1.6 EU5B1.7 EU5B1.8(VSW2) ISO17599.1 L4B2.1 R5M2.1
VCCSFR_OC_FB: EU5C2.4 R5C29.1 R5C34.2(B)
VCCSFR_OC_PVIN: C5C17.1 C5C19.1 C5C24.1 EU5C2.8 R5C14.2
VCCSFR_OC_SR_CAP: C4C8.1 U4C1.7
VCCSFR_OC_SW: EU5C2.7 L5C1.1 R5C20.1
VCCST_PWRGD: Q8C5.3 R1C46.1 R4C10.1 R4C11.2(B) R8C47.2(B)
VCCST_PWRGD_CPU: C4C5.1 J3D1.B13 R4C10.2(B)
VCCST_SFR_EN: R7G22.2(B) R7G25.2(B) U4C2.9
VCCST_SFR_EN_R: R7G22.1 U7G5.4(Y)
VCCSTG_EN: R5D3.2(B) R8D74.2(B) U4C3.9
VCCSTG_EN_R: R8D74.1 R8D96.1 U5D1.1 U8D12.4(Y)
VDDQ_BLEED: Q2G1.1 R2G17.2(B)
VDDQ_BLEED_L: R2G17.1 U2G2.8
VDDQ_CTRL: R2G37.1 U2G3.8
VDDQ_EN: R2G16.2(B) R2G29.1
VDDQ_EN_L: R2G16.1 U2G2.9
VDDQ_LGATE: EU2G1.15 R2G11.1
VDDQ_LGATE_R: R2G11.2(B) U2G1.8
VDDQ_PWRGD: Q8C11.2 R8C56.1 R8C64.2(B) R8C72.1 R8C73.1
VDDQ_PWRGD_ISOLATE: Q8C11.3 R5C62.1 R5E7.1 R5E11.1 R8C61.2(B)
VDDQ_UGATE: EU2G1.17 R2G7.1
VDDQ_UGATE_R: R2G7.2(B) U2G1.1
VDDQ_VR_CS: EU2G1.13 R2G15.2(B)
VDDQ_VR_EN_S3: EU2G1.7 R2G28.2(B)
VDDQ_VR_EN_S5: EU2G1.8 R2G29.2(B)
VDDQ_VR_FB: EU2G1.6 R2G26.1 R2G37.2(B)
VDDQ_VR_FB_R: C2G23.2(B) R2G25.2(B) R2G26.2(B) R2G33.1
VDDQ_VR_TON: EU2G1.9 R2G27.1
VDDQ_VR_VDD: C2G21.1 EU2G1.12 R2G18.2(B) R2G21.2(B)
VDDQ_VR_VDDQ_PIN: C2G22.1 EU2G1.5 R2G20.2(B)
VSS_EDP_AMOLED: J1B2.28 J1B2.32(VSS_EDP_AMOLED1) R1A4.1 R1A5.1
VSS_SA_PCIE_IO_SENSE: J3D1.D6 R5B60.2(B) R5C40.2(B)
VSSGT_SENSE: J3D1.AB38 R1C13.2(B) TP2C1.1(TP)
VSSMPHY_SENSE: R4G2.2(B) U6E1.K46
2X4_GND: J1A1.4 J1A2.4 R1A1.1
2X4_POWER_DETECT: R1A1.2(B) R1A2.2(B) U6E1.T47
3.3A_KBC_SENSE_SMC: EU8F1.4 R8F14.2(B) R8F15.1
3G16_JTAG2_CLK: J5B2.A5 R5B19.1
3G16_RSVD_B12: J5B2.B12 R5C4.2(B)
3P3APG_PIN2: C8D31.1 Q8D13.1 R8D85.1 R8D88.2(B)
3P3APG_PIN5: Q8D13.3 Q8D14.1 R8D90.2(B)
12_FAN_FETDRV: EU1E1.4 EU1E2.7
12_PEG_FETDRV: EU6B1.7 EU6B2.4
12_SLOT2_FETDRV: EU8B1.7 EU8B3.4
12_SLOT3_FETDRV: EU8B2.4 EU8B4.7
+BV_VBAT_VREG_R_CR: CR8C1.2 J8J13.40 R9E1.1
+BV_VREG_MAIN_R34BV: J9J4.2(IO2) R9J14.1
+BV_VREG_VBAT_J: J9E1.2(IO2) R9E1.2(B)
+BV_VREG_VBAT_R: BH9C1.1 BH9C1.2(P2) J9E1.1
+DRMOS_5V: R1D5.1 R1D6.2(B) R1D8.1 R1D9.2(B) R2B5.1 R2B6.1 R2B7.1 R2B16.2(B) R2B17.2(B) R2B19.2(B) R2M20.2(B) R3B26.1 R3B27.1 R3B28.1 R3B40.2(B) R3B41.2(B) R3B42.2(B) R3M45.2(B) R4B20.1 R4B21.1 R4B28.2(B) R4B29.2(B)
+HDMIC_ALS_SCL_R: CR2A3.1 R2A22.1
+HDMIC_ALS_SDA_R: CR2A3.2(C2) R2A23.1
+PW_VCC0V9_LAN: C6L3.1 C6L4.1 C7B4.1 C7B5.1 C7L3.1 C7L6.1 C7L8.1 C7M1.1 C7M3.1 C7M5.1 C7M8.1 EU7A3.9 EU7A3.26 EU7A3.38 EU7A3.44 EU7A3.50 EU7A3.56 L7B1.2(INB)
+PW_VCC0V9_LC: C5L20.1 U5A2.J8
+PW_VCC0V9_LVR: C5L9.1 C5L10.1 C5L12.1 C5L16.1 U5A2.H6 U5A2.H8
+PW_VCC0V9_PCIE: C5L17.1 C5L18.1 C5L21.1 C5L22.1 C5L27.1 U5A2.J18 U5A2.L18 U5A2.L19 U5A2.M16 U5A2.M18 U5A2.M19
+PW_VCC0V9_SVR_FOX: EU7A3.5 EU7A3.6 L7B1.1
+PW_VCC0V9_SVR_IND: L5A2.1 U5A2.K1 U5A2.K2 U5A2.L1 U5A2.L2
+PW_VCC3V3_ANA: C5L5.1 U5A2.E16
+PW_VCC3V3_ANA_PCIE: C5L4.1 U5A2.L16
+PW_VCC3V3_ANA_USB2: C4L3.1 U5A2.H18
+PW_VCC3V3_LC: C5L36.1 R4L2.2(B) R5L17.2(B) R5L18.2(B) R5L22.2(B) U5A2.V6
+U11EV_PIN7: C7H11.1 C7J1.1 R7H72.2(B) U8H6.7(VS_POS) U8J1.7(VS_POS)
+U12EV_PIN4: C8H25.1 C8J1.1 R8H71.2(B) U8H6.4 U8J1.4
+V_3P3_PORT80: C8L1.1 C8L2.1 C8L3.1 R8L1.2(B) R8L2.1 R8L3.2(B) R8L4.1 R8L6.1 R8L7.1 U8L1.16(VP)
+V_3V3_USBC_FLASH: C6A49.1 C6B1.1 C6B2.1 CR5B1.1(CATHODE) J6B1.6 J6B1.18 R5B13.1 R5B14.1 R5B15.1 R6B8.1 U5B1.8
+V_5.0_7_PC: J5J2.14 R6W4.2(B)
+V_CODEC_CPVEE: C6A15.2(B) EU6A1.20
+V_CODEC_CPVPP: C6A6.2(B) EU6A1.25
+V_CODEC_LDO1: C6A13.1 EU6A1.39 R6A30.1
+V_CODEC_LDO2: C6A17.1 EU6A1.18
+V_CODEC_LDO3: C6A27.1 EU6A1.16
+V_CODEC_LDO4: C6A16.1 EU6A1.42
+V_CODEC_STB: R6A11.1 R6A18.2
+V_CODEC_VREF: C6A8.2(B) C6A11.2(B) EU6A1.38(VREF)
+V_CPU_VREF_CA_DIMM0_CHA: C1F1.1 J3D1.AC40 R1F6.1
+V_CPU_VREF_CA_DIMM0_CHA_R: R1F3.2(B) R1F4.1 R1F5.1 R1F6.2(B)
+V_CPU_VREF_CA_DIMM0_CHB: C1F7.1 J3D1.AC39 R1F26.1
+V_CPU_VREF_CA_DIMM0_CHB_R: R1F26.2(B) R1F31.1 R1F32.1 R1F34.2(B)
+V_CPU_VREF_CA_DIMM1_CHA: C1F4.1 J3D1.AC38 R1F12.1
+V_CPU_VREF_CA_DIMM1_CHA_R: R1F12.2(B) R1F17.1
+V_CPU_VREF_CA_DIMM1_CHB: C1F12.1 J3D1.AB40 R1F52.1
+V_CPU_VREF_CA_DIMM1_CHB_R: R1F51.1 R1F52.2(B)
+V_CPU_VREF_DIMM1_CHA: R1F16.1 R1F17.2(B) R1F21.1 R1F22.2(B)
+V_CPU_VREF_DIMM1_CHB: R1F39.2(B) R1F42.1 R1F43.1 R1F51.2(B)
+V_LDO_1V8_BP_PD: C5A27.1 EU5A1.35
+V_LDO_3V3_USBC: C5A28.1 C6A34.1 CR5B1.2 EU5A1.9 R5A31.1 R5A33.1 R5A36.1 R5A38.1 R5A46.1 R5A47.1 R5A59.1 R5A60.1 R5B6.1 R5B7.1 R6A57.1 R8G11.1 U6A4.5(VS)
+V_PPHV_TYPEC: Q6A4.5 R6A83.2
+V_PPHV_TYPEC_BP_R: C6A43.1 C6A44.1 C6A45.1 C6A46.1 L6A1.2(INB) R6A82.1 R6A83.1
+V_PWR_MON1: C3H4.1 R3H25.2(B) U3H1.B2(VDD_IO)
+V_PWR_MON2: C2E1.1 R2E5.2(B) U1E2.B2(VDD_IO)
+V_PWR_MON3: C1E8.1 R1E34.2(B) U1E3.B2(VDD_IO)
+V_PWR_MON4: C1D13.1 R1E3.2(B) U1E1.B2(VDD_IO)
+V_PWR_MON5: C4H7.1 R4H24.2(B) U4H1.B2(VDD_IO)
+V_PWR_MON6: C3H1.1 R3H10.2(B) U3H2.B2(VDD_IO)
+V_PWR_MON7: C4H9.1 R4H32.2(B) U4H2.B2(VDD_IO)
+V_VDDQ_VR_OUT: C2G3.1 C2G4.1 C2G5.1 C2G6.1 C2G7.1 C2G9.1 L2G1.2(INB) R2G2.1 R2G31.1
+VHDMI_1P2S_PHASE: EU2B1.7 L2B1.1
+VHDMI_1P2S_VR_IN: C2A33.1 EU2B1.2 R2B3.2
+VPP: C5E15.1 C5E16.1 C5F1.1 C5F2.1 C5F13.1 C5F14.1 C5G3.1 C5G4.1 J1E5.142 J1E5.143 J1E5.286 J1E5.287 J1E5.288 J1F1.142 J1F1.143 J1F1.286 J1F1.287 J1F1.288 J1F2.142 J1F2.143 J1F2.286 J1F2.287 J1F2.288 J1F3.142 J1F3.143 J1F3.286 J1F3.287 J1F3.288 R2G38.1 R5F6.1 R5F13.2 R5F19.1 R7C4.1
+VPP_VR_OUT: C5F8.1 C5F9.1 EU5F1.5(VOS) L5F1.2(INB) R5F13.1 R5F22.1
+VPP_VR_PHASE: EU5F1.7 L5F1.1 R5F9.1
+VPP_VR_SW_SNUB: C5F7.1 R5F9.2(B)
+VPP_VR_VIN: C5F10.1 C5F11.1 C5F12.1 EU5F1.8 R5F12.2
+VR_CAP: C9F3.1 U8F6.18
+VREF_ADC: FB6J1.2(B) J6J2.153 J6J2.161
+VREF_CPU: C8G7.1 J6J2.217 J6J2.225 R8G25.2(B) U8F6.95
+VREF_VTT_VR: C2G20.1 EU2G1.4
+VREG_PS2: C7J7.1 C7J8.1 J7J4.2 J7J6.4 J7J6.10 M7J1.2(B) R7J2.1 R7J3.1 R7J4.1 R7J5.1
+VREG_PS2_FB: M7J1.1 RT7J1.2(B)
+VRTC: C8C4.1 CR8C1.3(C) J6J2.113 J6J2.121 R7F5.1 R7F23.1 R7R60.1 R7R62.1 R8F49.1
+VRTC_V3P3DSW_RDIV: C8C9.1 CR8C1.1 R8C13.1 R8C16.2(B)
+VTT: C3E10.1 C3E15.1 C3F2.1 C3F12.1 C3F16.1 C3F18.1 C3G1.1 C3G4.1 J1E5.77(VTT<1>) J1E5.221 J1F1.77(VTT<1>) J1F1.221 J1F2.77(VTT<1>) J1F2.221 J1F3.77(VTT<1>) J1F3.221 R2G8.2 R2G14.2(B)
+VTT_LDO_VIN: C2G12.1 C2G13.1 EU2G1.19 R2G5.1
+VTT_OUT: C2G16.1 C2G17.1 EU2G1.20 R2G8.1
+VTYPEC_VR_IN_BP: C6A35.1 C6A37.1 C6A39.1 EU6A2.4 EU6A2.5 EU6A2.6 R6A73.1 R6A77.2
AIC_TBT_CIO_PWR_EN: J6J1.4 R6H44.1
AIC_USB_FORCE_PWR: J6J1.8 R5L25.1
ALL_SYS_PWRGD: R7H8.1 R8C37.2(B) R8C39.2(B) R8C40.1
AMP_PD_N_HDR: CR8A1.2 J9A5.10 Q8B1.3 Q8B2.3 R8A31.2(B) R8A32.2(B)
AN_RCAL: EU7A3.42 R7A6.2(B)
AN_RESREF: EU7A3.20 R6B1.2(B)
ATX_DETECT_N: J6J2.56 R9F25.1 U8F6.36
AU1_VR_READY: EU1B1.36 R2C6.2(B)
AU_D0LL: EU1B1.46 R1B44.1
AU_DBLR: EU1B1.51 R1B39.2(B)
AU_DRVEN_L: EU1B1.47 R1B43.2(B)
AUDIO_AGND: C5A1.2(B) C5A8.2(B) C5A11.2(B) C6A2.1 C6A3.2(B) C6A6.1 C6A8.1 C6A11.1 C6A13.2(B) C6A15.1 C6A16.2(B) C6A17.2(B) C6A18.2(B) C6A20.2(B) C6A21.2(B) C6A25.2(B) EU6A1.19 EU6A1.37 ISO6L1.1 ISO6L2.1 J5A1.4(TRANSFER_TERMINAL) J5A1.7 J5A1.8 R6A30.2(B) R6A38.2(B) R6A49.2(B)
BACKFEED_CUT_DSW_N: Q8C3.3 R8C25.2(B) U8C1.3
BACKFEED_CUT_DSW_N_S0IDLE: R4G9.1 R4H11.1 R7B5.1 R8D20.1 U8C1.4(Y)
BACKFEED_CUT_N: Q8C4.3 R4H3.1 R5J13.2(B) R8C33.1 R8C34.2(B) U8D11.3
BACKFEED_CUT_N_EC: J6J2.223 R5J13.1
BACKFEED_CUT_N_S0IDLE: R4G6.1 R4H6.2(B) R5C45.2(B) R8D19.1 U8D11.4(Y)
BACKFEED_CUT_N_S0IDLE_SSD2_R: Q5C3.2 Q5C4.5 R5C45.1
BACKFEED_CUT_RR: Q8C3.1 Q8C4.1 R8C35.2(B) R8C36.2(B)
BACKFEED_CUT_RR_N: Q8C13.2 R8C33.2(B)
BACKFEED_CUT_SOURCE_GATE_NGFF_FET2: Q7B3.1 Q7B5.1 R7B3.2(B) R7B5.2(B)
BATLOW_N: R6J16.2(B) R6J27.1 U6E1.BF44
BC_ACOK_EC_IN: J6J2.120 R6J21.2(B) R8F34.1 R8F35.2(B) U8F6.128
BMP_0: J3D1.L38 R1C79.1 R1C80.2(B)
BMP_1: J3D1.L40 R1C70.2(B) R1C74.1
BMP_2: J3D1.T32 R1C96.2(B)
BMP_3: J3D1.R32 R1C55.2(B)
BOARD_ID0: R9E2.2(B) R9E3.1 U8E3.13
BOARD_ID1: R9E4.2(B) R9E5.1 U8E3.14
BOARD_ID2: R9E7.2(B) R9E8.1 U8E3.15
BOARD_ID3: R9E9.2(B) R9E10.1 U8E3.16
BOARD_ID4: R9E12.2(B) R9E13.1 U8E3.17
BOARD_ID5: R5J10.2(B) R8G21.2(B) R8G30.1 U8F6.86
BOM_ID0: R9E15.2(B) R9E16.1 U8E3.18
BOM_ID1: R9E17.2(B) R9E18.1 U8E3.19
BOM_ID2: R9E20.2(B) R9E21.1 U8E3.20
BP_PD_BUSPOWERZ: EU5A1.6 R5A28.1 R5A31.2(B)
BP_PD_HRESET_R: EU5A1.44 R5A23.1 R5A24.1
BP_PD_I2C_ADDR: EU5A1.10 R5A36.2(B) R5A42.1
BP_TBT_CIO_PWR_EN: R5L13.1 R6F20.1 U5A2.T5
BRD_ID_A0: R9E22.2(B) R9E23.1 U8E3.21
BRD_ID_A1: R8E32.1 R8E33.2(B) U8E3.2
BRD_ID_A2: R8E24.1 R8E25.2(B) U8E3.3
BT_RF_KILL_N: J8H5.4(IO4) Q7B8.2(S) R7B38.2(B) R7B50.2(B)
BT_RF_KILL_N_HDR: J8H5.3 R8H67.1
BT_RF_KILL_R_N: R7B38.1 U6E1.BF32
BUF_PLT_RST_1V8_AUDIO_HDR_N: J9A5.6 R8A27.2(B)
BV_5VDUAL_BACKFEED_CUT_L: Q4G1.2 Q4G1.5 R4G6.2(B) R4G9.2(B)
BV_PS_ON_HEADER_N: C4H2.1 C4H3.1 J4G1.16 R4H4.1 R4H8.2(B)
BV_V3P3DUAL_BACKFEED_CUT_L: Q8D1.2 Q8D1.5 R8D19.2(B) R8D20.2(B)
BV_VDDQ_PGOOD: EU2G1.10 R8C56.2(B)
BV_VREG_MAIN_STBY_LED_R: DS9J1.1 R9J14.2(B)
C1+1: C9C2.2(B) U9C1.1
C1-3: C9C2.1 U9C1.3
C1_N: C1A3.2(B) U1B1.3
C1_P: C1A3.1 U1B1.6
C2+4: C9C3.2(B) U9C1.4
C2-5: C9C3.1 U9C1.5
CATERR_LED_D: CR8H2.1 R8H62.2(B)
CATERR_LED_DRV: CR8H2.2(C) EU8H2.7 J7J3.1 J7J3.2(IO2) R7G32.2(B)
CATERR_TTK_N: J7G1.28 R7G32.1
CB_GAIN1: EU3M1.10 R3B30.2(B) R3B38.1
CB_GAIN2: EU3M2.10 R3B29.2(B) R3B37.1
CB_GAIN3: EU2M1.10 R2B8.2(B) R2B14.1
CB_GAIN4: EU4M1.10 R4B22.2(B) R4B27.1
CFG_CML_PCUDEBUG_<0>: J1C1.9 J3D1.L35 R1C94.1 R1C98.2(B)
CFG_CML_PCUDEBUG_<1>: J1C1.11 J3D1.K36 R1C95.2(B)
CFG_CML_PCUDEBUG_<2>: J1C1.15 J3D1.M35 R1C92.2(B)
CFG_CML_PCUDEBUG_<3>: J1C1.17 J3D1.N35 R1C88.2(B)
CFG_CML_PCUDEBUG_<4>: J1C1.27 J3D1.N37 R1C62.2(B)
CFG_CML_PCUDEBUG_<5>: J1C1.29 J3D1.P36 R1C58.2(B)
CFG_CML_PCUDEBUG_<6>: J1C1.33 J3D1.R36 R1C54.2(B)
CFG_CML_PCUDEBUG_<7>: J1C1.35 J3D1.P37 R1C50.2(B)
CFG_CML_PCUDEBUG_<8>: J1C1.10 J3D1.N34 R1C93.2(B)
CFG_CML_PCUDEBUG_<9>: J1C1.12 J3D1.L36 R1C85.2(B)
CFG_CML_PCUDEBUG_<10>: J1C1.16 J3D1.M37 R1C77.2(B)
CFG_CML_PCUDEBUG_<11>: J1C1.18 J3D1.P34 R1C72.2(B)
CFG_CML_PCUDEBUG_<12>: J1C1.28 J3D1.M38 R1C66.2(B)
CFG_CML_PCUDEBUG_<13>: J1C1.30 J3D1.N36 R1C60.2(B)
CFG_CML_PCUDEBUG_<14>: J1C1.34 J3D1.P38 R1C56.2(B)
CFG_CML_PCUDEBUG_<15>: J1C1.36 J3D1.P39 R1C51.2(B)
CHA_DIMM0_TS_EVENT_N: J1E5.78 R3F2.2(B)
CHA_DIMM1_TS_EVENT_N: J1F1.78 R3F1.2(B)
CHB_DIMM0_TS_EVENT_N: J1F2.78 R3F3.2(B)
CHB_DIMM1_TS_EVENT_N: J1F3.78 R3G1.2(B)
CK_M_DDR0_A_DN: J1E5.75 J3D1.AV24
CK_M_DDR0_A_DP: J1E5.74 J3D1.AU24
CK_M_DDR0_B_DN: J1F2.75 J3D1.AU23
CK_M_DDR0_B_DP: J1F2.74 J3D1.AT23
CK_M_DDR1_A_DN: J1E5.219 J3D1.AW23
CK_M_DDR1_A_DP: J1E5.218 J3D1.AY23
CK_M_DDR1_B_DN: J1F2.219 J3D1.AU22
CK_M_DDR1_B_DP: J1F2.218 J3D1.AV22
CK_M_DDR2_A_DN: J1F1.75 J3D1.AU19
CK_M_DDR2_A_DP: J1F1.74 J3D1.AT19
CK_M_DDR2_B_DN: J1F3.75 J3D1.AU21
CK_M_DDR2_B_DP: J1F3.74 J3D1.AT21
CK_M_DDR3_A_DN: J1F1.219 J3D1.AW18
CK_M_DDR3_A_DP: J1F1.218 J3D1.AY18
CK_M_DDR3_B_DN: J1F3.219 J3D1.AV20
CK_M_DDR3_B_DP: J1F3.218 J3D1.AU20
CLK_1G74_22: C8D23.1 R8D60.2(B) U8D6.1
CLK_REQ_LAN_R_N: EU4B1.48 R4B15.2(B)
CLK_REQ_M.2_WLAN_N: J7C1.53 R7B29.2(B)
CLK_SRC0_M.2_WLAN_DN: R7B54.1 U6E1.AJ6
CLK_SRC0_M.2_WLAN_DP: R7B59.1 U6E1.AJ7
CLK_SRC0_M.2_WLAN_R_DN: J7C1.49 R7B54.2(B)
CLK_SRC0_M.2_WLAN_R_DP: J7C1.47 R7B59.2(B)
CLK_SRC1_LAN_DN: EU4B1.45 U6E1.AH9
CLK_SRC1_LAN_DP: EU4B1.44 U6E1.AH10
CLK_SRC2_M.2_SSD_DN: J8H1.53 U6E1.AE14
CLK_SRC2_M.2_SSD_DP: J8H1.55 U6E1.AE15
CLK_SRC3_CPU_SSD_DN: R5B48.2(B) U6E1.AE6
CLK_SRC3_CPU_SSD_DP: R5B49.2(B) U6E1.AE7
CLK_SRC3_CPU_SSD_R_DN: J5B3.53 R5B48.1
CLK_SRC3_CPU_SSD_R_DP: J5B3.55 R5B49.1
CLK_SRC4_SLOT3_DN: J8B1.A14 U6E1.AC2
CLK_SRC4_SLOT3_DP: J8B1.A13 U6E1.AC3
CLK_SRC5_SLOT2_DN: J7B1.A14 U6E1.AB2
CLK_SRC5_SLOT2_DP: J7B1.A13 U6E1.AB3
CLK_SRC6_TR_DN: R6D41.1 U5A2.T19
CLK_SRC6_TR_DP: R6D38.1 U5A2.V19
CLK_SRC6_TR_U2_DN: R6D41.2(B) R6D42.2(B) U6E1.W4
CLK_SRC6_TR_U2_DP: R6D38.2(B) R6D39.2(B) U6E1.W3
CLK_SRC6_U2_DN: R5H5.1 R6D42.1
CLK_SRC6_U2_DP: R5H4.1 R6D39.1
CLK_SRC6_U2_R_DN: J5H1.A2 R5H5.2(B)
CLK_SRC6_U2_R_DP: J5H1.A1 R5H4.2(B)
CLK_SRC7_X16PORT_DN: R5B43.2(B) U6E1.W7
CLK_SRC7_X16PORT_DN_R: J5B2.A14 R5B43.1
CLK_SRC7_X16PORT_DP: R5B41.2(B) U6E1.W6
CLK_SRC7_X16PORT_DP_R: J5B2.A13 R5B41.1
CLK_SRC8_LAN_FOX_DN: R6A80.1 U6E1.AC14
CLK_SRC8_LAN_FOX_DP: R6A84.1 U6E1.AC15
CLK_SRC9_PEGX16_DN: J5B2.A8 U6E1.U2
CLK_SRC9_PEGX16_DP: J5B2.A7 U6E1.U3
CLK_SRC10_PEGX16_DN: R5C28.2(B) U6E1.AC9
CLK_SRC10_PEGX16_DN_R: J5B2.A33 R5C28.1
CLK_SRC10_PEGX16_DP: R5C22.2(B) U6E1.AC11
CLK_SRC10_PEGX16_DP_R: J5B2.A32 R5C22.1 R5C23.1
CLK_SRC11_DN: J7C9.3(IO3) U6E1.AE9
CLK_SRC11_DP: J7C9.1 U6E1.AE11
CLK_SRC_LAN_FOX_DN: EU7A3.22 R6A80.2(B)
CLK_SRC_LAN_FOX_DP: EU7A3.21 R6A84.2(B)
CLN_RST_FET_GATE1_LED: Q7H1.5 R6H19.2(B)
CLN_RST_FET_GATE2_LED: Q7H1.2 Q7H1.3 R7H68.2(B)
CLN_RST_FET_SOURCE_LED: CR7H1.2(C) Q7H1.6
CLN_RST_FET_SOURCE_LED_R: CR7H1.1 R7H67.2(B)
CML_CFG_STRAP_3: J1E1.1 R1D1.1
CNV_BRI_DT: R7D31.2(B) R7D32.2(B) R7D35.1 U6E1.AV4
CNV_BRI_DT_PU: J7D3.1 R7D32.1
CNV_BRI_DT_R: J7C1.36 R7D31.1
CNV_BRI_RSP: R7B75.2(B) R7D20.1 U6E1.AY2
CNV_BRI_RSP_R: J7C1.22 R7B75.1
CNV_GNSS_PA_BLANKING: R7B58.2(B) U6E1.AV6
CNV_GNSS_PA_BLANKING_R: J7C1.44 R7B58.1
CNV_MFUART2_RXD: R7B52.2(B) U6E1.AW2
CNV_MFUART2_RXD_R: J7C1.48 R7B52.1
CNV_MFUART2_TXD: R7B57.2(B) R7P3.1 R7P4.2(B) U6E1.AU9
CNV_MFUART2_TXD_R: J7C1.46 R7B57.1
CNV_RGI_DT: R7D19.2(B) R7D40.2(B) R7D41.1 U6E1.BA4
CNV_RGI_DT_R: J7C1.32 R7D19.1
CNV_RGI_RSP: R7B62.2(B) R7D21.1 U6E1.AV3
CNV_RGI_RSP_R: J7C1.34 R7B62.1
CNV_WR_0_DN: R7B78.1 U6E1.BB3
CNV_WR_0_DP: R7B74.1 U6E1.BB4
CNV_WR_1_DN: R7B83.1 U6E1.BA3
CNV_WR_1_DP: R7B80.1 U6E1.BA2
CNV_WR_CLK_DN: R7B72.1 U6E1.BD4
CNV_WR_CLK_DP: R7B71.1 U6E1.BE3
CNV_WR_R_0_DN: J7C1.15 R7B78.2(B)
CNV_WR_R_0_DP: J7C1.17 R7B74.2(B)
CNV_WR_R_1_DN: J7C1.9 R7B83.2(B)
CNV_WR_R_1_DP: J7C1.11 R7B80.2(B)
CNV_WR_R_CLK_DN: J7C1.21 R7B72.2(B)
CNV_WR_R_CLK_DP: J7C1.23 R7B71.2(B)
CNV_WT_0_DN: R7B43.1 U6E1.BE6
CNV_WT_0_DP: R7B40.1 U6E1.BD7
CNV_WT_1_DN: R7B51.1 U6E1.BG6
CNV_WT_1_DP: R7B47.1 U6E1.BF6
CNV_WT_CLK_DN: R7B37.1 U6E1.BC5
CNV_WT_CLK_DP: R7B35.1 U6E1.BB6
CNV_WT_R_0_DN: J7C1.65 R7B43.2(B)
CNV_WT_R_0_DP: J7C1.67 R7B40.2(B)
CNV_WT_R_1_DN: J7C1.59 R7B51.2(B)
CNV_WT_R_1_DP: J7C1.61 R7B47.2(B)
CNV_WT_R_CLK_DN: J7C1.71 R7B37.2(B)
CNV_WT_R_CLK_DP: J7C1.73 R7B35.2(B)
CNV_WT_RCOMP: R7D51.1 U6E1.BA1
CNVI_EN: Q7A1.2 Q7A1.5 Q7B2.3 R7B6.2(B)
CNVI_EN_N: R7A8.1 R7A9.2(B) R7P1.1
CNVI_EN_PCH_N: R7P1.2(B) U6E1.AR13
CODEC_1P8PWR_EN: R6A19.1 R6A25.2(B) R6A26.2(B) R6A27.2(B) R6A85.2(B) R6A88.2(B)
CODEC_5V_3P3_PWR_EN: R6A13.1 R6A20.2(B) R6A21.2(B) R6A22.2(B) R6A86.2(B) R6A87.2(B) R8A9.1
CODEC_CBN: C6A14.2(B) EU6A1.24 R6A17.1
CODEC_CBN2: EU6A1.22 R6A23.1
CODEC_CBP: C6A14.1 EU6A1.21
CODEC_CBP2: C6A9.1 EU6A1.23
CODEC_CBP_ES1_ES2: C6A9.2(B) R6A17.2(B) R6A23.2(B)
CODEC_CC1: EU6A1.2 R6A42.2(B) R6A49.1
CODEC_CC2: EU6A1.1 R6A37.2(B) R6A38.1
CODEC_DMIC0_CLK_R: C6L2.1 R6L2.2(B) R8B4.1
CODEC_DMIC1_CLK_R: C6L1.1 R6L1.2(B) R8B16.1
CODEC_DMIC2_DATA: R6A48.2(B) R8B13.1
CODEC_DMIC_CLK: EU6A1.7 R6A45.1 R6A62.2(B) R6L1.1 R6L2.1
CODEC_DMIC_DATA: EU6A1.6 R6A44.1 R6A61.2(B) R8B11.1
CODEC_ES1_MIC2_VREFO_L: EU6A1.28 R6A16.1
CODEC_ES1_MIC2_VREFO_R: EU6A1.29 R6A15.1
CODEC_GPIO2_DMIC_DATA2: EU6A1.15 R6A39.1 R6A48.1 R6A51.2(B)
CODEC_HD_SDW_SEL: EU6A1.4 R6A43.1 R6A54.2(B)
CODEC_HPOUT-L: C5A10.2(B) EU6A1.27 R5A8.1
CODEC_HPOUT-R: C5A9.2(B) EU6A1.26 R5A14.1
CODEC_INT_N: Q8A1.2(SRC) R7F27.2(B) R7F41.2(B)
CODEC_IRQ_HDR: Q8A1.3 R8A29.1
CODEC_IRQ_HDR_R: J9A5.7 R8A29.2(B)
CODEC_JD1: EU6A1.48 R5A5.1 R5A6.1 R5A7.2(B)
CODEC_JD1_R: C5A1.1 C5A2.1 R5A2.1 R5A3.2(B) R5A5.2(B)
CODEC_JD2: EU6A1.47 R6A36.2(B)
CODEC_MIC2-VREFO-L: EU6A1.30 R6A2.1 R6A8.1
CODEC_MIC2_VREFO_R: EU6A1.31 R6A7.1 R6A14.1
CODEC_MIC_CAP: EU6A1.34 R6A10.2(B)
CODEC_MIC_CAP_R: C6A2.2(B) R6A10.1 R6A12.1
CODEC_RTC_CLK: R6A53.1 Y6A1.3
CODEC_RTC_CLK_EN: R6A32.1 R6A33.2(B) Y6A1.1
CODEC_RTC_CLK_SUS_CLK: EU6A1.3 R6A52.2(B) R6A53.2(B)
CORE_SPKR_R: C9G5.1 Q9G5.1 R9G31.2(B)
CPU_2_PCH_TRIGGER: R4C12.2(B) U6E1.AK2
CPU_2_PCH_TRIGGER_R: J3D1.D12 R4C12.1
CPU_24MHZ_R_DN: J3D1.U7 R5E15.2(B)
CPU_24MHZ_R_DP: J3D1.U8 R5E19.2(B)
CPU_C10_GATE_N: U6E1.AY3 U8D7.2
CPU_FAN_CTRL_OUT: Q9C1.2(SRC) R9C4.2(B) R9C10.1
CPU_FAN_DRIVER: J1E3.1 R1E33.1
CPU_FAN_DRIVER_GATE: Q9C1.1 R9C1.1
CPU_FAN_OUT: J1E3.4(IO4) Q9C1.3
CPU_FAN_TACH: C1E5.1 J6J2.48 R1E17.1 R1E18.2(B) U8F6.40
CPU_ID: J3D1.AB39 Q5E3.1 R2D1.1 R5M14.2(B) R5M16.1 U5E1.1
CPU_ID_N: Q5E2.2 Q5E2.5 Q5E3.3 R5E56.2(B)
CPU_ID_SA: Q5M2.1 Q5M3.1 Q5M4.1 R5M6.1 R5M15.2(B) R5M16.2(B)
CPU_ID_SA_1: Q5M1.1 R5M10.1 R5M13.2(B) R5M14.1
CPU_PWM_FAN: J6J2.40 R9C3.2(B) R9C4.1 U8F6.44
CPU_RTCCLK: J3D1.B15 U7F1.3
CPU_SSD_PWREN: R5C49.1 R6T3.2(B) U6E1.AE43
CPU_SSD_PWREN_N: Q5C2.3 Q5C3.5 R5C30.2(B)
CPU_SSD_PWREN_R: Q5C2.5 Q5C4.2 R5C49.2(B)
CPU_SUSCLK: R7F19.2(B) U7F1.4
CPU_TACH_OUT: J1E3.3 R1E18.1 R1E25.2(B)
CPU_VCCIO_PWR_GATEB: R2B2.1(CATHODE) R5C56.2(B) R5D30.2(B) R5E13.1 R5E14.1 R7B32.1 R8D67.2(B) R8D95.1 U8D7.4(Y)
CPU_VIDALERT_N: J3D1.A14 R4C8.1
CPU_VIDSCK: J3D1.C14 R4C9.1
CPU_VIDSOUT: J3D1.B14 R4C7.1
CPU_VREF_CA_A0_RC: C1F1.2(B) R1F8.1
CPU_VREF_CA_A1_RC: C1F4.2(B) R1F7.1
CPU_VREF_CA_B0_RC: C1F7.2(B) R1F25.1
CPU_VREF_CA_B1_RC: C1F12.2(B) R1F50.1
DB_APP: EU2M1.14 EU3M1.14 EU3M2.14 EU4M1.14 R3B32.2(B) R3B43.1
DB_EN1: C3M17.1 EU3M1.5 R3M10.2(B) R3M21.2(B)
DB_EN2: C3M18.1 EU3M2.5 R3M12.2(B) R3M22.2(B)
DB_EN3: C2M4.1 EU2M1.5 R2M2.2(B) R2M7.2(B)
DB_EN4: C4M15.1 EU4M1.5 R4M10.2(B) R4M15.2(B)
DB_VCC1: C3M8.1 EU3M1.9 R3B30.1 R3B31.1 R3B32.1 R3M9.2(B)
DB_VCC2: C3M9.1 EU3M2.9 R3B29.1 R3M11.2(B)
DB_VCC3: C2M1.1 EU2M1.9 R2B8.1 R2M1.2(B)
DB_VCC4: C4M8.1 EU4M1.9 R4B22.1 R4M9.2(B)
DB_ZD: EU2M1.11(ZD) EU3M1.11(ZD) EU3M2.11(ZD) EU4M1.11(ZD) R3B31.2(B) R3B39.1
DBLR_MODE: EU2M1.12 EU3M1.12 EU3M2.12 EU4M1.12 R1B39.1 R1B40.1
DCI_OOB_ENABLE: J8H3.2(IO2) R5J11.2(B) R8H64.1 U8F6.39
DCI_OOB_ENABLE_J: J8H3.1 R8H54.2(B)
DCIN_EN: EU2A7.3 R2A69.1
DDI1_AUX_DN: C2A21.1 J3D1.K38
DDI1_AUX_DP: C2A24.1 J3D1.K39
DDI1_AUX_EN: Q2A4.1 Q2A5.1 Q2A7.1 Q2A8.3 R2A33.2(B)
DDI1_DDC_EN: Q2A3.1 Q2A5.3 Q2A6.1 R2A32.2(B)
DDI1_DP_AUX_C_DN: C2A21.2(B) C2A22.1 Q2A4.2(SRC)
DDI1_DP_AUX_C_DP: C2A23.1 C2A24.2(B) Q2A7.2(SRC)
DDI1_DP_CTRLCLK_AUX_DP: EU2A5.1 EU2A5.10 J2A1.T15 Q2A6.2(SRC) Q2A7.3 R2A19.2(B)
DDI1_DP_CTRLDATA_AUX_DN: EU2A5.2 EU2A5.9 J2A1.T17 Q2A3.3 Q2A4.3 R2A20.2(B)
DDI1_DP_TX0_C_DN: C2A14.2(B) R2A12.1 U2A1.4(PIN4)
DDI1_DP_TX0_C_DP: C2A13.2(B) R2A11.1 U2A1.1
DDI1_DP_TX0_L_DN: EU2A3.2 EU2A3.9 J2A1.T3 R2A12.2(B) U2A1.3
DDI1_DP_TX0_L_DP: EU2A3.1 EU2A3.10 J2A1.T1 R2A11.2(B) U2A1.2
DDI1_DP_TX1_C_DN: C2A15.2(B) R2A13.1 U2A2.1
DDI1_DP_TX1_C_DP: C2A16.2(B) R2A14.1 U2A2.4(PIN4)
DDI1_DP_TX1_L_DN: EU2A3.4 EU2A3.7 J2A1.T6 R2A13.2(B) U2A2.2
DDI1_DP_TX1_L_DP: EU2A3.5 EU2A3.6 J2A1.T4 R2A14.2(B) U2A2.3
DDI1_DP_TX2_C_DN: C2A20.2(B) R2A18.1 U2A4.4(PIN4)
DDI1_DP_TX2_C_DP: C2A19.2(B) R2A17.1 U2A4.1
DDI1_DP_TX2_L_DN: EU2A4.5 EU2A4.6 J2A1.T9 R2A18.2(B) U2A4.3
DDI1_DP_TX2_L_DP: EU2A4.4 EU2A4.7 J2A1.T7 R2A17.2(B) U2A4.2
DDI1_DP_TX3_C_DN: C2A17.2(B) R2A15.1 U2A3.1
DDI1_DP_TX3_C_DP: C2A18.2(B) R2A16.1 U2A3.4(PIN4)
DDI1_DP_TX3_L_DN: EU2A4.1 EU2A4.10 J2A1.T12 R2A15.2(B) U2A3.2
DDI1_DP_TX3_L_DP: EU2A4.2 EU2A4.9 J2A1.T10 R2A16.2(B) U2A3.3
DDI1_DPCON_PIN14_PD: J2A1.T14 R2A7.1
DDI1_OB_AUX_EN: EU2A5.4 EU2A5.7 J2A1.T13 Q2A8.1 R2A8.2(B) R2A10.1
DDI1_OB_DP_HPD: EU2A5.5 EU2A5.6 J2A1.T18 R2A48.1
DDI1_OB_DP_HPD_R: Q1A1.3 R2A48.2(B) R2A49.1 R2A53.2(B)
DDI1_TX0_DN: C2A14.1 J3D1.F38
DDI1_TX0_DP: C2A13.1 J3D1.F39
DDI1_TX1_DN: C2A15.1 J3D1.G39
DDI1_TX1_DP: C2A16.1 J3D1.G40
DDI1_TX2_DN: C2A20.1 J3D1.H39
DDI1_TX2_DP: C2A19.1 J3D1.H38
DDI1_TX3_DN: C2A17.1 J3D1.J40
DDI1_TX3_DP: C2A18.1 J3D1.J39
DDI2_HDMI_ALS_CTRLCLK: EU2A7.34 R2A55.2(B)
DDI2_HDMI_ALS_CTRLDATA: EU2A7.33 R2A51.2(B)
DDI2_HDMI_CLK_DN: C2B5.2(B) EU2A7.48
DDI2_HDMI_CLK_DP: C2B4.2(B) EU2A7.47
DDI2_HDMI_DATA0_DN: C2A32.2(B) EU2A7.45
DDI2_HDMI_DATA0_DP: C2A31.2(B) EU2A7.44
DDI2_HDMI_DATA1_DN: C2B3.2(B) EU2A7.42
DDI2_HDMI_DATA1_DP: C2B2.2(B) EU2A7.41
DDI2_HDMI_DATA2_DN: C2A30.2(B) EU2A7.39
DDI2_HDMI_DATA2_DP: C2A29.2(B) EU2A7.38
DDI2_HDMI_HPD: EU2A7.40 R2A70.2(B)
DDI2_TX0_DN: C2A30.1 J3D1.F36
DDI2_TX0_DP: C2A29.1 J3D1.F35
DDI2_TX1_DN: C2B3.1 J3D1.E37
DDI2_TX1_DP: C2B2.1 J3D1.E36
DDI2_TX2_DN: C2A32.1 J3D1.D38
DDI2_TX2_DP: C2A31.1 J3D1.D37
DDI2_TX3_DN: C2B5.1 J3D1.G37
DDI2_TX3_DP: C2B4.1 J3D1.G36
DDI3_AUX_DN: C3A19.1 C3A20.1 J3D1.C36
DDI3_AUX_DP: C3A21.1 C3A22.1 J3D1.B36
DDI3_AUX_PCON_C_DN: C3A20.2(B) R3A45.2(B) U3A5.C8
DDI3_AUX_PCON_C_DP: C3A21.2(B) R3A46.1 U3A5.C7
DDI3_TR_AUX_C_DN: C3A19.2(B) U5A2.N2
DDI3_TR_AUX_C_DP: C3A22.2(B) U5A2.N1
DDI3_TR_TX0_C_DN: C5B2.1 U5A2.AB7
DDI3_TR_TX0_C_DP: C5B1.1 U5A2.AC7
DDI3_TR_TX0_R_DN: C5B2.2(B) R3B2.2(B)
DDI3_TR_TX0_R_DP: C5B1.2(B) R3B1.2(B)
DDI3_TR_TX1_C_DN: C5B4.1 U5A2.AC9
DDI3_TR_TX1_C_DP: C5B3.1 U5A2.AB9
DDI3_TR_TX1_R_DN: C5B4.2(B) R3B4.2(B)
DDI3_TR_TX1_R_DP: C5B3.2(B) R3B3.2(B)
DDI3_TR_TX2_C_DN: C5B6.1 U5A2.AB11
DDI3_TR_TX2_C_DP: C5B5.1 U5A2.AC11
DDI3_TR_TX2_R_DN: C5B6.2(B) R3B6.2(B)
DDI3_TR_TX2_R_DP: C5B5.2(B) R3B5.2(B)
DDI3_TR_TX3_C_DN: C5B8.1 U5A2.AC13
DDI3_TR_TX3_C_DP: C5B7.1 U5A2.AB13
DDI3_TR_TX3_R_DN: C5B8.2(B) R2B1.2(B)
DDI3_TR_TX3_R_DP: C5B7.2(B) R3B7.2(B)
DDI3_TX0_C_DN: C3B2.2(B) U3A5.A7
DDI3_TX0_C_DP: C3B1.2(B) U3A5.A8
DDI3_TX0_DN: C3B2.1 J3D1.B37 R3B2.1
DDI3_TX0_DP: C3B1.1 J3D1.A37 R3B1.1
DDI3_TX1_C_DN: C3B4.2(B) U3A5.A5
DDI3_TX1_C_DP: C3B3.2(B) U3A5.A6
DDI3_TX1_DN: C3B4.1 J3D1.B38 R3B4.1
DDI3_TX1_DP: C3B3.1 J3D1.C38 R3B3.1
DDI3_TX2_C_DN: C3B6.2(B) U3A5.A3
DDI3_TX2_C_DP: C3B5.2(B) U3A5.A4
DDI3_TX2_DN: C3B6.1 J3D1.C40 R3B6.1
DDI3_TX2_DP: C3B5.1 J3D1.D40 R3B5.1
DDI3_TX3_C_DN: C2B1.2(B) U3A5.A1
DDI3_TX3_C_DP: C3B7.2(B) U3A5.A2
DDI3_TX3_DN: C2B1.1 J3D1.E40 R2B1.1
DDI3_TX3_DP: C3B7.1 J3D1.E39 R3B7.1
DDPB_CTRLCLK: Q2A6.3 R2A46.2(B) U6E1.AL13
DDPB_CTRLDATA: Q2A3.2(SRC) R2A36.2(B) U6E1.AR8
DDPC_CTRLCLK: R2A54.2(B) R2A55.1 U6E1.AN13
DDPC_CTRLDATA: R2A50.2(B) R2A51.1 U6E1.AL10
DDR4_DRAMRST_N: C3E13.1 C3F3.1 C3F17.1 C3G10.1 J1E5.58 J1F1.58 J1F2.58 J1F3.58 R7F16.1
DDR_THERM_IN: R8G2.1 U8F6.117
DDR_THERM_IN_R: C8G2.1 R8G2.2(B) R8G5.2(B) R8G7.1
DDR_VTT_CNTL: J3D1.AC33 R2G39.1
DDSP_3_AUX_DN: C1B11.1 J3D1.K11 R1B48.1
DDSP_3_AUX_DP: C1B12.1 J3D1.K12 R1B49.1
DDSP_HPD_2_PCON: R5B1.2(B) U3A5.B1
DDSP_HPD_2_TR: R5B2.2(B) U5A2.AA2
DEVICE_DET_G3: R6H38.1 R6H39.1 R9F7.2(B) R9F9.2(B)
DEVICE_DET_G3_AIC: J6J1.17 R6H39.2(B)
DEVICE_DET_G3_BP: EU5A1.42 R6H38.2(B)
DEVICE_DET_G3_EC: R5J20.1 R9F9.1 R9F12.2(B) U8F6.16
DEVICE_DET_G3_PCH: R6F18.2(B) R9F7.1 U6E1.R46
DG_DEV_DIS_N: EU7A3.2 R7B10.2(B) R7B22.2(B) R7B26.2(B)
DG_GPIO0: R5A49.1 R5A50.1 U5A2.W1
DG_GPIO1: R5A48.1 U5A2.W2
DG_GRN1_LED_N: C7A2.2(B) J7A1.17 R7A2.2(B)
DG_GRN_LED_N: C7A3.1 J7A1.20 R7A3.2(B)
DG_GRN_LED_P: C7A1.1 J7A1.18 R7A1.2(B)
DG_JTAG_EN: J7A2.2 R7A5.2(B)
DG_JTAG_TCK: EU7A3.29 J7A2.5 R6A72.2(B)
DG_JTAG_TDI: EU7A3.19 J7A2.1 R6B2.2(B)
DG_JTAG_TDO: EU7A3.18 J7A2.7 R6B5.2(B) R6B6.1
DG_JTAG_TMS: EU7A3.17 J7A2.3 R6B9.2(B)
DG_LINK_1000: EU7A3.32 R7A4.1
DG_LINK_2500: EU7A3.31 R7A3.1
DG_LINK_ACT: EU7A3.30 R7A2.1
DG_NVM_CLK: R6B16.2(B) R6B35.1 U6B1.6 U6B2.6
DG_NVM_CS_N: R6B17.2(B) R6B23.2(B) R7B84.1 U6B1.1 U6B2.1
DG_NVM_HOLD_N: R7B39.2(B) U6B1.7 U6B2.7
DG_NVM_SI: J9A2.1 R6B15.2(B) R7B34.2(B) U6B1.5 U6B2.5
DG_NVM_SI_PD: J9A2.2(IO2) R9A3.1
DG_NVM_SO: R6B18.2(B) R6B19.2(B) R6B22.2(B) U6B1.2 U6B2.2
DG_NVM_WP_N: R6B21.2(B) U6B1.3(WP_N_IO2) U6B2.3(WP_N)
DG_PG: EU7A3.1 R7B9.2(B)
DG_SDP0: EU7A3.15 J7A2.8 R6B11.2(B)
DG_SPI_CLK: EU7A3.35 R6B16.1
DG_SPI_CS_N: EU7A3.37 R6B17.1
DG_SPI_MISO: EU7A3.36 R6B18.1
DG_SPI_MOSI: EU7A3.34 R6B15.1
DG_TEST_PWR_GOOD: R5L19.1 U5A2.W5
DG_TRSTN: EU7A3.16 J7A2.4
DG_VQPS: EU7A3.8 R7M1.1
DG_YLW_LED_N: C7A4.2(B) J7A1.19(YEL_M) R7A4.2(B)
DGPU_PWR_EN_N: J5B2.A19 R7T11.2(B) R7T18.2(B)
DGPU_PWR_OK: R5C23.2(B) R7F26.2(B) R7F37.1
DGPU_SEL_N: J5B2.B30 R7F28.2(B) R7F42.2(B)
DIMM0_CHA_VREF_CA: C1E13.1 C1E14.1 J1E5.146 R1F4.2(B) R1F9.1
DIMM0_CHB_VREF_CA: C1F8.1 C1F9.1 J1F2.146 R1F31.2(B) R1F33.1
DIMM1_CHA_VREF_CA: C1F2.1 C1F3.1 J1F1.146 R1F9.2(B) R1F16.2(B)
DIMM1_CHB_VREF_CA: C1G1.1 C1G2.1 J1F3.146 R1F33.2(B) R1F42.2(B)
DIS_LATCH_BFCN: Q8C13.1(S) Q8C13.3 R8D3.2(B)
DISP_UTIL: R1B5.1 U1B2.4(Y)
DISP_UTIL_CPU: J3D1.L37 R1B9.2(B) R1B10.1 U1B2.2
DMI_IT_MR_0_DN: J3D1.AD5 J4R1.15 U6E1.C33
DMI_IT_MR_0_DP: J3D1.AD4 J4R1.13 U6E1.B33
DMI_IT_MR_1_DN: J3D1.AD8 J4R1.14 U6E1.C32
DMI_IT_MR_1_DP: J3D1.AD7 J4R1.12 U6E1.B32
DMI_IT_MR_2_DN: J3D1.AC6 J4R1.20 U6E1.C31
DMI_IT_MR_2_DP: J3D1.AC5 J4R1.18 U6E1.B31
DMI_IT_MR_3_DN: J3D1.AB7 J4R1.19 U6E1.C29
DMI_IT_MR_3_DP: J3D1.AB6 J4R1.17 U6E1.B29
DMI_MT_IR_0_DN: J3D1.AF2 J4R1.3 U6E1.K34
DMI_MT_IR_0_DP: J3D1.AF1 J4R1.5 U6E1.J35
DMI_MT_IR_1_DN: J3D1.AE3 J4R1.2 U6E1.G33
DMI_MT_IR_1_DP: J3D1.AE2 J4R1.4 U6E1.F34
DMI_MT_IR_2_DN: J3D1.AD2 J4R1.8 U6E1.K32
DMI_MT_IR_2_DP: J3D1.AD1 J4R1.10 U6E1.J32
DMI_MT_IR_3_DN: J3D1.AC3 J4R1.7 U6E1.G30
DMI_MT_IR_3_DP: J3D1.AC2 J4R1.9 U6E1.F30
DMIC0_SDW4_CLK_HDR: C8B3.1 J9B1.1 R8B3.2(B) R8B4.2(B)
DMIC0_SDW4_DATA_HDR: C8B5.1 J9B1.2 R8B11.2(B) R9B9.2(B)
DMIC1_SDW3_CLK_HDR: J9B1.5 R8B16.2(B) R8B17.2(B)
DMIC1_SDW3_DATA_HDR: J9B1.6 R8B12.2(B) R8B13.2(B)
DMIC_CLK_0: R7E18.1 U6E1.BD16
DMIC_CLK_1: R7R16.1 U6E1.AW15
DMIC_DATA_0: R7E17.1 U6E1.BF15
DMIC_DATA_1: R7R19.1 U6E1.AV16
DPSRC_TBT_HPD: R5L8.1 U5A2.R5
DPWROK_IC: C8D7.1 Q8D10.3 R8D25.1 R8D31.2(B) R8D38.2(B)
DRAM_PWROK_RR: Q8C13.5 R8C73.2(B) R8C76.1
DRAM_RESET_N: R7F16.2(B) R7F30.1 U6E1.BB46
DRVEN: EU1B1.48 R1P1.1 R1P4.1 R2B12.1 R2M4.1 R2M6.1 R2M7.1 R3M16.1 R3M19.1 R3M20.1 R3M21.1 R3M22.1 R4M12.1 R4M14.1 R4M15.1
DSW_LED_DRV: DS8H6.2(C) EU8H1.12
DSW_PWROK: C7R2.1 R7R58.2(B) U6E1.AW41
DSWPG_PIN1: C8D6.1 Q8D9.1 R8D26.2(B)
DSWPG_PIN3: Q8D9.3 R8D33.2(B) U8D1.2
DSWPG_PIN4: R8D8.1 U8D1.4(Y_N)
DUMMY_LOAD_G: Q3G2.6 R3G35.2(B) R3G36.2(B) R3G37.2(B) R3G38.2(B) R3G39.2(B) R3G40.2(B)
EC_5VDUAL_MONITOR: J6J2.44 R6J2.2(B) R6J9.1
EC_12VS_MONITOR: J6J2.62 R6J17.1 R6J28.2(B)
EC_DS3: J6J2.61 R5J21.1 U8F6.75
EC_EEPROM_WP: R7L1.2(B) R8L5.1 U8L2.7(WP)
EC_FAN_PWR_DISABLE_N: J6J2.74 R1E46.1 U8F6.119
EC_GP102_CR_STRAP: R5J14.2(B) R9G15.2(B) U8F6.68
EC_M.2_SSD_PLN_D_N: CR8H3.2 R8H52.1
EC_M.2_SSD_PLN_N: CR8H3.1(CATHODE) R5J16.2(B) U8F6.72
EC_PCH_SPI_OE_N: J6J2.132 R5J12.2(B) R7U32.1 U8F6.50
EC_SHD_CS_AIC_N: J6J2.164 R9U13.1
EC_SHD_CS_N: R9F14.2(B) R9U14.1 U8F6.27
EC_SHD_CS_N_R: R9F11.1 R9U7.1 R9U8.1 R9U13.2(B) R9U14.2(B)
EC_SHD_IO0: R9U18.1 U8F6.28
EC_SHD_IO0_AIC: J6J2.148 R9U17.1
EC_SHD_IO0_R: R9U11.1 R9U12.1 R9U17.2(B) R9U18.2(B)
EC_SHD_IO1: R9U16.1 U8F6.29
EC_SHD_IO1_AIC: J6J2.156 R9U15.1
EC_SHD_IO1_R: R9U5.1 R9U6.1 R9U15.2(B) R9U16.2(B)
EC_SHD_IO2: R9F20.1 U8F6.30
EC_SHD_IO2_R: R9F17.1 R9F20.2(B) R9U3.1 R9U4.1
EC_SHD_IO3: R9F19.1 U8F6.31
EC_SHD_IO3_R: R9F16.1 R9F19.2(B) R9U1.1 R9U2.1
EC_SHD_SCLK: R9U20.1 U8F6.32
EC_SHD_SCLK_AIC: J6J2.140 R9U19.1
EC_SHD_SCLK_R: R9U9.1 R9U10.1 R9U19.2(B) R9U20.2(B)
EC_SLP_S0_CS_N: R9F22.1 U6E1.Y48
EC_SMI_N: CR8F6.1(CATHODE) J6J2.224 J7J1.24 R8F17.1 R8F26.2(B) U8F6.1
EC_SMI_R_N: CR8F6.2 R8F26.1 R8F32.2(B) U6E1.AL15
EC_SPI_CS_N: EU9E1.1 J9E9.2 R9E29.2(B) R9U8.2(B)
EC_SPI_HOLD_N: EU9E1.7 R8E45.2(B) R9U2.2(B)
EC_SPI_MISO: EU9E1.2 J9E9.10 R9E30.2(B) R9U5.2(B)
EC_SPI_MOSI: EU9E1.5 J9E9.12 R9U11.2(B)
EC_SPI_OE_N: R7G1.1 R7G2.1 R7U30.2(B) R7U31.2(B) R7U32.2(B) U7U1.1(OE_N) U7U1.4 U7U1.10 U7U1.13 U7U2.4 U7U2.10 U7U2.13
EC_SPI_OE_RC_N: C7G1.1 Q7G1.1 R7G1.2(B)
EC_SPI_SCLK: EU9E1.6 J9E9.7 R9U10.2(B)
EC_SPI_WP_N: EU9E1.3 R9E31.2(B) R9U4.2(B)
EC_SUS_CLK: R7F17.2(B) R8F39.1 R8F42.1
EC_SUS_CLK_AIC: J6J2.236 R8F39.2(B)
EC_THERM_STRAP: J9E7.2(IO2) R9E28.1 U8E3.11
EC_THERM_STRAP_PU: J9E7.1 R9E24.2(B)
EC_UART_CTS_N: R5J17.2(B) R7G28.2(B) U8F6.108
EC_UART_CTS_TTK: J7G1.4 R7G28.1
EC_UART_RTS_N: R5J15.2(B) R7G29.2(B) U8F6.107
EC_UART_RTS_TTK: J7G1.6 R7G29.1
EC_UART_RX: R9B15.2(B) U8F6.80
EC_UART_RX_AIC: J6J2.212 R9B14.2(B)
EC_UART_RX_HDR: J9B6.1 R9B25.1
EC_UART_RX_R: R9B14.1 R9B15.1 R9B21.2(B) R9B25.2(B)
EC_UART_RX_TTK: J7G1.8 R9B21.1
EC_UART_TX: R8G20.2(B) R9B12.2(B) R9G18.2(B) U8F6.81
EC_UART_TX_AIC: J6J2.220 R9B13.2(B)
EC_UART_TX_HDR: J9B5.1 R9B24.1
EC_UART_TX_R: R9B12.1 R9B13.1 R9B20.2(B) R9B24.2(B)
EC_UART_TX_TTK: J7G1.10 R9B20.1
EC_V5S_MONITOR: J6J2.78 R6J18.1 R6J29.2(B)
EC_WAKE_CLK_R: J6J2.30 R8F13.2(B) R9F1.2(B) U8F6.85
ECAIC_BUF_CTS_N: J6J2.204
ECDBG_CLK_HDR: J9F5.5(IO5) R9F28.1 R9F30.2(B)
ECDBG_DATA_HDR: J9F5.4 R9F24.1 R9F27.2(B)
ECDBG_ICSP_CLK: R9F28.2(B) U8F6.101
ECDBG_ICSP_DAT: R9F24.2(B) U8F6.102
ECDBG_ICSP_MCLR: R9F21.2(B) R9F23.2(B) U8F6.87
ECDBG_MCLR_HDR: J9F5.1 R9F23.1
EDP_ALS_INT_R_N: J1B2.43 J1D2.2(IO2) R1D2.2(B) R6F31.2(B)
EDP_C_TX0_DN: C1B14.2(B) R1B30.1 U1B3.4(PIN4)
EDP_C_TX0_DP: C1B13.2(B) R1B27.2(B) U1B3.1
EDP_C_TX1_DN: C1B17.2(B) R1B33.1 U1B4.4(PIN4)
EDP_C_TX1_DP: C1B15.2(B) R1B32.2(B) U1B4.1
EDP_C_TX2_DN: C1B19.2(B) R1B37.1 U1B5.4(PIN4)
EDP_C_TX2_DP: C1B18.2(B) R1B35.2(B) U1B5.1
EDP_C_TX3_DN: C1B21.2(B) R1B41.1 U1B6.4(PIN4)
EDP_C_TX3_DP: C1B20.2(B) R1B38.2(B) U1B6.1
EDP_D_TX0_DN: J1B2.23 R1B30.2(B) U1B3.3
EDP_D_TX0_DP: J1B2.24 R1B27.1 U1B3.2
EDP_D_TX1_DN: J1B2.20 R1B33.2(B) U1B4.3
EDP_D_TX1_DP: J1B2.21 R1B32.1 U1B4.2
EDP_D_TX2_DN: J1B2.17 R1B37.2(B) U1B5.3
EDP_D_TX2_DP: J1B2.18 R1B35.1 U1B5.2
EDP_D_TX3_DN: J1B2.14 R1B41.2(B) U1B6.3
EDP_D_TX3_DP: J1B2.15 R1B38.1 U1B6.2
EDP_HPD_PD: Q1C2.2(S) R7P9.1 U6E1.AN6
EDP_TX0_DN: C1B14.1 J3D1.M14
EDP_TX0_DP: C1B13.1 J3D1.M15
EDP_TX1_DN: C1B17.1 J3D1.N14
EDP_TX1_DP: C1B15.1 J3D1.N15
EDP_TX2_DN: C1B19.1 J3D1.L15
EDP_TX2_DP: C1B18.1 J3D1.L14
EDP_TX3_DN: C1B21.1 J3D1.K13
EDP_TX3_DP: C1B20.1 J3D1.L13
EMB_AUXN: C1B11.2(B) J1B2.27 R1B22.2(B)
EMB_AUXP: C1B12.2(B) J1B2.26 R1B23.1
EMB_HPD: J1B2.10 Q1C2.3 R1B42.1
EMB_VDDEN_D_N: C1C10.2(B) Q1C1.1 R1C33.2(B)
EMB_VDDEN_N: Q1C3.3 R1C21.2(B) R1C33.1
EN_FET_GLITCH_SLP: J9E5.1 Q7F1.3 R7F9.2(B)
EN_FET_GLITCH_SLP_HDR: J9E5.2(IO2) Q8H4.1 Q8H6.1 Q8H7.1 R8H56.1
EQ_ADDR0: EU2A7.5 R2A43.1 R2A45.2(B)
EXP_A_RX_0_DN: J3D1.H12 J5B2.A17
EXP_A_RX_0_DP: J3D1.G12 J5B2.A16
EXP_A_RX_1_DN: J3D1.G11 J5B2.A22
EXP_A_RX_1_DP: J3D1.F11 J5B2.A21
EXP_A_RX_2_DN: J3D1.H10 J5B2.A26
EXP_A_RX_2_DP: J3D1.G10 J5B2.A25
EXP_A_RX_3_DN: J3D1.G9 J5B2.A30
EXP_A_RX_3_DP: J3D1.F9 J5B2.A29
EXP_A_RX_4_DN: J3D1.K9 J5B2.A36
EXP_A_RX_4_DP: J3D1.J9 J5B2.A35
EXP_A_RX_5_DN: J3D1.E6 J5B2.A40
EXP_A_RX_5_DP: J3D1.E7 J5B2.A39
EXP_A_RX_6_DN: J3D1.F5 J5B2.A44
EXP_A_RX_6_DP: J3D1.F6 J5B2.A43
EXP_A_RX_7_DN: J3D1.G6 J5B2.A48
EXP_A_RX_7_DP: J3D1.G7 J5B2.A47
EXP_A_RX_8_DN: J3D1.H6 J5B2.A53
EXP_A_RX_8_DP: J3D1.H5 J5B2.A52
EXP_A_RX_9_DN: J3D1.J7 J5B2.A57
EXP_A_RX_9_DP: J3D1.J6 J5B2.A56
EXP_A_RX_10_DN: J3D1.K6 J5B2.A61
EXP_A_RX_10_DP: J3D1.K5 J5B2.A60
EXP_A_RX_11_DN: J3D1.L7 J5B2.A65
EXP_A_RX_11_DP: J3D1.L6 J5B2.A64
EXP_A_RX_12_DN: J3D1.M6 J5B2.A69
EXP_A_RX_12_DP: J3D1.M5 J5B2.A68
EXP_A_RX_13_DN: J3D1.N7 J5B2.A73
EXP_A_RX_13_DP: J3D1.N6 J5B2.A72
EXP_A_RX_14_DN: J3D1.P6 J5B2.A77
EXP_A_RX_14_DP: J3D1.P5 J5B2.A76
EXP_A_RX_15_DN: J3D1.R7 J5B2.A81
EXP_A_RX_15_DP: J3D1.R6 J5B2.A80
EXP_A_TX_0_C_DN: C5B33.2(B) J5B2.B15
EXP_A_TX_0_C_DP: C5B32.2(B) J5B2.B14
EXP_A_TX_0_DN: C5B33.1 J3D1.B8
EXP_A_TX_0_DP: C5B32.1 J3D1.A8
EXP_A_TX_1_C_DN: C5C2.2(B) J5B2.B20
EXP_A_TX_1_C_DP: C5C1.2(B) J5B2.B19
EXP_A_TX_1_DN: C5C2.1 J3D1.C7
EXP_A_TX_1_DP: C5C1.1 J3D1.B7
EXP_A_TX_2_C_DN: C5C4.2(B) J5B2.B24
EXP_A_TX_2_C_DP: C5C3.2(B) J5B2.B23
EXP_A_TX_2_DN: C5C4.1 J3D1.A5
EXP_A_TX_2_DP: C5C3.1 J3D1.A6
EXP_A_TX_3_C_DN: C5C15.2(B) J5B2.B28
EXP_A_TX_3_C_DP: C5C14.2(B) J5B2.B27
EXP_A_TX_3_DN: C5C15.1 J3D1.B4
EXP_A_TX_3_DP: C5C14.1 J3D1.B5
EXP_A_TX_4_C_DN: C5C22.2(B) J5B2.B34
EXP_A_TX_4_C_DP: C5C18.2(B) J5B2.B33
EXP_A_TX_4_DN: C5C22.1 J3D1.C3
EXP_A_TX_4_DP: C5C18.1 J3D1.C4
EXP_A_TX_5_C_DN: C5C28.2(B) J5B2.B38
EXP_A_TX_5_C_DP: C5C26.2(B) J5B2.B37
EXP_A_TX_5_DN: C5C28.1 J3D1.D2
EXP_A_TX_5_DP: C5C26.1 J3D1.D3
EXP_A_TX_6_C_DN: C5C30.2(B) J5B2.B42
EXP_A_TX_6_C_DP: C5C29.2(B) J5B2.B41
EXP_A_TX_6_DN: C5C30.1 J3D1.E1
EXP_A_TX_6_DP: C5C29.1 J3D1.E2
EXP_A_TX_7_C_DN: C5C36.2(B) J5B2.B46
EXP_A_TX_7_C_DP: C5C35.2(B) J5B2.B45
EXP_A_TX_7_DN: C5C36.1 J3D1.F2
EXP_A_TX_7_DP: C5C35.1 J3D1.F3
EXP_A_TX_8_C_DN: C5C40.2(B) J5B2.B51
EXP_A_TX_8_C_DP: C5C39.2(B) J5B2.B50
EXP_A_TX_8_DN: C5C40.1 J3D1.G1
EXP_A_TX_8_DP: C5C39.1 J3D1.G2
EXP_A_TX_9_C_DN: C5D3.2(B) J5B2.B55
EXP_A_TX_9_C_DP: C5D2.2(B) J5B2.B54
EXP_A_TX_9_DN: C5D3.1 J3D1.H2
EXP_A_TX_9_DP: C5D2.1 J3D1.H3
EXP_A_TX_10_C_DN: C5D7.2(B) J5B2.B59
EXP_A_TX_10_C_DP: C5D6.2(B) J5B2.B58
EXP_A_TX_10_DN: C5D7.1 J3D1.J1
EXP_A_TX_10_DP: C5D6.1 J3D1.J2
EXP_A_TX_11_C_DN: C5D10.2(B) J5B2.B63
EXP_A_TX_11_C_DP: C5D9.2(B) J5B2.B62
EXP_A_TX_11_DN: C5D10.1 J3D1.K2
EXP_A_TX_11_DP: C5D9.1 J3D1.K3
EXP_A_TX_12_C_DN: C5D12.2(B) J5B2.B67
EXP_A_TX_12_C_DP: C5D11.2(B) J5B2.B66
EXP_A_TX_12_DN: C5D12.1 J3D1.L1
EXP_A_TX_12_DP: C5D11.1 J3D1.L2
EXP_A_TX_13_C_DN: C5D15.2(B) J5B2.B71
EXP_A_TX_13_C_DP: C5D14.2(B) J5B2.B70
EXP_A_TX_13_DN: C5D15.1 J3D1.M2
EXP_A_TX_13_DP: C5D14.1 J3D1.M3
EXP_A_TX_14_C_DN: C5D21.2(B) J5B2.B75
EXP_A_TX_14_C_DP: C5D18.2(B) J5B2.B74
EXP_A_TX_14_DN: C5D21.1 J3D1.N1
EXP_A_TX_14_DP: C5D18.1 J3D1.N2
EXP_A_TX_15_C_DN: C5D27.2(B) J5B2.B79
EXP_A_TX_15_C_DP: C5D26.2(B) J5B2.B78
EXP_A_TX_15_DN: C5D27.1 J3D1.P2
EXP_A_TX_15_DP: C5D26.1 J3D1.P3
FAN_PWREN: EU1E2.2 EU1E2.3 R1E45.2(B) R1E46.2(B) R1E47.1
FN1_C3: R2L2.2(B) R3L3.1 U3A5.C3
FOX_CLKREQ_N: EU7A3.3 R7B11.2(B)
FOX_ULP_WAKE_N: EU7A3.4 R7B12.2(B) R7M2.2(B)
FOX_WAKE_N: R6B10.1 R7E44.2(B)
FP_HDD_LED_G_N: CP9H1.2 J9H1.3 R9G41.1
FP_RST_DEBUG_N: R6H20.2(B) R6H21.2(B) R6H23.2(B) SW5H1.1 SW5H1.2
FP_RST_N: C9G7.1 J8J13.31 J9H1.7 R1C40.2(B) R6H23.1 R7G27.2(B) U6E1.AU2
FP_RST_TTK_N: J7G1.2 R7G27.1
FP_SW_ON_N: C9G8.1 J9H1.6 R5H9.1 R5H10.1 R7H6.1
FPF_LDOMON: TP6T2.1(TP) U6E1.AL35(TP)
FRU_A0: R8J2.1 R8J3.2(B) U8J2.1
FRU_A1: R8J4.1 R8J5.2(B) U8J2.2
FRU_A2: R8J6.1 R8J7.2(B) U8J2.3
FRU_WP: R7J10.2(B) R7J11.1 U8J2.7(WP)
G3SHARING_SAF_N_DETECT: J9G1.1 R9G3.2(B) U8E3.6
GATE_SEL_1G97_22: R8D81.2(B) U8D11.1
GATE_SEL_1G97_55: R8D77.2(B) U8D9.3
GATE_SEL_1G97_BFCDSW: R8C26.2(B) U8C1.1
GATE_SEL_1G97_PGPS: R8C49.2(B) U8C3.1
GATE_SEL_1G97_VREN: R5C50.2(B) U5C2.1
GP39_GFX_CRB_DETECT: R7F36.1 R7F43.2(B) R7F47.1
GPD_1_FOXLAN_DEV_OFF_N: CR7F1.1(CATHODE) R7F4.2(B) U6E1.BG42
GPD_7: R7E61.2(B) R7F2.2(B) U6E1.BE41
GPIO_GRN_BLNK_BRD: CR9H1.1 Q8G6.3 R8G38.1 R9H4.2(B)
GPIO_GRN_BLNK_HDR: Q8G5.3 R8H74.1 R9G22.1
GPIO_GRN_BLNK_HDR_R: C8H24.1 CP9H1.3 J8J2.3(IO3) J9H1.2 R8H73.2(B) R8H74.2(B) R9H1.2(B)
GPIO_PCIE_SLOT2_WAKE_N: R6F3.1 R6F8.2(B) R7B65.2(B) R7B69.1 U6E1.AB47
GPIO_PCIE_SLOT3_WAKE_N: R7E19.2(B) R7E20.1 R8B20.1 R8B21.2(B) U6E1.BF24
GPIO_PCIESLOT2_RST_N: R7B68.1 U6E1.AP2
GPIO_PCIESLOT2_RST_R_N: R7B61.1 R7B67.2(B) R7B68.2(B) U7B3.2
GPIO_PCIESLOT3_RST_N: R7P2.1 U6E1.AN4
GPIO_PCIESLOT3_RST_R_N: R7P2.2(B) R8C51.1 R9C18.2(B) U9C2.2
GPIO_PEG_RST_N: R7F25.1 U6E1.AT49
GPIO_SSD2_RST_N: R5C7.2(B) R5C11.1 R7P7.2(B) U5C1.2
GPIO_SSD2_RST_R_N: R7P7.1 U6E1.AM7
GPIO_SSD_RST_N: R8G43.1 U6E1.AB48
GPIO_SSD_RST_R_N: R8G33.1 R8G43.2(B) R8G45.2(B) U8G1.2
GPIO_WLAN_RST_N: R7T8.1 U6E1.AN40
GPIO_WLAN_RST_R_N: R7T8.2(B) R7T19.2(B) R8E58.1 U8F1.2
GPIO_WLAN_WAKE_N: R6T13.1 R7B28.1 U6E1.AE39
GPIO_YLW_BLNK_BRD: CR9H1.3 Q8H5.3
GPIO_YLW_BLNK_HDR: Q8H1.3 R8H72.1 R9H20.1
GPIO_YLW_BLNK_HDR_R: C8H23.1 CP9H1.1 J8J2.1 J9H1.4 R8H72.2(B)
GPP_A_8_CLKRUN_N: R7R53.2(B) R7R56.1 U6E1.AV32
GPP_A_8_CLKRUN_R_N: J6J2.171 J7J1.18 R7R56.2(B) U8F6.63
GPP_B_14_SPKR: R7R51.1 R7R52.2(B) R9G31.1 R9G32.1 U6E1.AW29
GPP_E_0_SATAPCIE_0_SATAGP_0: R6H8.1 R6H9.1 U6E1.AH41
GPP_E_1_SATAPCIE_1_SATAGP_1: R5H6.1 R6H24.1 U6E1.AJ43
GPP_E_2_SATAPCIE_2_SATAGP_2: R6H25.1 R6H34.1 U6E1.AK47
GPP_E_3_CPU_GP_0: R6H26.1 U6E1.AL47
GPP_E_4_SATA_DEVSLP_0: R6H27.1 R6H35.1 U6E1.AL48
GPP_E_5_SATA_DEVSLP_1: R6H28.1 R7T12.1 U6E1.AH35
GPP_E_6_SATA_DEVSLP_2: R6H29.1 R6H36.1 U6E1.AH40
GPP_E_7_CPU_GP1: R6H30.1 R7F29.1 U6E1.AM45
GPP_E_8_SATA_LED_N: R6H31.1 R9G36.1 U6E1.AK48
GPP_E_9_USB_OC0_N: C6R2.1 R6H10.1 R6T5.2(B) U6E1.AH36
GPP_E_10_USB_OC1_N: R6H11.1 R7T25.2(B) R7T26.1 R7T27.2(B) U6E1.AL40
GPP_E_11_USB_OC2_N: C6R3.1 CR6H1.2 R6H12.1 R6T17.2(B) R6T18.1 R6T19.2(B) U6E1.AJ44
GPP_E_12_USB_OC3_N: C6R4.1 CR6H2.2 CR8F1.2 R6H1.2(B) R6H18.2(B) U6E1.AL41
GPP_F_0_SATAPCIE_3_SATAGP_3: R6H3.1 R6H14.1 U6E1.AN47
GPP_F_1_SATAPCIE_4_SATAGP_4: R6H15.1 R7F51.1 U6E1.AM46
GPP_F_2_SATAPCIE_5_SATAGP_5: R6H4.1 R6H16.1 U6E1.AM43
GPP_F_3_SATAPCIE_6_SATAGP_6: R6H5.1 R6H17.1 U6E1.AM47
GPP_F_4_SATAPCIE_7_SATAGP_7: R6H2.1 R6H13.1 U6E1.AM48
GPP_F_5_SATA_DEVSLP_3: R7F27.1 U6E1.AP48
GPP_F_6_SATA_DEVSLP_4: R8G82.2(B) R8H39.2(B) U6E1.AR47
GPP_F_7_SATA_DEVSLP_5: R7F28.1 U6E1.AN46
GPP_F_8_SATA_DEVSLP_6: R7T11.1 U6E1.AN37
GPP_F_9_SATA_DEVSLP_7: R7F26.1 U6E1.AP47
GPP_F_10_SATA_SLOCK: R7T16.2(B) U6E1.AR42
GPP_F_12_SATA_SDATAOUT1: R7F50.2(B) U6E1.AU46
GPP_F_13_SATA_SDATAOUT0: R7F36.2(B) U6E1.AU47
GPP_F_14_EXT_PWR_GATE_PS_ON_N: R7T9.1 U6E1.AP41
GPP_F_15_USB_OC4_N: R7F35.2(B) U6E1.AV47
GPP_F_16_USB_OC5_N: R7T3.2(B) U6E1.AR35
GPP_F_17_USB_OC6_N: CR7T1.2 CR8F2.2 R7T13.2(B) U6E1.AR37
GPP_F_18_USB_OC7_N: R3B16.2(B) U6E1.AV43
GPP_H_5_WAKE_SLTBC_L: R5J3.2(B) U6E1.AC39
GPP_H_15: R5A58.1 R6T6.1 R6T11.2(B) R7F44.2(B) U6E1.AC47
GPP_I_0_DDSP_HPD_0: Q1A1.2(S) R1A6.1 U6E1.AT6
GPP_I_1_DDSP_HPD_1: R2A70.1 U6E1.AN10
GPP_I_2_DDSP_HPD_2: R5B1.1 R5B2.1 R5B8.1 U6E1.AP9
GPP_K_9_FOXLAN_PWR_EN: R6A40.1 R6T15.2(B) U6E1.V47
GPP_K_14_EDP_ALS_INT_N: R6F31.1 U6E1.W46
GPP_K_19_SMI_N: R6W1.1 U6E1.T48
GPP_K_19_SMI_R_N: J7J1.25 R6W1.2(B) R6W2.2(B)
GPPC_B2_UART_BT_WAKE_N: J7C1.20 R7B77.1 R7E38.1
GPPC_C8_TCH_PAD_INT_N_ECAIC: J6J2.186
GPPJ_RCOMP: R7R4.1 U6E1.BD1 U6E1.BE1 U6E1.BE2
GSPI2_MISO_BSSB_CLK: R7R21.2(B) R9D40.1 R9D41.1
GSPI2_MOSI_BSSB_DI: R7R15.2(B) R9D38.1 R9D39.1
GSVTT_PWROK_BJT: Q8C7.6 R8C41.1
H8S_EEPROM_WP: R7H57.1 U7H3.7(WP)
H_CATERR_N: EU8H2.4 J3D1.D16 R8H37.2(B)
H_CPU_SVIDALRT_R_N: J1G4.1 R1G6.1 R4C2.2(B) R4C8.2(B)
H_CPU_SVIDCLK_R: J1G5.1 R1H2.1 R4C3.2(B) R4C9.2(B)
H_CPU_SVIDDAT_R: J1G3.1 R1G5.1 R4C1.2(B) R4C7.2(B)
H_PECI: J3D1.A15 R7D24.1 R8G24.1
H_PM_DOWN: R4C5.1 R4C6.2(B) U6E1.AE2
H_PM_DOWN_R: J3D1.D13 R4C6.1
H_PM_SYNC: J3D1.C15 R6D66.1
H_PM_SYNC_R: R6D66.2(B) U6E1.AF3
H_PRDY_N: J3D1.L34 R1C97.1 R2C26.2(B)
H_PREQ_N: J3D1.K35 R1C101.1 R2C27.2(B)
H_PROCHOT_BUFF_N: C8E18.1 R8E56.1 R8F71.2(B) U8F3.4(Y)
H_PROCHOT_EC_N: J6J2.201 R8F31.1 R8F70.2(B) R8F71.1 U8F3.2 U8F6.4
H_PROCHOT_N: R4B35.2(B) R4B40.2(B) R4C4.2(B) R5B45.1 R5B82.2(B) R8E56.2(B)
H_PROCHOT_R_N: C4B35.1 J3D1.A16 R4B40.1
H_PWRGD: C4B36.1 J3D1.D14 R6D67.2(B)
H_PWRGD_R: R6D67.1 U6E1.AE3
H_PWRGD_R21BV: Q8C7.3 R8C47.1
H_SKTOCC_N: J3D1.AC37 J4J2.1 Q4J1.2(E) R4J5.2(B) R7D46.1
H_SKTOCC_N_R: R7D46.2(B) U6E1.AP3
H_TCK: J3D1.M40 R1C32.1 R2C28.1
H_TDI: J3D1.N39 R1C23.1 R2C31.2(B)
H_TDO: J3D1.N40 R1C25.1 R2C30.2(B)
H_THERMTRIP_N: J3D1.AF3 R4D8.1
H_TMS: J3D1.L39 R1C22.1 R2C29.2(B)
H_TRST_N: J3D1.N38 R1C24.1
HD_LED_N: CR9G4.2(C) Q9G6.3 R9G34.2(B) R9G35.1 R9G41.2(B)
HDA_BCLK_I2S0_SCLK: R7E8.1 R7E9.1 R7E10.1 U6E1.BD11
HDA_BCLK_I2S0_SCLK_HDR: J9A4.1 R7E9.2(B)
HDA_CODEC_BCLK: C6A32.2(B) R6A64.1 R7E10.2(B)
HDA_CODEC_BCLK_R: EU6A1.11 R6A64.2(B)
HDA_CODEC_RESETO: EU6A1.10 R6A46.1 R6A63.2(B) R8B7.1
HDA_CODEC_RESETO_R: Q8B1.2(E) R8B7.2(B)
HDA_CODEC_SDI: EU6A1.13 R6A50.2(B)
HDA_CODEC_SDI_R: R6A50.1 R7E2.2(B)
HDA_CODEC_SDO: EU6A1.14 R7E7.2(B)
HDA_CODEC_SYNC: EU6A1.12 R6A47.1 R6A55.2(B) R7E5.2(B)
HDA_PCH_PWREN: J9A4.13 R9B4.2(B) R9B5.2(B) R9B6.2(B)
HDA_RST_N_I2S_MCLK_HDR: J9A4.3 R9A8.2(B)
HDA_RST_N_SNDW1_CLK: R9A11.2(B) R9A12.1
HDA_RST_N_SW1_CK_I2S_MCLK_HDR: R9A7.1 R9A8.1 R9A12.2(B) R9A13.2(B)
HDA_RSTB_I2S1_SCLK: R7D50.1 R7E11.1 U6E1.BE10
HDA_RSTB_I2S1_SCLK_R: R7D50.2(B) R9A10.1 R9A11.1
HDA_SDI0_I2S0_RXD_HDR: J9A4.9(IO9) R9B3.2(B)
HDA_SDI0_I2S0_RXD_HDR_R: R7E1.2(B) R9B3.1
HDA_SDI_0_I2S0_RXD: R7E1.1 R7E2.1 U6E1.BE11
HDA_SDI_1_I2S1_RXD: R7E12.1 U6E1.BF10
HDA_SDI_1_I2S1_RXD_HDR: J9A4.11 R9A5.2(B)
HDA_SDI_1_I2S1_RXD_SW1_DATA: R7E12.2(B) R9A5.1 R9A6.1
HDA_SDO_I2S0_TXD: R7E4.2(B) R7E6.1 R7E7.1 U6E1.BF12
HDA_SDO_I2S0_TXD_HDR: J9A4.7 R7E6.2(B)
HDA_SDO_I2S0_TXD_J: J7D2.2(IO2) R7E4.1
HDA_SYNC_I2S0_SFRM: R7E3.1 R7E5.1 U6E1.BG13
HDA_SYNC_I2S0_SFRM_HDR: J9A4.5 R7E3.2(B)
HDACPU_SCLK: R7D48.1 U6E1.AM3
HDACPU_SCLK_R: J3D1.M9 R7D48.2(B)
HDACPU_SDI: J3D1.M10 R3P1.1
HDACPU_SDI_R: R3P1.2(B) U6E1.AN3
HDACPU_SDO: R7D49.1 U6E1.AM2
HDACPU_SDO_R: J3D1.N9 R7D49.2(B)
HDD_PROT: J8H2.46 R6W3.1
HDD_PROT_R: J5J2.18 R6W3.2(B)
HDMI_1.2V_ENABLE: EU2A7.37 R2A64.1
HDMI_1P2S_EN: C2A28.1 CR2A4.2 EU2B1.3 R2A64.2(B) R2A65.2(B) R2A71.2(B)
HDMI_1P2S_FB: EU2B1.5 R2A59.1 R2A63.1
HDMI_1P2S_FB_TOP: R2A57.1 R2A59.2(B)
HDMI_1P2S_PGOOD: EU2B1.8 R2B4.2(B)
HDMI_RESETB: C2A26.1 EU2A7.35 R2A61.2(B)
HDMIC_ALS_CLK_DN: EU2A7.13 L2A4.4(OUT_2) R2A31.1
HDMIC_ALS_CLK_DP: EU2A7.14 L2A4.1 R2A30.1
HDMIC_ALS_CLK_R_DN: EU2A2.5 EU2A2.6 J2A1.B12 L2A4.3 R2A31.2(B)
HDMIC_ALS_CLK_R_DP: EU2A2.4 EU2A2.7 J2A1.B10 L2A4.2 R2A30.2(B)
HDMIC_ALS_DATA0_DN: EU2A7.16 L2A3.4(OUT_2) R2A29.1
HDMIC_ALS_DATA0_DP: EU2A7.17 L2A3.1 R2A28.1
