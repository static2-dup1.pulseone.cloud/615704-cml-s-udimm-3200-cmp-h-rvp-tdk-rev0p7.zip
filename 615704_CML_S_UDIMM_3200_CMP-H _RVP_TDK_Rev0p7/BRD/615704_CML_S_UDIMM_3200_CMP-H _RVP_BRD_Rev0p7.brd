# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_SSD_PWREN: length 159
  TOP w0.089: U6E1.AE43 v1(101.52,138.08)
  TOP w0.1: R5C49.1 v1(152.9,202.44)
  LAY5 w0.125: v1(152.9,202.44) 151.38,202.44 150.74,201.8 150.74,199.62 152.25,198.11 153.52,198.11 154.43,197.2 154.43,193.29 153.31,192.17 153.31,178.69 151.25,176.63 151.25,165.86 151.25,165.85 151.25,163.96 150.62,163.32 150.62,159.64 151.63,158.62 151.63,156.67 151.1,156.13 150.47,156.13 150.24,156.36 149.27,156.36 147.32,154.41 147.32,152.14 142.74,147.57 142.74,134.08 140.74,132.08 139.34,132.08 136.26,129 136.26,123.27 129.44,116.45 120.65,116.45 118.99,114.8 118.99,113.94 v1(118.97,113.92)
  LAY6 w0.125: v1(104.14,116.33) 110.74,116.33 113.15,113.92 v1(118.97,113.92)
  BOTTOM w0.1: v1(104.14,116.33) R6T3.2 103.37,115.57 101.62,117.32 101.62,118.42 100.17,119.87 100.17,127.47 101.06,128.37 101.06,135.23 102.1,136.27 102.1,137.49 v1(101.52,138.08)
CPU_SSD_PWREN_N: length 6.8
  TOP w0.1: Q5C3.5 151.52,208.04 152.01,208.53 154.05,208.53 R5C30.2 155.79,207.55 Q5C2.3
CPU_SSD_PWREN_R: length 7.3
  TOP w0.1: Q5C4.2 153.99,204.15 153.67,203.83 R5C49.2 154.05,203.33 155.19,204.47 155.19,205.74 155.44,205.99 156.21,205.99 156.44,205.75 Q5C2.5
CPU_SUSCLK: length 3.6
  TOP w0.1: U7F1.4 71.62,116.49 R7F19.2
CPU_TACH_OUT: length 6.4
  TOP w0.2: R1E25.2 296.03,151.76 R1E18.1 296.29,153.16 298.7,153.16 J1E3.3
CPU_VCCIO_PWR_GATEB: length 459.8
  TOP w0.1: R5D30.2 154.3,170.05 154.43,169.92 154.43,168.22 v1(157.65,165) ; U8D7.4 45.72,174.24 v1(46.48,175) 46.95,174.53 47.36,174.53 47.37,174.52 R8D67.2 R8D95.1 ; R5C56.2 161.92,197.98 v1(161.83,197.89) ; R5E13.1 R5E14.1 157.5,154.15 157.5,155.68 157.35,155.83 v1(157.35,156.44) ; R7B32.1 v1(82.67,247.65) ; v1(260.78,260.48) 261.49,259.76 R2B2.1
  LAY5 w0.125: v1(49.91,251.84) 50.25,251.5 52.1,251.5 52.45,251.85 69.45,251.85 69.81,251.5 70.65,251.5 72.6,249.55 77.76,249.55 78.76,248.55 81.78,248.55 v1(82.67,247.65) 83.69,247.65 86.48,244.85 88.9,244.85 89.44,244.31 101.29,244.31 102,245.02 103.46,245.02 104.17,244.31 105.16,244.31 105.81,244.97 107.74,244.97 108.98,243.72 111.86,243.72 112.07,243.93 115.88,243.93 116.42,243.39 126.12,243.39 127.32,244.59 130.42,244.59 132.32,246.5 133.9,246.5 138.34,250.94 148.34,250.94 149.48,249.8 156.75,249.8 158.4,251.45 172.98,251.45 v1(175.05,249.38) ; v1(191.97,252.22) 192.52,251.67 193.17,251.67 194.06,252.56 194.06,252.99 195.3,254.23 198.32,254.23 199.02,254.93 199.27,254.93 200,255.66 210.26,255.66 210.54,255.93 212.95,255.93 213.94,256.92 222.12,256.92 223.38,255.66 225.76,255.66 226.28,256.18 229.36,256.18 229.48,256.06 232.02,256.06 233.39,257.43 236.34,257.43 237.1,258.19 246.61,258.19 247.01,258.59 252.24,258.59 252.86,259.21 254.5,259.21 255.77,260.48 v1(260.78,260.48)
  LAY6 w0.125: v1(46.48,175) 46.99,175.52 46.99,183.76 45.59,185.16 44.7,185.16 44.07,185.79 44.07,192.29 43.18,193.19 43.18,198.88 42.49,199.57 42.49,201.11 43.06,201.68 43.06,204.09 42.67,204.48 42.67,205.72 43.17,206.22 43.17,209.02 42.51,209.68 39.44,209.68 35.69,213.42 35.69,235.88 36.38,236.57 36.38,239.72 37.33,240.66 38.35,240.66 39.24,241.55 42.67,241.55 43.56,242.44 44.93,242.44 47.24,244.75 47.24,248.05 49.91,250.72 v1(49.91,251.84) ; v1(191.97,252.22) 191.16,252.22 189.46,250.52 185.76,250.52 184.04,248.8 175.63,248.8 v1(175.05,249.38) 175.03,249.4 173.33,249.4 172.97,249.05 172.97,248.54 176.06,245.45 176.06,239.65 174.02,237.62 171.83,237.62 171.29,237.08 168.31,237.08 165.48,234.25 165.48,228.19 162.21,224.93 162.21,220.21 162.96,219.46 167.66,219.46 168.65,218.46 168.65,216.13 167.66,215.13 166.9,215.13 165.73,213.97 165.73,209.17 163.44,206.89 163.44,205.48 164.4,204.53 164.4,200.46 v1(161.83,197.89) 164.4,195.33 164.4,191.07 165.16,190.3 165.16,182.19 162.92,179.94 162.28,179.94 160.62,178.28 160.62,175.65 160.45,175.47 160.45,171.19 159.82,170.56 159.82,167.16 v1(157.65,165) 158.11,164.54 158.11,158.98 157.88,158.75 157.88,157.12 157.35,156.59 v1(157.35,156.44)
CPU_VIDALERT_N: length 53.4
  TOP w0.089: 214.63,203.2 214.63,200.74 215.38,199.99 215.38,199.01 J3D1.A14
  TOP w0.1: R4C8.1 176.27,219.85 183.37,212.74 193.94,212.74 195.43,211.26 207.37,211.26 214.63,204 214.63,203.2
CPU_VIDSCK: length 55
  TOP w0.089: 214.88,203.2 214.88,200.84 215.72,200 215.72,197.88 215.38,197.54 215.38,197.18 J3D1.C14
  TOP w0.1: R4C9.1 177.03,219.76 183.57,213.22 194.14,213.22 195.63,211.73 207.19,211.73 214.88,204.04 214.88,203.2
CPU_VIDSOUT: length 55
  TOP w0.089: J3D1.B14 215.22,198.09 215.02,198.3 215.02,199.26 215.15,199.39 215.15,199.93 214.37,200.71 214.37,202.94
  TOP w0.1: 214.37,202.94 214.37,203.93 207.53,210.78 195.23,210.78 193.74,212.27 183.18,212.27 175.51,219.94 R4C7.1
CPU_VREF_CA_A0_RC: length 1
  TOP w0.38: 291.97,117.85 R1F8.1
CPU_VREF_CA_A1_RC: length 1
  TOP w0.38: R1F7.1 C1F4.2
CPU_VREF_CA_B0_RC: length 1
  TOP w0.38: R1F25.1 C1F7.2
CPU_VREF_CA_B1_RC: length 0.9
  TOP w0.38: C1F12.2 290.95,97.53 R1F50.1
DB_APP: length 83.6
  TOP w0.2: R3B32.2 237.74,246.76 237.74,245.62 237.49,245.36 R3B43.1 237.99,244.6 v1(238.25,244.85)
  LAY5 w0.2: v1(191.89,244.98) 192.32,244.98 192.95,244.35 195.25,244.35 195.63,244.73 200.61,244.73 202.06,246.18 205.98,246.18 207.22,244.94 210.77,244.94 211.06,244.65 214.38,244.65 214.83,245.11 v1(215.13,245.11) 215.69,245.11 216.65,244.15 218.08,244.15 218.95,245.01 224.26,245.01 225.43,246.18 228.84,246.18 229.98,245.04 238.07,245.04 v1(238.25,244.85) 238.37,244.98 238.8,244.98 239.51,244.27 241.56,244.27 242.32,245.04 247.83,245.04 248.79,246 251.26,246 252.27,244.98 256.92,244.98 257.3,245.36 261.23,245.36 v1(261.49,245.11)
  BOTTOM w0.2: EU3M1.14 237.86,244.34 238.25,244.73 v1(238.25,244.85) ; EU2M1.14 261.1,244.34 261.49,244.73 v1(261.49,245.11) ; EU3M2.14 214.49,244.34 215.13,244.98 v1(215.13,245.11) ; EU4M1.14 191.51,244.34 191.89,244.73 v1(191.89,244.98)
DB_EN1: length 7.7
  BOTTOM w0.2: R3M10.2 233.29,247.39 233.29,246.63 233.93,246 233.93,245.36 R3M21.2 233.55,244.73 233.04,244.22 C3M17.1 234.73,243.33 EU3M1.5
DB_EN2: length 7.7
  BOTTOM w0.2: R3M12.2 209.8,247.52 209.8,246.73 210.56,245.97 210.56,245.36 R3M22.2 210.18,244.73 209.67,244.22 C3M18.1 211.36,243.33 EU3M2.5
DB_EN3: length 7.7
  BOTTOM w0.2: EU2M1.5 257.97,243.33 C2M4.1 256.28,244.22 256.79,244.73 R2M7.2 257.17,245.36 257.17,246 256.54,246.63 256.54,247.39 R2M2.2
DB_EN4: length 7.7
  BOTTOM w0.2: EU4M1.5 188.38,243.33 C4M15.1 186.69,244.22 187.19,244.73 R4M15.2 187.57,245.36 187.57,246 186.94,246.63 186.94,247.39 R4M10.2
DB_VCC1: length 7.4
  TOP w0.3: R3B32.1 237.87,247.9 v1(237.23,248.54) 236.6,247.9 R3B31.1 R3B30.1
  BOTTOM w0.3: v1(237.23,248.54) 236.98,248.28 R3M9.2 236.22,247.9 235.45,247.14 C3M8.1 235.15,246.71 235.15,245.92 235.34,245.73 EU3M1.9
DB_VCC2: length 6.4
  TOP w0.3: R3B29.1 213.68,247.9 v1(213.86,247.72)
  BOTTOM w0.3: EU3M2.9 211.97,245.73 211.73,245.97 211.73,246.66 C3M9.1 212.09,247.14 212.85,247.9 R3M11.2 213.3,248.28 v1(213.86,247.72)
DB_VCC3: length 6.2
  TOP w0.3: R2B8.1 v1(260.47,247.9)
  BOTTOM w0.3: v1(260.47,247.9) 260.09,248.28 R2M1.2 259.46,247.9 258.69,247.14 C2M1.1 258.34,246.66 258.34,245.97 258.58,245.73 EU2M1.9
DB_VCC4: length 6.2
  TOP w0.3: R4B22.1 190.72,247.9 v1(190.88,247.75)
  BOTTOM w0.3: EU4M1.9 188.98,246.9 C4M8.1 189.1,247.14 189.86,247.9 R4M9.2 190.5,248.28 190.88,247.9 v1(190.88,247.75)
DB_ZD: length 79.9
  TOP w0.3: R3B39.1 236.47,245.74 v1(236.47,246.25) 236.34,246.38 R3B31.2
  LAY5 w0.2: v1(190.37,246.25) 190.88,246.25 191.51,246.89 207.26,246.89 207.77,246.38 208.78,246.38 208.9,246.26 210.8,246.26 211.45,245.62 212.47,245.62 v1(213.1,246.25) 213.72,245.63 214.08,245.63 214.41,245.96 214.41,246.34 214.96,246.89 222.75,246.89 223.39,246.25 224.02,246.25 224.66,246.89 229.87,246.89 230.37,246.38 234.69,246.38 235.2,246.89 235.83,246.89 v1(236.47,246.25) 236.98,245.74 237.46,245.74 237.74,246.02 237.74,246.25 238.37,246.89 246.3,246.89 247.06,246.12 247.65,246.12 248.41,246.89 252.22,246.89 252.73,246.38 258.19,246.38 258.57,246.76 259.2,246.76 v1(259.71,246.25)
  BOTTOM w0.2: v1(190.37,246.25) 189.98,245.87 EU4M1.11 ; v1(259.71,246.25) 259.58,246.12 EU2M1.11 ; EU3M1.11 236.34,246.12 v1(236.47,246.25)
  BOTTOM w0.3: EU3M2.11 212.97,246.12 v1(213.1,246.25)
DBLR_MODE: length 126.9
  TOP w0.2: R1B39.1 R1B40.1 289.17,233.42 289.56,233.81 289.56,237.32 288.83,238.04 288.83,241.46 v1(289.17,241.81) ; v1(282.11,245.93) 282.11,246.07 280.79,247.39 272.92,247.39 270.89,249.43 265.17,249.43 v1(263.52,247.78)
  LAY5 w0.2: v1(263.52,247.78) 262.12,247.78 261.49,248.41 260.09,248.41 259.2,247.52 256.79,247.52 256.03,246.76 253.11,246.76 252.6,247.27 238.12,247.27 237.23,246.38 v1(237.23,246.25) 235.96,247.52 233.55,247.52 232.79,246.76 230.88,246.76 230.25,247.39 223.52,247.39 223.39,247.27 214.88,247.27 v1(213.86,246.25) 213.23,246.89 211.83,246.89 211.58,246.63 209.16,246.63 208.91,246.89 208.02,246.89 207.64,247.27 192.12,247.27 v1(191.64,247.75)
  LAY6 w0.2: v1(289.17,241.81) 286.49,241.81 282.37,245.93 v1(282.11,245.93)
  BOTTOM w0.2: EU2M1.12 260.08,245.86 260.98,246.76 260.98,247.52 261.87,248.41 262.89,248.41 v1(263.52,247.78) ; v1(237.23,246.25) 236.84,245.86 EU3M1.12 ; v1(213.86,246.25) 213.47,245.86 EU3M2.12 ; v1(191.64,247.75) 191.64,247.01 190.94,246.31 190.94,245.89 EU4M1.12
DCI_OOB_ENABLE: length 257.5
  TOP w0.1: U8F6.39 16.32,102.29 15.36,103.25 v1(14.35,103.25) ; v1(24,39.37) 24.51,38.86 24.89,38.86 R8H64.1 27.81,38.1 J8H3.2 ; v1(152.27,9.52) 152.27,8.83 150.66,7.22 148.66,7.22 148.23,7.64 145.7,7.64 145.22,8.13 143,8.13 R5J11.2
  LAY3 w0.1: v1(152.27,9.52) 152.27,10.16 152.92,10.81 152.92,27.68 146.7,33.9 121.67,33.9 118.6,36.97 108.74,36.97 107.89,37.82 103.62,37.82 102.59,38.85 91.52,38.85 89.57,36.89 88,36.89 87.4,37.49 76.02,37.49 74.86,36.33 72.93,36.33 72.33,36.93 69.3,36.93 66.41,39.82 60.35,39.82 59.52,40.65 55.79,40.65 53.31,43.12 51.89,43.12 49.3,45.72 45.33,45.72 44.95,45.34 41.98,45.34 v1(40.51,43.86)
  LAY5 w0.125: v1(14.35,103.25) 13.69,102.59 13.69,101.09 14.47,100.31 14.47,96.54 13.96,96.03 13.96,85.6 14.47,85.09 14.47,83.82 14.09,83.44 14.09,70.82 14.47,70.44 14.47,61.74 11.55,58.82 11.55,42.42 12.7,41.27 19.43,41.27 21.33,39.37 v1(24,39.37)
  BOTTOM w0.1: v1(24,39.37) 24,39.88 26.67,42.54 36.32,42.54 37.64,43.86 v1(40.51,43.86)
DCI_OOB_ENABLE_J: length 2.3
  TOP w0.1: R8H54.2 27.81,40.64 27.94,40.51
DCIN_EN: length 4
  TOP w0.1: EU2A7.3 259.58,264.53 260.09,264.03 R2A69.1
DDI1_AUX_DN: length 113.7
  TOP w0.1: v1(258.7,199.64) 258.46,199.88 258.46,200.08 258.19,200.35 257.47,200.35 250.41,193.29 245.33,193.29 242.55,190.51 241.73,190.51 241.66,190.44 240.02,190.44 239.8,190.23 239.8,190.13 239.54,189.86 J3D1.K38 ; C2A21.1 v1(275.84,268.6)
  BOTTOM w0.1: v1(275.84,268.6) 276.11,268.33 278.68,268.33 283.66,263.35 283.66,255.07 283.98,254.75 283.98,247.1 285.11,245.96 285.11,240.16 285.87,239.39 285.87,236.73 285.31,236.16 285.31,222.71 281.4,218.8 280.9,218.8 280.61,218.51 280.61,217.7 279.24,216.32 278.32,216.32 277.52,215.52 275.74,215.52 264.59,204.37 263.42,204.37 259.63,200.58 258.87,200.58 258.47,200.18 258.47,199.88 v1(258.7,199.64)
DDI1_AUX_DP: length 113.7
  TOP w0.1: v1(257.91,199.64) 258.1,199.64 258.26,199.8 258.26,199.99 258.1,200.15 257.55,200.15 250.49,193.09 245.41,193.09 242.63,190.31 241.81,190.31 241.75,190.24 240.1,190.24 240,190.14 240,190 240.14,189.86 J3D1.K39 ; v1(275.84,267.71) 275.74,267.82 275.53,267.82 C2A24.1
  BOTTOM w0.1: v1(275.84,267.71) 275.84,268.03 275.94,268.13 278.59,268.13 283.46,263.27 283.46,254.99 283.78,254.67 283.78,247.01 284.91,245.88 284.91,240.07 285.67,239.31 285.67,236.81 285.11,236.25 285.11,222.8 281.31,219 280.81,219 280.41,218.59 280.41,217.78 279.15,216.52 278.24,216.52 277.44,215.72 275.66,215.72 264.51,204.57 263.34,204.57 259.55,200.78 258.79,200.78 258.27,200.26 258.27,199.8 258.11,199.64 v1(257.91,199.64)
DDI1_AUX_EN: length 11.4
  TOP w0.1: R2A33.2 278.51,269.62 278.51,268.48 Q2A5.1 277.89,267.97 Q2A8.3 274.86,266.72 274.21,266.06 272.41,266.06 Q2A7.1 271.52,266.95 271.52,267.46 Q2A4.1
DDI1_DDC_EN: length 13.4
  TOP w0.1: Q2A6.1 269.49,267.59 v1(269.74,267.84) 269.36,268.22 Q2A3.1 269.74,268.48 270.25,268.98 271.39,268.98 271.8,269.39 272.56,269.39 273.17,270 275.97,270 276.47,269.49 276.47,268.53 Q2A5.3 276.73,268.46 276.73,269.37 277.36,270 R2A32.2
DDI1_DP_AUX_C_DN: length 2.9
  TOP w0.1: C2A21.2 274.29,268.22 274.19,268.12 273.65,268.12 C2A22.1 272.88,268.9 Q2A4.2
DDI1_DP_AUX_C_DP: length 2.8
  TOP w0.1: C2A24.2 274.29,267.77 274.14,267.92 273.76,267.92 C2A23.1 272.96,267.12 Q2A7.2
DDI1_DP_CTRLCLK_AUX_DP: length 15.5
  TOP w0.1: J2A1.T15 267.97,276.83 267.97,275.72 268.13,275.55 268.13,274.66 267.98,274.51 EU2A5.10 EU2A5.1 268.14,273.16 268.14,272.97 267.46,272.29 R2A19.2 267.81,271.81 267.81,270 267.46,269.65 267.46,268.22 267.66,268.02 268.22,268.02 268.31,267.93 Q2A6.2 268.53,267.37 268.53,267.1 268.75,266.88 269.83,266.88 270.36,267.41 270.61,267.41 270.8,267.22 Q2A7.3
DDI1_DP_CTRLDATA_AUX_DN: length 15.5
  TOP w0.1: Q2A4.3 270.8,267.82 270.58,267.61 270.27,267.61 269.74,267.08 268.83,267.08 268.73,267.18 268.73,267.97 268.47,268.22 267.74,268.22 267.66,268.31 267.66,268.53 Q2A3.3 267.66,269.22 267.66,269.57 268.01,269.92 268.01,271.82 R2A20.2 268.17,272.59 268.17,272.72 268.34,272.89 268.34,273.18 EU2A5.2 EU2A5.9 268.48,274.51 268.33,274.66 268.33,275.63 268.17,275.8 268.17,276.84 J2A1.T17
DDI1_DP_TX0_C_DN: length 1.4
  TOP w0.1: C2A14.2 260.54,270.83 260.54,271.44 R2A12.1
DDI1_DP_TX0_C_DP: length 1.4
  TOP w0.1: R2A11.1 260.34,271.28 260.34,270.63 C2A13.2
DDI1_DP_TX0_L_DN: length 7
  TOP w0.1: J2A1.T3 259.04,277.44 258.94,277.34 258.94,276.19 260.17,274.95 260.4,274.95 260.69,274.66 260.69,274.48 260.86,274.31 EU2A3.9 EU2A3.2 260.7,273.16 260.7,272.85 260.39,272.54 260.39,272.39 R2A12.2
DDI1_DP_TX0_L_DP: length 7.1
  TOP w0.1: R2A11.2 260.16,272.23 260.16,272.59 260.5,272.93 260.5,273.18 EU2A3.1 EU2A3.10 260.36,274.33 260.49,274.46 260.49,274.58 260.31,274.75 260.09,274.75 258.74,276.11 258.74,277.31 258.61,277.44 J2A1.T1
DDI1_DP_TX1_C_DN: length 1.4
  TOP w0.1: R2A13.1 262.37,271.41 262.37,270.75 C2A15.2
DDI1_DP_TX1_C_DP: length 1.4
  TOP w0.1: C2A16.2 262.57,270.7 262.57,271.31 R2A14.1
DDI1_DP_TX1_L_DN: length 9.5
  TOP w0.1: v1(260.85,275.29) 261.15,275.59 261.62,275.59 262,275.2 262,274.55 261.86,274.41 EU2A3.7 EU2A3.4 262,273.18 262,272.89 262.29,272.6 262.29,272.2 R2A13.2
  BOTTOM w0.1: v1(260.85,275.29) 260.85,275.44 261.12,275.7 261.26,275.7 261.51,275.95 261.51,277.77 260.72,278.57 260.72,278.74 260.82,278.84 J2A1.T6
DDI1_DP_TX1_L_DP: length 9.5
  TOP w0.1: v1(260.85,276.09) 261.15,275.79 261.7,275.79 262.2,275.29 262.2,274.55 262.36,274.38 EU2A3.6 EU2A3.5 262.2,273.16 262.2,272.97 262.49,272.68 262.49,272.45 R2A14.2
  BOTTOM w0.1: v1(260.85,276.09) 261.04,275.9 261.18,275.9 261.31,276.03 261.31,277.69 260.52,278.49 260.52,278.68 260.36,278.84 J2A1.T4
DDI1_DP_TX2_C_DN: length 1.4
  TOP w0.1: C2A20.2 266.25,270.7 266.25,271.31 R2A18.1
DDI1_DP_TX2_C_DP: length 1.4
  TOP w0.1: C2A19.2 266.05,270.75 266.05,271.41 R2A17.1
DDI1_DP_TX2_L_DN: length 7.8
  TOP w0.1: J2A1.T9 263.21,277.44 262.89,277.12 262.89,276.98 263.22,276.66 264.01,276.66 265.77,274.89 265.77,274.53 265.92,274.38 EU2A4.6 EU2A4.5 265.76,273.16 265.76,272.97 266.52,272.21 R2A18.2
DDI1_DP_TX2_L_DP: length 7.8
  TOP w0.1: R2A17.2 265.93,272.16 265.93,272.51 265.56,272.89 265.56,273.18 EU2A4.4 EU2A4.7 265.42,274.39 265.57,274.54 265.57,274.81 263.92,276.46 263.13,276.46 262.69,276.9 262.69,277.26 262.52,277.44 J2A1.T7
DDI1_DP_TX3_C_DN: length 1.5
  TOP w0.1: C2A17.2 264.13,270.61 264.13,271.17 R2A15.1
DDI1_DP_TX3_C_DP: length 1.5
  TOP w0.1: C2A18.2 264.65,270.38 264.33,270.7 264.33,271.55 R2A16.1
DDI1_DP_TX3_L_DN: length 9
  TOP w0.1: v1(263.46,275.07) 263.76,275.37 263.9,275.37 264.05,275.22 264.05,274.55 263.92,274.41 EU2A4.10 EU2A4.1 264.08,273.16 264.08,272.92 263.93,272.77 263.93,272.32 R2A15.2
  BOTTOM w0.1: v1(263.46,275.07) 263.79,275.39 263.96,275.39 264.21,275.64 264.21,277.93 264.68,278.4 264.68,278.74 264.78,278.84 J2A1.T12
DDI1_DP_TX3_L_DP: length 9.1
  TOP w0.1: v1(263.46,275.87) 263.76,275.57 263.99,275.57 264.25,275.3 264.25,274.58 264.42,274.41 EU2A4.9 EU2A4.2 264.28,273.18 264.28,272.84 264.13,272.69 264.13,272.34 R2A16.2
  BOTTOM w0.1: J2A1.T10 264.36,278.84 264.48,278.71 264.48,278.49 264.01,278.01 264.01,275.72 263.88,275.59 263.74,275.59 v1(263.46,275.87)
DDI1_DPCON_PIN14_PD: length 5.8
  TOP w0.1: R2A7.1 266.7,275.72 265.37,277.04 265.37,277.82 266.39,278.84 J2A1.T14
DDI1_OB_AUX_EN: length 27
  TOP w0.1: v1(276.98,271.52) 277.24,271.52 277.74,272.03 R2A8.2 R2A10.1 ; v1(269.62,272.11) 269.62,272.79 269.48,272.93 EU2A5.4 EU2A5.7 269.48,277.76 269.11,278.13 266.75,278.13 J2A1.T13 ; Q2A8.1 279.14,266.32 279.4,266.57 279.4,268.81 v1(278.99,269.21)
  BOTTOM w0.1: v1(269.62,272.11) 270.45,271.27 276.73,271.27 v1(276.98,271.52) 278.99,269.52 v1(278.99,269.21)
DDI1_OB_DP_HPD: length 22.3
  TOP w0.1: R2A48.1 v1(278.89,265.84) ; J2A1.T18 269.87,278.13 270.51,278.13 270.63,278 270.63,276.99 269.87,276.22 269.87,275.33 269.98,275.22 EU2A5.6 EU2A5.5 269.98,272.99 270.1,272.87 270.1,271.5 v1(269.24,270.64)
  BOTTOM w0.1: v1(269.24,270.64) 269.74,270.13 272.28,270.13 275.71,266.7 278.02,266.7 v1(278.89,265.84)
DDI1_OB_DP_HPD_R: length 4.4
  TOP w0.1: R2A53.2 R2A48.2 279.78,265.17 R2A49.1 279.9,265.37 Q1A1.3
DDI1_TX0_DN: length 113.8
  TOP w0.1: J3D1.F38 239.96,193.52 240.06,193.62 240.06,193.85 240.26,194.06 241.52,194.06 244.22,196.75 244.22,199.39 246.83,202 254.08,202 254.4,201.68 254.4,201.4 v1(254.63,201.17) ; C2A14.1 260.72,269.24 260.72,268.9 v1(260.95,268.67)
  BOTTOM w0.1: v1(254.63,201.17) 254.32,201.47 254.32,201.75 258.08,205.51 260.38,205.51 261.99,207.11 263.42,207.11 275.26,218.95 276.22,218.95 278.33,221.05 278.33,222.7 279.01,223.39 279.01,228.47 280.18,229.64 280.18,234.54 279.65,235.08 279.65,247.52 279.21,247.96 279.21,248.87 277.06,251.03 277.06,253.7 274.06,256.69 274.06,259.46 270.69,262.83 270.31,262.83 267.13,266.01 266.27,266.01 265.3,266.98 262.82,266.98 262.26,267.53 261.22,267.53 260.8,267.95 260.8,268.53 v1(260.95,268.67)
DDI1_TX0_DP: length 113.8
  TOP w0.1: v1(253.93,201.17) 254.2,201.43 254.2,201.6 254,201.8 246.91,201.8 244.42,199.31 244.42,196.67 241.6,193.86 240.35,193.86 240.26,193.77 240.26,193.62 240.36,193.52 J3D1.F39 ; C2A13.1 260.09,269.64 260.19,269.74 260.43,269.74 260.52,269.64 260.52,268.86 260.34,268.67 v1(260.12,268.67)
  BOTTOM w0.1: v1(253.93,201.17) 254.12,201.36 254.12,201.83 258,205.71 260.3,205.71 261.9,207.31 263.34,207.31 275.18,219.15 276.14,219.15 278.13,221.13 278.13,222.79 278.81,223.47 278.81,228.55 279.98,229.72 279.98,234.46 279.45,234.99 279.45,247.44 279.01,247.87 279.01,248.79 276.86,250.95 276.86,253.62 273.86,256.61 273.86,259.38 270.6,262.63 270.22,262.63 267.05,265.81 266.19,265.81 265.22,266.78 262.73,266.78 262.18,267.33 261.14,267.33 260.6,267.87 260.6,268.19 v1(260.12,268.67)
DDI1_TX1_DN: length 112.4
  TOP w0.1: v1(262.03,268.67) 262.25,268.67 262.43,268.85 262.43,269.39 262.33,269.49 C2A15.1 ; J3D1.G39 240.62,192.79 240.62,192.94 240.82,193.14 241.73,193.14 241.81,193.06 242.43,193.06 244.77,195.4 249.62,195.4 256.21,201.98 256.21,203.16 256.55,203.5 256.74,203.5 v1(257.04,203.8)
  BOTTOM w0.1: v1(257.04,203.8) 257.34,203.5 257.48,203.5 259,205.02 260.58,205.02 262.19,206.62 263.62,206.62 275.43,218.44 277.15,218.44 278.89,220.17 278.89,222.15 279.5,222.76 279.5,228.07 280.67,229.24 280.67,234.94 280.16,235.46 280.16,247.75 279.78,248.13 279.78,255.09 275.13,259.74 275.13,260.52 272.64,263.02 271.88,263.02 268.19,266.7 266.44,266.7 265.68,267.46 263.09,267.46 262.39,268.16 262.39,268.4 262.11,268.67 v1(262.03,268.67)
DDI1_TX1_DP: length 112.4
  TOP w0.1: J3D1.G40 241.23,192.48 240.95,192.48 240.82,192.61 240.82,192.86 240.91,192.94 241.65,192.94 241.73,192.86 242.51,192.86 244.85,195.2 249.71,195.2 256.41,201.9 256.41,203.07 256.64,203.3 256.74,203.3 v1(257.04,203) ; v1(262.85,268.67) 262.63,268.9 262.63,269.23 C2A16.1
  BOTTOM w0.1: v1(257.04,203) 257.34,203.3 257.57,203.3 259.09,204.82 260.67,204.82 262.27,206.42 263.7,206.42 275.52,218.24 277.23,218.24 279.09,220.09 279.09,222.07 279.7,222.68 279.7,227.98 280.87,229.15 280.87,235.03 280.36,235.54 280.36,247.83 279.98,248.21 279.98,255.18 275.33,259.82 275.33,260.6 272.72,263.22 271.96,263.22 268.27,266.9 266.52,266.9 265.76,267.66 263.17,267.66 262.59,268.24 262.59,268.41 v1(262.85,268.67)
DDI1_TX2_DN: length 111.2
  TOP w0.1: C2A20.1 266.28,269.21 266.28,268.92 v1(266.54,268.67) ; v1(258.95,202.9) 258.65,203.2 258.42,203.2 257.81,202.58 257.81,202.33 249.96,194.49 245.03,194.49 242.75,192.2 241.81,192.2 241.63,192.03 239.99,192.03 239.91,191.94 239.91,191.79 240.01,191.69 J3D1.H39
  BOTTOM w0.1: v1(266.54,268.67) 266.21,268.35 266.21,268.18 266.73,267.66 268.48,267.66 272.16,263.98 273,263.98 276.04,260.94 276.04,260.07 280.67,255.45 280.67,248.66 281.63,247.7 281.63,242.65 281.55,242.56 281.55,227.42 280.87,226.74 280.87,221.94 279.85,220.92 279.85,219.88 276.94,216.97 275.21,216.97 263.98,205.74 262.55,205.74 260.01,203.2 259.25,203.2 v1(258.95,202.9)
DDI1_TX2_DP: length 111.2
  TOP w0.1: v1(258.95,203.7) 258.65,203.4 258.34,203.4 257.61,202.66 257.61,202.42 249.88,194.69 244.95,194.69 242.67,192.4 241.73,192.4 241.55,192.23 239.91,192.23 239.71,192.02 239.71,191.88 J3D1.H38 ; v1(265.71,268.67) 265.96,268.67 266.08,268.8 266.08,269.37 265.96,269.49 C2A19.1
  BOTTOM w0.1: v1(258.95,203.7) 259.25,203.4 259.93,203.4 262.47,205.94 263.9,205.94 275.12,217.17 276.86,217.17 279.65,219.96 279.65,221.01 280.67,222.02 280.67,226.82 281.35,227.51 281.35,242.65 281.43,242.73 281.43,247.62 280.47,248.58 280.47,255.36 275.84,259.99 275.84,260.86 272.92,263.78 272.08,263.78 268.4,267.46 266.65,267.46 266.01,268.1 266.01,268.37 v1(265.71,268.67)
DDI1_TX3_DN: length 115.1
  TOP w0.1: v1(263.93,268.67) 264.26,269 264.26,269.14 C2A17.1 ; J3D1.J40 241.35,190.78 241.35,191.01 241.45,191.11 241.67,191.11 241.72,191.06 242.49,191.06 245.23,193.8 250.24,193.8 258.02,201.59 258.63,201.59 v1(258.93,201.29)
  BOTTOM w0.1: v1(263.93,268.67) 264.25,268.98 264.25,269.16 264.58,269.49 269.04,269.49 278.33,260.2 278.33,259.16 283.28,254.2 283.28,223.31 280.67,220.7 280.67,219.73 277.21,216.28 275.51,216.28 264.28,205.05 263.14,205.05 259.67,201.59 259.23,201.59 v1(258.93,201.29)
DDI1_TX3_DP: length 115.1
  TOP w0.1: J3D1.J39 240.84,190.78 241.37,191.31 241.75,191.31 241.81,191.26 242.41,191.26 245.15,194 250.16,194 257.94,201.79 258.63,201.79 v1(258.93,202.08) ; v1(264.76,268.67) 264.66,268.67 264.46,268.87 264.46,269.16 C2A18.1
  BOTTOM w0.1: v1(264.76,268.67) 264.6,268.67 264.45,268.82 264.45,269.08 264.66,269.29 268.96,269.29 278.13,260.12 278.13,259.08 283.08,254.12 283.08,223.4 280.47,220.78 280.47,219.81 277.13,216.48 275.43,216.48 264.2,205.25 263.06,205.25 259.59,201.79 259.23,201.79 v1(258.93,202.08)
DDI2_HDMI_ALS_CTRLCLK: length 1.9
  TOP w0.1: EU2A7.34 252.08,264.53 R2A55.2
DDI2_HDMI_ALS_CTRLDATA: length 1.7
  TOP w0.1: EU2A7.33 251.72,264.93 R2A51.2
DDI2_HDMI_CLK_DN: length 4.9
  TOP w0.1: EU2A7.48 258.3,262.53 258.2,262.43 258.2,260.33 258.69,259.84 258.99,259.84 259.23,259.6 259.23,259.3 C2B5.2
DDI2_HDMI_CLK_DP: length 4.9
  TOP w0.1: EU2A7.47 257.9,262.53 258,262.43 258,260.25 258.61,259.64 258.91,259.64 259.03,259.52 259.03,259.29 C2B4.2
DDI2_HDMI_DATA0_DN: length 1.9
  TOP w0.1: C2A32.2 256.98,261.68 256.98,262.4 257.1,262.53 EU2A7.45
DDI2_HDMI_DATA0_DP: length 1.9
  TOP w0.1: C2A31.2 256.78,261.74 256.78,262.45 256.7,262.53 EU2A7.44
DDI2_HDMI_DATA1_DN: length 3.7
  TOP w0.1: EU2A7.42 255.9,262.53 255.81,262.43 255.81,259.94 C2B3.2
DDI2_HDMI_DATA1_DP: length 3.7
  TOP w0.1: C2B2.2 255.61,259.93 255.61,262.43 255.5,262.53 EU2A7.41
DDI2_HDMI_DATA2_DN: length 2.6
  TOP w0.1: EU2A7.39 254.7,262.71 254.61,262.61 254.61,262.23 254.3,261.92 253.77,261.92 253.66,261.81 253.66,261.7 C2A30.2
DDI2_HDMI_DATA2_DP: length 2.6
  TOP w0.1: C2A29.2 253.46,261.72 253.46,261.9 253.69,262.12 254.22,262.12 254.41,262.31 254.41,262.61 254.3,262.71 EU2A7.38
DDI2_HDMI_HPD: length 1.7
  TOP w0.1: R2A70.2 255.01,262.07 255.1,262.16 EU2A7.40
DDI2_TX0_DN: length 111.9
  TOP w0.1: C2A30.1 253.65,260.13 253.65,256.63 v1(254,256.28) ; J3D1.F36 v1(237.24,193.06)
  BOTTOM w0.1: v1(254,256.28) 253.65,256.63 253.65,256.79 253.78,256.92 254.73,256.92 255.45,256.2 267.54,256.2 270.38,253.36 273.02,253.36 273.93,252.45 273.93,249.81 275.1,248.64 275.1,241.4 275.57,240.94 275.57,234.32 275.13,233.89 275.13,222.98 263.89,211.73 261.74,211.73 258.74,208.73 256.96,208.73 255.53,207.3 247.16,207.3 236.9,197.04 236.9,195.53 236.52,195.15 236.52,193.81 236.76,193.57 237.07,193.57 237.24,193.4 v1(237.24,193.06)
DDI2_TX0_DP: length 111.9
  TOP w0.1: C2A29.1 253.45,260.13 253.45,256.63 v1(253.11,256.28) ; J3D1.F35 v1(237.24,193.98)
  BOTTOM w0.1: v1(237.24,193.98) 237.03,193.77 236.84,193.77 236.72,193.9 236.72,195.07 237.1,195.45 237.1,196.96 247.24,207.1 255.61,207.1 257.04,208.53 258.82,208.53 261.82,211.53 263.97,211.53 275.33,222.89 275.33,233.81 275.77,234.24 275.77,241.02 275.3,241.48 275.3,248.72 274.13,249.89 274.13,252.53 273.1,253.56 270.46,253.56 267.63,256.4 255.54,256.4 254.81,257.12 253.69,257.12 253.45,256.88 253.45,256.63 v1(253.11,256.28)
DDI2_TX1_DN: length 107.3
  TOP w0.1: v1(256.11,257.58) 255.83,257.85 255.83,258.38 C2B3.1 ; J3D1.E37 v1(238.15,193.98)
  BOTTOM w0.1: v1(238.15,193.98) 237.66,194.47 237.66,196.21 238.88,197.43 239.56,197.43 240.58,198.45 240.58,199.77 247.44,206.62 255.87,206.62 257.27,208.02 259,208.02 261.99,211.02 264.13,211.02 275.84,222.72 275.84,233.58 276.91,234.65 276.91,236.77 276.26,237.42 276.26,248.5 274.62,250.13 274.62,252.8 273.3,254.13 270.63,254.13 267.87,256.89 257.68,256.89 256.45,258.12 256,258.12 255.9,258.02 255.9,257.79 v1(256.11,257.58)
DDI2_TX1_DP: length 107.3
  TOP w0.1: C2B2.1 255.63,258.33 255.63,257.9 v1(255.31,257.58) ; J3D1.E36 v1(238.15,194.89)
  BOTTOM w0.1: v1(255.31,257.58) 255.5,257.58 255.7,257.78 255.7,258.1 255.92,258.32 256.54,258.32 257.77,257.09 267.95,257.09 270.71,254.33 273.38,254.33 274.82,252.88 274.82,250.22 276.46,248.58 276.46,237.5 277.11,236.85 277.11,234.57 276.04,233.5 276.04,222.64 264.22,210.82 262.07,210.82 259.08,207.82 257.35,207.82 255.95,206.42 247.52,206.42 240.78,199.68 240.78,198.37 239.64,197.23 238.96,197.23 237.86,196.13 237.86,194.99 237.96,194.89 v1(238.15,194.89)
DDI2_TX2_DN: length 107.7
  TOP w0.1: C2A32.1 257.3,260.63 257.2,260.73 256.94,260.73 256.84,260.63 256.84,260.17 257.3,259.72 257.3,259.33 257.57,259.06 v1(257.67,259.06) ; J3D1.D38 v1(239.07,195.81)
  BOTTOM w0.1: v1(239.07,195.81) 239.42,195.45 239.62,195.45 242.11,197.95 242.11,200.33 247.73,205.95 256.24,205.95 257.5,207.21 259.88,207.21 262.42,209.75 263.85,209.75 274.69,220.59 275.55,220.59 276.6,221.64 276.6,230.79 278.08,232.26 278.08,239.9 277.59,240.39 277.59,248.18 275.33,250.44 275.33,253.08 273.52,254.89 271.01,254.89 268.34,257.56 259.96,257.56 257.98,259.54 257.42,259.54 257.3,259.41 257.3,259.33 257.57,259.06 v1(257.67,259.06)
DDI2_TX2_DP: length 107.8
  TOP w0.1: C2A31.1 256.64,260.24 256.64,260.09 257.1,259.63 257.1,259.29 v1(256.87,259.06) ; J3D1.D37 v1(239.07,194.89)
  BOTTOM w0.1: v1(256.87,259.06) 257.1,259.29 257.1,259.49 257.34,259.74 258.06,259.74 260.04,257.76 268.42,257.76 271.1,255.09 273.61,255.09 275.53,253.16 275.53,250.53 277.79,248.27 277.79,240.47 278.28,239.98 278.28,232.18 276.8,230.7 276.8,221.56 275.63,220.39 274.77,220.39 263.93,209.55 262.5,209.55 259.96,207.01 257.58,207.01 256.32,205.75 247.81,205.75 242.31,200.25 242.31,197.86 239.7,195.25 239.43,195.25 v1(239.07,194.89)
DDI2_TX3_DN: length 107.9
  TOP w0.1: C2B5.1 259.58,258.12 259.48,258.22 259.23,258.22 259.13,258.12 259.13,257.67 259.38,257.43 260.97,257.43 262.44,258.9 263.29,258.9 263.39,259 v1(263.39,259.2) ; J3D1.G37 v1(239.07,193.06)
  BOTTOM w0.1: v1(239.07,193.06) 239.09,193.06 243.04,197.01 243.04,200.02 248.1,205.07 256.63,205.07 257.81,206.25 260.17,206.25 262.2,208.28 263.63,208.28 275.06,219.71 275.97,219.71 277.56,221.31 277.56,230.45 278.96,231.85 278.96,247.19 278.51,247.65 278.51,248.57 276.29,250.78 276.29,253.42 273.86,255.85 271.35,255.85 268.3,258.9 263.69,258.9 v1(263.39,259.2)
DDI2_TX3_DP: length 107.9
  TOP w0.1: C2B4.1 258.93,257.83 258.93,257.59 259.29,257.23 261.06,257.23 262.53,258.7 263.09,258.7 v1(263.39,258.4) ; J3D1.G36 v1(238.15,193.06)
  BOTTOM w0.1: v1(263.39,258.4) 263.69,258.7 268.22,258.7 271.27,255.65 273.78,255.65 276.09,253.33 276.09,250.7 278.31,248.48 278.31,247.57 278.76,247.11 278.76,231.93 277.36,230.53 277.36,221.39 275.88,219.91 274.97,219.91 263.54,208.48 262.12,208.48 260.08,206.45 257.72,206.45 256.55,205.27 248.02,205.27 242.84,200.1 242.84,197.1 239.27,193.52 238.61,193.52 v1(238.15,193.06)
DDI3_AUX_DN: length 130.7
  TOP w0.1: v1(235.34,256.18) 235.58,256.42 235.58,257.01 233.85,258.75 233.47,258.75 230.8,261.41 230.8,262.18 231.18,262.56 232.71,262.56 C3A19.1 ; v1(259.33,210.32) 259.03,210.61 250.36,210.61 238.23,198.48 238.23,196.65 238.03,196.45 237.88,196.45 J3D1.C36
  BOTTOM w0.1: v1(235.34,256.18) 235.58,256.42 235.58,257.08 236.89,258.39 244.68,258.39 247.35,255.72 267.29,255.72 274.62,248.39 274.62,241.03 275.06,240.59 275.06,236.58 274.62,236.14 274.62,223.15 263.68,212.22 261.52,212.22 259.92,210.62 259.63,210.62 v1(259.33,210.32)
DDI3_AUX_DP: length 130.7
  TOP w0.1: J3D1.B36 237.7,196.75 237.8,196.65 237.95,196.65 238.03,196.73 238.03,198.57 250.28,210.81 259.03,210.81 v1(259.33,211.12) ; v1(236.17,256.18) 235.93,256.18 235.78,256.33 235.78,257.1 233.93,258.95 233.55,258.95 231,261.5 231,262.09 231.27,262.36 233.26,262.36 233.38,262.23 233.38,262.09 C3A22.1
  BOTTOM w0.1: v1(259.33,211.12) 259.63,210.82 259.84,210.82 261.43,212.42 263.6,212.42 274.42,223.23 274.42,236.22 274.86,236.66 274.86,240.51 274.42,240.94 274.42,248.31 267.2,255.52 247.26,255.52 244.6,258.19 236.98,258.19 235.78,256.99 235.78,256.34 235.94,256.18 v1(236.17,256.18)
DDI3_AUX_PCON_C_DN: length 8.8
  TOP w0.1: C3A20.2 233.8,262.76 233.8,262.53 233.93,262.4 234.3,262.4 234.44,262.54 236,262.54 R3A45.2 236.95,262.53 237.11,262.53 237.21,262.63 237.21,263.8 236.98,264.03 236.98,265.78 237.33,266.14 237.53,266.14 237.62,266.23 237.62,266.37 U3A5.C8
DDI3_AUX_PCON_C_DP: length 8.8
  TOP w0.1: U3A5.C7 238.29,266.39 237.84,265.94 237.42,265.94 237.18,265.7 237.18,264.11 237.41,263.89 237.41,262.55 237.19,262.33 236.93,262.33 R3A46.1 236,262.34 234.53,262.34 C3A21.2
DDI3_TR_AUX_C_DN: length 98.2
  TOP w0.089: U5A2.N2 161.54,266.85 160.98,266.85 160.91,266.78
  TOP w0.1: 160.91,266.78 160.73,266.78 160.52,266.57 159.87,266.57 159.54,266.9 157.81,266.9 157.3,267.41 155.41,267.41 155.19,267.19 155.19,266.96 v1(154.88,266.65) ; C3A19.2 v1(231.52,263.02)
  LAY6 w0.115: v1(231.52,263.02) 231.26,262.76 229.36,262.76 227.1,265.02 203.98,265.02 201.29,267.71 198.88,267.71 198.5,268.1 197.73,268.86 192.15,268.86 191.64,268.35 186.76,268.35 186.38,268.73 183.33,268.73 180.46,271.6 180.46,273.81 179.32,274.95 176.83,274.95 174.14,272.26 162.17,272.26 161.76,272.67 158.62,272.67 158.01,272.06 158.01,268.5 156.94,267.44 155.31,267.44 155.06,267.19 155.06,266.83 v1(154.88,266.65)
DDI3_TR_AUX_C_DP: length 98.2
  TOP w0.089: 160.99,266.51 161.11,266.39 161.36,266.39 161.44,266.47 161.44,266.55 161.36,266.62 U5A2.N1
  TOP w0.1: C3A22.2 v1(231.52,261.87) ; 160.99,266.51 160.93,266.57 160.81,266.57 160.61,266.37 159.79,266.37 159.46,266.7 157.73,266.7 157.22,267.21 155.49,267.21 155.39,267.11 155.39,266.96 v1(155.7,266.65)
  LAY6 w0.115: v1(231.52,261.87) 231.64,262 231.64,262.36 231.47,262.53 229.26,262.53 227,264.79 203.89,264.79 201.19,267.48 198.78,267.48 197.64,268.63 192.24,268.63 191.73,268.12 186.66,268.12 186.28,268.5 183.23,268.5 180.23,271.5 180.23,273.72 179.22,274.72 176.93,274.72 174.24,272.03 162.07,272.03 161.67,272.44 158.71,272.44 158.24,271.96 158.24,268.41 157.04,267.21 155.41,267.21 155.29,267.09 155.29,266.9 155.54,266.65 v1(155.7,266.65)
DDI3_TR_TX0_C_DN: length 3.6
  TOP w0.089: 164.3,261.31 164.3,262.25 U5A2.AB7
  TOP w0.1: C5B2.1 163.95,259.46 163.57,259.84 163.57,260.01 164.3,260.74 164.3,261.31
DDI3_TR_TX0_C_DP: length 3.6
  TOP w0.089: 164.1,261.31 164.1,261.33 164.1,261.33 164.1,261.39 164.11,261.4 164.11,261.55 163.84,261.82 163.84,262.11 163.91,262.18 164.01,262.18 164.07,262.12 U5A2.AC7
  TOP w0.1: 164.1,261.31 164.1,260.82 163.37,260.09 163.37,259.76 163.06,259.46 C5B1.1
DDI3_TR_TX0_R_DN: length 84.1
  TOP w0.1: R3B2.2 v1(238.37,257.55) ; v1(164.84,256.28) 164.65,256.48 164.65,256.89 163.61,257.93 163.61,258.24 C5B2.2
  LAY6 w0.115: v1(164.84,256.28) 164.61,256.06 164.61,255.34 167.07,252.88 170.43,252.88 171.05,253.5 174.73,253.5 176.15,254.91 177.88,254.91 178.99,256.03 182.04,256.03 182.53,256.51 190.6,256.51 192.58,258.49 198.22,258.49 199.82,260.09 224.22,260.09 226.51,257.81 231.95,257.81 232.5,258.35 237.46,258.35 237.88,257.93 237.88,257.72 238.05,257.55 v1(238.37,257.55)
DDI3_TR_TX0_R_DP: length 84.1
  TOP w0.1: C5B1.2 163.41,258.24 163.41,257.84 164.45,256.8 164.45,256.58 v1(164.16,256.28) ; R3B1.2 v1(237.23,257.55)
  LAY6 w0.115: v1(237.23,257.55) 237.54,257.55 237.65,257.67 237.65,257.83 237.37,258.12 232.59,258.12 232.05,257.58 226.41,257.58 224.13,259.86 199.92,259.86 198.32,258.26 192.67,258.26 190.69,256.28 182.62,256.28 182.14,255.8 179.09,255.8 177.97,254.68 176.24,254.68 174.83,253.27 171.15,253.27 170.53,252.65 166.98,252.65 164.38,255.25 164.38,256.06 v1(164.16,256.28)
DDI3_TR_TX1_C_DN: length 3.5
  TOP w0.089: U5A2.AC9 164.99,262.12 165.04,262.18 165.14,262.18 165.22,262.11 165.22,261.82 164.94,261.55 164.94,261.25
  TOP w0.1: C5B4.1 165.42,259.77 165.42,260.28 164.94,260.75 164.94,261.25
DDI3_TR_TX1_C_DP: length 3.5
  TOP w0.089: 164.74,261.25 164.74,261.27 164.75,261.28 164.75,261.33 164.76,261.34 164.76,262.25 U5A2.AB9
  TOP w0.1: 164.74,261.25 164.74,260.67 165.22,260.2 165.22,259.84 164.84,259.46 C5B3.1
DDI3_TR_TX1_R_DN: length 84.2
  TOP w0.1: v1(166.37,256.28) 166.05,256.6 166.05,257.25 165.39,257.92 165.39,258.24 C5B4.2 ; R3B4.2 v1(240.41,257.55)
  LAY6 w0.115: v1(166.37,256.28) 166.1,256.02 166.1,255.53 168.02,253.62 170.13,253.62 170.73,254.22 174.41,254.22 176.46,256.26 178.03,256.26 178.81,257.05 179.76,257.05 180.01,257.3 190.11,257.3 193.21,260.4 198.73,260.4 199.16,260.83 224.75,260.83 226.38,259.21 239.26,259.21 239.99,258.48 239.99,257.97 v1(240.41,257.55)
DDI3_TR_TX1_R_DP: length 84.2
  TOP w0.1: R3B3.2 v1(239.26,257.55) ; C5B3.2 165.19,258.24 165.19,257.83 165.85,257.17 165.85,256.53 v1(165.6,256.28)
  LAY6 w0.115: v1(239.26,257.55) 239.76,258.05 239.76,258.39 239.17,258.98 226.28,258.98 224.66,260.6 199.26,260.6 198.82,260.17 193.31,260.17 190.21,257.07 180.11,257.07 179.85,256.82 178.91,256.82 178.12,256.03 176.55,256.03 174.51,253.99 170.83,253.99 170.23,253.39 167.92,253.39 165.87,255.44 165.87,256.02 v1(165.6,256.28)
DDI3_TR_TX2_C_DN: length 3.7
  TOP w0.089: U5A2.AB11 166.14,262.25 166.14,261.09 166.29,260.93
  TOP w0.1: 166.29,260.93 167.14,260.09 167.14,259.83 167.51,259.46 C5B6.1
DDI3_TR_TX2_C_DP: length 3.7
  TOP w0.089: 166.1,260.84 166.1,260.86 165.95,261.01 165.95,261.55 165.68,261.82 165.68,262.11 165.75,262.18 165.85,262.18 165.91,262.12 U5A2.AC11
  TOP w0.1: C5B5.1 166.62,259.46 166.94,259.78 166.94,260 166.1,260.84
DDI3_TR_TX2_R_DN: length 85.4
  TOP w0.1: R3B6.2 v1(242.44,257.55) ; C5B6.2 167.16,258.24 167.16,257.78 167.51,257.43 167.51,256.58 v1(167.81,256.28)
  LAY6 w0.115: v1(242.44,257.55) 242.03,257.96 242.03,258.98 241.07,259.94 226.91,259.94 225.26,261.59 216.63,261.59 216.02,262.2 193.42,262.2 190.02,258.8 185.07,258.8 184.68,258.42 179.04,258.42 177.67,257.05 176.2,257.05 174.86,255.71 171.18,255.71 169.83,254.36 168.8,254.36 167.57,255.59 167.57,256.05 v1(167.81,256.28)
DDI3_TR_TX2_R_DP: length 85.4
  TOP w0.1: C5B5.2 166.96,258.24 166.96,257.69 167.31,257.34 167.31,256.49 v1(167.11,256.28) ; R3B5.2 v1(241.3,257.55)
  LAY6 w0.115: v1(167.11,256.28) 167.34,256.05 167.34,255.49 168.71,254.13 169.92,254.13 171.28,255.48 174.96,255.48 176.3,256.82 177.76,256.82 179.14,258.19 184.78,258.19 185.16,258.57 190.11,258.57 193.52,261.97 215.92,261.97 216.53,261.36 225.17,261.36 226.82,259.71 240.97,259.71 241.8,258.88 241.8,258.06 v1(241.3,257.55)
DDI3_TR_TX3_C_DN: length 4.7
  TOP w0.089: U5A2.AC13 166.83,262.12 166.88,262.18 166.98,262.18 167.06,262.11 167.06,261.82 166.78,261.55 166.78,261.47 166.87,261.38 167.32,261.38
  TOP w0.1: 167.32,261.38 167.75,261.38 168.98,260.15 168.98,259.76 C5B8.1
DDI3_TR_TX3_C_DP: length 4.7
  TOP w0.089: U5A2.AB13 166.6,262.25 166.6,261.39 166.79,261.19 167.23,261.19 167.24,261.18 167.3,261.18 167.3,261.18 167.32,261.18
  TOP w0.1: C5B7.1 168.4,259.46 168.78,259.84 168.78,260.06 167.66,261.18 167.32,261.18
DDI3_TR_TX3_R_DN: length 85
  TOP w0.1: v1(169.24,256.28) 168.94,256.59 168.94,258.24 C5B8.2 ; R2B1.2 v1(244.47,257.55)
  LAY6 w0.115: v1(169.24,256.28) 169.01,256.05 169.01,255.89 169.12,255.77 170.06,255.77 170.72,256.43 173.88,256.43 175.38,257.94 177.41,257.94 178.79,259.31 183.67,259.31 184.05,259.69 189.58,259.69 192.83,262.94 216.68,262.94 217.13,262.48 225.52,262.48 227.29,260.71 242.15,260.71 244.07,258.79 244.07,257.96 v1(244.47,257.55)
DDI3_TR_TX3_R_DP: length 85
  TOP w0.1: R3B7.2 v1(243.33,257.55) ; v1(168.54,256.28) 168.75,256.49 168.74,256.5 168.74,258.24 C5B7.2
  LAY6 w0.115: v1(168.54,256.28) 168.78,256.05 168.78,255.79 169.03,255.54 170.16,255.54 170.82,256.2 173.97,256.2 175.48,257.71 177.51,257.71 178.88,259.08 183.76,259.08 184.15,259.46 189.68,259.46 192.93,262.71 216.58,262.71 217.04,262.25 225.42,262.25 227.2,260.48 242.06,260.48 243.84,258.7 243.84,258.06 v1(243.33,257.55)
DDI3_TX0_C_DN: length 5.1
  TOP w0.1: U3A5.A7 238.1,264.48 238.1,261.21 237.92,261.03 237.92,260.55 C3B2.2
DDI3_TX0_C_DP: length 5.1
  TOP w0.1: U3A5.A8 237.9,264.5 237.9,261.3 237.72,261.12 237.72,260.58 C3B1.2
DDI3_TX0_DN: length 109.3
  TOP w0.1: R3B2.1 237.89,258.72 237.89,256.49 v1(238.2,256.18) ; J3D1.B37 239.14,197.71 239.14,198.38 250.11,209.35 251.16,209.35 v1(251.46,209.05)
  BOTTOM w0.1: v1(251.46,209.05) 251.83,209.42 252.25,209.42 257.78,214.96 262.47,214.96 271.4,223.89 271.4,229.87 271.8,230.27 271.8,231.6 271.4,232 271.4,246.37 268.93,248.85 268.93,250.02 265.97,252.98 240.64,252.98 237.89,255.73 237.89,255.87 v1(238.2,256.18)
DDI3_TX0_DP: length 109.3
  TOP w0.1: v1(251.46,209.85) 251.16,209.55 250.03,209.55 238.94,198.46 238.94,197.79 238.83,197.68 238.6,197.68 238.5,197.78 238.5,197.98 J3D1.A37 ; R3B1.1 237.26,259.21 237.69,258.77 237.69,256.5 v1(237.38,256.18)
  BOTTOM w0.1: v1(251.46,209.85) 251.68,209.62 252.16,209.62 257.7,215.16 262.39,215.16 271.2,223.97 271.2,229.96 271.6,230.36 271.6,231.51 271.2,231.91 271.2,246.29 268.73,248.76 268.73,249.93 265.88,252.78 240.56,252.78 237.69,255.65 237.69,255.87 v1(237.38,256.18)
DDI3_TX1_C_DN: length 5.1
  TOP w0.1: U3A5.A5 239.71,264.49 239.71,261.94 239.95,261.7 239.95,260.55 C3B4.2
DDI3_TX1_C_DP: length 5.1
  TOP w0.1: C3B3.2 239.75,260.58 239.75,261.61 239.51,261.85 239.51,264.49 239.21,264.79
DDI3_TX1_DN: length 110.5
  TOP w0.1: v1(254.12,209.29) 253.82,208.99 253.64,208.99 248.94,204.29 245.78,204.29 240.79,199.29 240.79,198.63 239.83,197.67 239.83,197.24 239.72,197.13 239.58,197.13 J3D1.B38 ; v1(240.24,256.18) 240.02,256.18 239.92,256.28 239.92,259.27 240.05,259.39 240.22,259.39 C3B4.1
  BOTTOM w0.1: v1(254.12,209.29) 253.82,208.99 253.71,208.99 253.61,209.08 253.61,209.45 258.44,214.28 262.75,214.28 272.56,224.08 272.56,237.62 272.1,238.08 272.1,247.86 266.3,253.66 242.03,253.66 239.85,255.84 239.85,256.06 239.97,256.18 v1(240.24,256.18)
DDI3_TX1_DP: length 110.5
  TOP w0.1: v1(254.12,208.49) 253.82,208.79 253.72,208.79 249.02,204.09 245.87,204.09 240.99,199.21 240.99,198.54 240.03,197.59 240.03,197.16 239.53,196.65 J3D1.C38 ; v1(239.41,256.18) 239.72,256.5 239.72,258.75 C3B3.1
  BOTTOM w0.1: v1(239.41,256.18) 239.65,255.94 239.65,255.76 241.95,253.46 266.21,253.46 271.9,247.78 271.9,238 272.36,237.54 272.36,224.16 262.67,214.47 258.36,214.47 253.41,209.53 253.41,209 253.62,208.79 253.82,208.79 v1(254.12,208.49)
DDI3_TX2_C_DN: length 5.3
  TOP w0.1: C3B6.2 241.98,260.55 241.98,262.23 241.29,262.92 241.29,264.47 U3A5.A3
DDI3_TX2_C_DP: length 5.3
  TOP w0.1: 240.81,264.79 241.09,264.5 241.09,262.84 241.78,262.15 241.78,260.58 C3B5.2
DDI3_TX2_DN: length 110.3
  TOP w0.1: R3B6.1 241.96,258.72 241.96,256.49 v1(242.27,256.18) ; v1(256.03,209.34) 255.73,209.04 255.52,209.04 249.93,203.45 245.97,203.45 241.78,199.27 241.78,195.91 241.6,195.73 241.45,195.73 241.35,195.83 241.35,196.26 J3D1.C40
  BOTTOM w0.1: v1(242.27,256.18) 241.95,255.87 241.95,255.73 243.33,254.35 266.63,254.35 273.24,247.73 273.24,240.36 272.92,240.03 272.92,238.5 273.25,238.18 273.25,223.72 263.12,213.59 259.56,213.59 255.47,209.5 255.47,209.14 255.57,209.04 255.73,209.04 v1(256.03,209.34)
DDI3_TX2_DP: length 110.3
  TOP w0.1: J3D1.D40 241.54,195.53 241.69,195.53 241.98,195.83 241.98,199.19 246.05,203.25 250.01,203.25 255.6,208.84 255.73,208.84 v1(256.03,208.54) ; C3B5.1 241.76,258.75 241.76,256.36 241.57,256.18 v1(241.44,256.18)
  BOTTOM w0.1: v1(256.03,208.54) 255.73,208.84 255.48,208.84 255.27,209.06 255.27,209.58 259.48,213.79 263.03,213.79 273.05,223.8 273.05,238.09 272.72,238.42 272.72,240.11 273.04,240.44 273.04,247.65 266.54,254.15 243.25,254.15 241.75,255.65 241.75,255.87 v1(241.44,256.18)
DDI3_TX3_C_DN: length 5.5
  TOP w0.1: 243.21,264.79 242.91,264.49 242.91,263.08 244,261.99 244,260.56 C2B1.2
DDI3_TX3_C_DP: length 5.5
  TOP w0.1: U3A5.A2 242.71,264.49 242.71,263 243.8,261.91 243.8,260.57 C3B7.2
DDI3_TX3_DN: length 111
  TOP w0.1: J3D1.E40 241.23,194.31 240.95,194.31 240.82,194.44 240.82,194.68 240.91,194.77 241.76,194.77 242.93,195.94 242.93,198.99 246.43,202.49 251.76,202.49 258.01,208.73 258.01,209.12 v1(258.3,209.42) ; C2B1.1 243.98,258.72 243.98,256.5 v1(244.3,256.18)
  BOTTOM w0.1: v1(258.3,209.42) 258.01,209.72 258.01,210.51 260.39,212.9 263.4,212.9 273.92,223.43 273.92,238.62 274.32,239.01 274.32,240.28 273.93,240.67 273.93,248.06 266.95,255.04 244.72,255.04 243.99,255.78 243.99,255.87 v1(244.3,256.18)
DDI3_TX3_DP: length 111
  TOP w0.1: v1(243.47,256.18) 243.68,256.18 243.78,256.28 243.78,259.26 243.65,259.39 243.51,259.39 R3B7.1 ; J3D1.E39 240.62,194.62 240.62,194.77 240.82,194.97 241.67,194.97 242.73,196.02 242.73,199.07 246.35,202.69 251.68,202.69 257.81,208.82 257.81,209.12 v1(257.51,209.42)
  BOTTOM w0.1: v1(243.47,256.18) 243.79,255.87 243.79,255.7 244.64,254.84 266.87,254.84 273.73,247.98 273.73,240.58 274.12,240.2 274.12,239.1 273.72,238.7 273.72,223.51 263.31,213.1 260.31,213.1 257.81,210.59 257.81,209.72 v1(257.51,209.42)
DDPB_CTRLCLK: length 290.6
  TOP w0.089: U6E1.AL13 v1(98.84,152.35)
  TOP w0.1: v1(268,266.23) Q2A6.3 270.47,266.23 R2A46.2
  LAY5 w0.125: v1(268,266.23) 267.58,265.81 264.71,265.81 264.07,265.17 262.38,265.17 259.97,262.76 254.63,262.76 251.72,259.85 236.94,259.85 236.55,259.46 233.65,259.46 232.12,257.93 230.89,257.93 229.98,258.83 224.82,258.83 224.16,258.17 216.4,258.17 214.86,259.71 211.45,259.71 210.56,258.82 208.53,258.82 207.88,258.17 199.52,258.17 197.58,256.24 195.53,256.24 194.55,255.26 193.33,255.26 192.94,254.87 182.22,254.87 180.56,253.21 180.03,252.68 174.62,252.68 174.09,253.21 147.6,253.21 146.98,252.6 137.58,252.6 134.59,249.6 131.77,249.6 130.42,248.25 128.39,248.25 125.3,245.16 117.01,245.16 116.58,245.59 111.37,245.59 111.16,245.37 109.69,245.37 108.39,246.68 97.41,246.68 v1(97.4,246.68)
  BOTTOM w0.089: 96.77,160.79 97.15,160.41 97.15,158.19 97.79,157.55 97.79,156.59 97.44,156.24 97.44,155.8 97.79,155.45 97.79,155.12 98.04,154.87 98.04,154.3 98.37,153.97 98.37,152.81 v1(98.84,152.35)
  BOTTOM w0.1: v1(97.4,246.68) 97.15,246.43 97.15,239.8 95.02,237.67 95.02,222.5 91.56,219.04 91.56,214.76 89.34,212.53 89.34,199.92 90.94,198.32 90.94,198.32 90.94,197.16 89.69,195.91 89.69,192.18 89.53,192.02 89.53,189.17 88.56,188.2 88.56,180.08 90.7,177.93 90.7,175.7 95.62,170.78 95.62,164.63 95.98,164.27 95.98,162.2 96.73,161.45 96.73,160.83 96.77,160.79
DDPB_CTRLDATA: length 305.4
  TOP w0.089: U6E1.AR8 v1(96.63,155.2)
  TOP w0.1: R2A36.2 270.38,269.87 v1(270.12,269.62) 269.78,269.28 Q2A3.2
  LAY5 w0.125: v1(270.12,269.62) 266.97,269.62 266.24,270.35 253.57,270.35 252.84,269.62 246.19,269.62 244.68,271.14 241.04,271.14 241.03,271.14 233.42,271.14 232.79,270.51 229.92,270.51 229.12,269.71 229.12,268.04 227.54,266.46 221.96,266.46 221.58,266.84 216.6,266.84 214.72,268.71 210.47,268.71 207.96,266.2 207.96,266 207.26,265.3 202.39,265.3 200.73,266.96 196.09,266.96 195.7,266.57 192.02,266.57 191.5,267.09 185.66,267.09 184.4,268.35 179.83,268.35 178.93,267.45 175.19,267.45 170.26,262.52 168.91,262.52 167.89,261.49 162.56,261.49 162.17,261.11 158.97,261.11 157.45,259.6 149.81,259.6 149.02,258.81 143.34,258.81 143.06,258.52 135.31,258.52 131.72,254.94 129.55,254.94 128.2,253.59 126.18,253.59 124.56,251.97 117.72,251.97 117.22,252.47 113.72,252.47 113.6,252.36 107.04,252.36 106.91,252.23 103.94,252.23 103.48,251.76 98.53,251.76 98.45,251.84 96.52,251.84 95.85,251.17 90.37,251.17 90.21,251.33 89.91,251.33 89.72,251.52 v1(89.7,251.52)
  BOTTOM w0.089: 95.37,159.89 96.13,159.14 96.13,156.28 96.01,156.16 96.01,155.81 96.26,155.56 96.27,155.56 v1(96.63,155.2)
  BOTTOM w0.1: 95.37,159.89 95.37,160.81 94.1,162.09 94.1,163.32 93.59,163.83 92.92,163.83 90.29,166.46 90.29,170.51 86.61,174.19 86.61,177.51 85.47,178.64 85.47,192.12 84.63,192.96 84.63,195.38 84.16,195.86 84.16,197.16 85.76,198.77 85.76,215.21 87.49,216.93 87.49,222.71 91.11,226.34 91.11,232.17 89.52,233.76 89.52,235.2 90.17,235.84 90.17,239.77 89.66,240.28 89.66,243.97 89.28,244.35 89.28,245.49 89.47,245.68 89.47,251.27 89.7,251.5 v1(89.7,251.52)
DDPC_CTRLCLK: length 278.2
  TOP w0.089: U6E1.AN13 v1(97.75,152.37)
  TOP w0.1: R2A54.2 v1(249.93,264.03) R2A55.1
  LAY5 w0.125: v1(98.17,250.77) 98.69,250.25 103.45,250.25 103.94,249.76 111.18,249.76 112.02,248.92 113.91,248.92 114.34,249.34 124.76,249.34 127,251.59 129.03,251.59 130.38,252.94 133.2,252.94 136.31,256.05 145.73,256.05 146.49,256.81 149.85,256.81 150.61,257.58 153.38,257.58 154.42,256.54 157.58,256.54 158.72,257.68 159.89,257.68 161.07,258.86 163.1,258.86 163.48,259.24 172.1,259.24 175.12,262.25 182.62,262.25 184.37,264 192.23,264 192.55,264.32 199.03,264.32 199.27,264.08 199.27,263.19 200.07,262.39 207.53,262.39 211.02,265.88 213.86,265.88 216.72,263.02 222.75,263.02 224.28,261.49 227.45,261.49 230.25,264.29 231.82,264.29 233.72,262.38 235.33,262.38 235.71,262 237.75,262 238.13,261.62 246.76,261.62 R2A54.2 v1(249.93,264.03)
  BOTTOM w0.089: v1(97.75,152.37) 98.18,152.81 98.18,153.89 97.85,154.22 97.85,154.79 97.6,155.04 97.6,155.37 97.25,155.72 97.25,156.32 97.59,156.67 97.59,157.48 96.96,158.11 96.96,160.07 96.6,160.42
  BOTTOM w0.1: v1(98.17,250.77) 98.17,249.93 96.9,248.66 96.9,247.52 96.64,247.27 96.64,245.11 94.55,243.01 94.55,230.03 93.38,228.87 93.38,221.53 91.09,219.23 91.09,214.95 88.86,212.73 88.86,199.72 90.46,198.12 90.46,197.36 89.21,196.1 89.21,192.38 88.08,191.25 88.08,179.88 90.23,177.74 90.23,174.43 93.18,171.48 93.18,169.61 95.15,167.65 95.15,164.43 95.51,164.07 95.51,162.04 96.41,161.14 96.41,160.62 96.6,160.42
DDPC_CTRLDATA: length 263.8
  TOP w0.089: U6E1.AL10 v1(98.84,153.87)
  TOP w0.1: R2A51.1 v1(249.93,264.79) R2A50.2
  LAY5 w0.125: v1(106.04,250.24) 106.06,250.26 114.61,250.26 115.02,249.84 124.55,249.84 126.8,252.09 128.82,252.09 130.17,253.44 132.99,253.44 136.12,256.56 145.54,256.56 146.28,257.31 149.64,257.31 150.41,258.08 153.89,258.08 154.93,257.04 157.37,257.04 159.69,259.36 162.9,259.36 163.27,259.73 171.89,259.73 175.57,263.41 178.95,263.41 180.04,264.5 192.03,264.5 192.35,264.82 199.23,264.82 199.77,264.29 199.77,263.4 200.27,262.89 207.32,262.89 210.81,266.38 214.06,266.38 216.21,264.23 221.8,264.23 222.15,264.58 228.91,264.58 229.26,264.93 231.9,264.93 233.31,263.52 235.45,263.52 236.22,262.76 237.87,262.76 238.37,262.25 246.68,262.25 249.22,264.79 v1(249.93,264.79)
  BOTTOM w0.089: 98.57,160.5 98.57,156.5 98.7,156.37 98.7,155.75 98.88,155.57 98.88,154.99 99.14,154.73 99.14,154.17 v1(98.84,153.87)
  BOTTOM w0.1: 98.57,160.5 98.57,171.04 96.52,173.1 96.52,183.13 97.28,183.89 97.28,185.42 99.94,188.09 99.94,190.17 98.67,191.44 98.67,193.8 98.42,194.05 98.42,210.5 101.34,213.43 101.34,217.68 100.45,218.57 100.45,220.72 103.28,223.55 103.28,229.74 107.23,233.69 107.23,240.74 106.04,241.93 v1(106.04,250.24)
DDR4_DRAMRST_N: length 308.4
  TOP w0.089: 233.42,98.17 233.42,99.57 234.18,100.33 234.18,102.83 234.32,102.97 ; 234.85,132.23 234.77,132.23 234.53,131.99 234.53,130.26 234.33,130.06 J1E5.58 ; 234.34,111.86 234.34,114.62 ; 234.34,111.86 234.34,109.12 233.42,108.2 233.42,107.69 233.14,107.42 C3F17.1 ; 234.34,111.86 J1F2.58 ; 232.66,105.41 232.66,104.39 233.29,103.76 233.68,103.76 234.32,103.11 234.32,102.97 ; 234.32,102.97 J1F3.58 ; J1F1.58 234.32,122.28 234.32,119.88 235.1,119.1 235.1,117.47 ; C3E13.1 235.58,132.96 235.54,132.91
  TOP w0.1: 234.34,114.62 234.34,115.59 C3F3.1 235.1,117.47 ; v1(232.53,97.15) 233.04,96.65 C3G10.1 233.29,97.41 233.42,97.54 233.42,98.17 ; R7F16.1 75.81,118.49 75.81,117.22 v1(76.45,116.58) ; 232.66,105.41 233.14,105.89 C3F17.1
  TOP w0.102: 234.85,132.23 235.54,132.91
  LAY3 w0.1: J1F1.58 234.74,122.28 236.04,123.59 236.04,124.96 235.11,125.89 235.11,126.55 235.97,127.41 235.97,128.41 J1E5.58
  LAY5 w0.125: v1(232.53,97.15) 232.02,97.15 231.9,97.28 217.04,97.28 216.4,96.65 216.4,93.85 218.82,91.44 218.82,88.26 215.54,84.99 211.17,84.99 210.56,85.6 210.56,86.87 204.46,92.97 191.79,92.97 189.77,90.94 186.54,90.94 186.02,90.42 179.08,90.42 174.65,85.98 171.25,85.98 165.4,80.14 163.14,80.14 162.81,79.8 162.81,79.37 162.94,79.25 162.94,78.23 162.45,77.74 154.69,77.74 153.36,76.41 142.77,76.41 138.12,71.75 132.22,71.75 131.34,70.86 107.41,70.86 106.72,71.56 99.5,71.56 98.51,70.58 98.51,63.31 91.21,56.01 90.7,56.01 90.5,55.8 90.5,55.34 89.42,54.27 86.87,54.27 86.59,54.56 83.53,54.56 82.69,53.71 81.27,53.71 80.51,52.96 v1(80.01,52.96)
  LAY6 w0.125: v1(80.01,52.96) 79.99,52.98 79.99,55 80.39,55.4 80.39,62.51 80.81,62.94 80.81,70.89 79.86,71.85 79.86,73.28 79.39,73.74 79.39,78.51 80.21,79.32 80.21,83.45 80.03,83.63 80.03,94.13 77.22,96.94 77.22,104.39 75.31,106.29 75.31,108.2 74.04,109.47 74.04,111.38 75.17,112.51 75.17,115.56 76.2,116.58 v1(76.45,116.58)
