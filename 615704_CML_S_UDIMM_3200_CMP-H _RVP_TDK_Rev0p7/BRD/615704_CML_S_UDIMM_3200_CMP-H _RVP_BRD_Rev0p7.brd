# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE8_TR_U2_RX_DN: length 23
  TOP w0.089: U6E1.F24 v1(111.52,147.81)
  TOP w0.1: v1(127.68,148.21) 127.5,148.21 127.37,148.34 127.37,148.53 127.51,148.67 130.63,148.67 130.84,148.46 R6E13.1
  BOTTOM w0.1: v1(127.68,148.21) 127.5,148.21 127.38,148.08 127.38,147.68 127.16,147.47 126.28,147.47 126.06,147.24 114.24,147.24 113.43,148.06 112.89,148.06 112.7,148.25 111.34,148.25 111.21,148.11 111.21,147.99 111.39,147.81 v1(111.52,147.81)
PCIE8_TR_U2_RX_DP: length 23
  TOP w0.089: U6E1.G24 v1(110.76,147.81)
  TOP w0.1: R6E11.1 130.35,148.87 127.43,148.87 127.17,148.62 127.17,148.33 127.05,148.21 v1(126.88,148.21)
  BOTTOM w0.1: v1(126.88,148.21) 127.18,147.91 127.18,147.77 127.08,147.67 126.2,147.67 125.98,147.44 114.33,147.44 113.51,148.26 112.98,148.26 112.79,148.45 111.26,148.45 111.01,148.2 111.01,148.07 v1(110.76,147.81)
PCIE8_TR_U2_TX_DN: length 23
  TOP w0.1: R5E38.1 134.78,145.8 134.78,145.35 134.69,145.26 134.45,145.26 134.28,145.44 124.69,145.44 122.96,147.16 113.3,147.16 U6E1.B24
PCIE8_TR_U2_TX_DP: length 23
  TOP w0.1: U6E1.C24 113.12,146.96 122.88,146.96 124.61,145.24 134.2,145.24 R5E39.1
PCIE8_U2_R_RX_DN: length 14.3
  TOP w0.1: J5H1.A8 162.96,63.12 161.75,64.34 155.11,64.34 154.76,64.69 151.84,64.69 R5G35.2
PCIE8_U2_R_RX_DP: length 14.3
  TOP w0.1: J5H1.A7 162.21,62.13 162.36,61.98 162.64,61.98 162.76,62.11 162.76,63.04 161.66,64.14 155.03,64.14 154.67,64.49 151.87,64.49 R5H1.2
PCIE8_U2_R_TX_DN: length 10.2
  TOP w0.1: J5H1.C8 162.96,69.66 166.7,73.39 166.7,76.91 C5G23.1
PCIE8_U2_R_TX_DP: length 10.2
  TOP w0.1: C5G22.1 166.5,76.83 166.5,73.48 162.83,69.81 162.39,69.81 162.21,69.98 J5H1.C7
PCIE8_U2_RX_DN: length 111.8
  TOP w0.1: v1(149.63,65.26) 149.32,64.94 149.32,64.78 149.42,64.68 150.02,64.68 R5G35.1 ; v1(128.88,126.8) 129.18,126.49 129.54,126.49 130.35,127.31 130.35,128.77 130.83,129.25 130.95,129.25 131.26,129.56 131.26,130.4 131.31,130.45 131.49,130.64 131.49,131.51 138.48,138.49 138.48,146.48 136.28,148.68 132.12,148.68 131.99,148.82 131.69,148.82 131.57,148.69 131.57,148.37 R6E13.2
  BOTTOM w0.1: v1(128.88,126.8) 129.18,126.49 129.41,126.49 129.66,126.24 129.66,119.05 126.7,116.08 126.7,95.57 128.14,94.13 128.14,80.77 137.21,71.7 138.51,71.7 140.49,69.72 145.41,69.72 148.13,67 148.8,67 149.27,66.53 149.27,65.62 v1(149.63,65.26)
PCIE8_U2_RX_DP: length 111.8
  TOP w0.1: v1(148.81,65.26) 149.12,64.95 149.12,64.69 149.34,64.48 150.02,64.48 R5H1.1 ; R6E10.2 132.21,148.88 136.36,148.88 138.68,146.56 138.68,138.41 131.69,131.43 131.69,130.55 131.46,130.32 131.46,129.48 131.03,129.05 130.91,129.05 130.55,128.69 130.55,127.22 129.62,126.29 129.18,126.29 v1(128.88,125.98)
  BOTTOM w0.1: v1(148.81,65.26) 149.07,65.52 149.07,66.45 148.71,66.8 148.05,66.8 145.33,69.52 140.4,69.52 138.43,71.5 137.13,71.5 127.94,80.69 127.94,94.05 126.5,95.49 126.5,116.17 129.46,119.13 129.46,126.15 129.33,126.29 129.18,126.29 v1(128.88,125.98)
PCIE8_U2_TX_DN: length 114.5
  TOP w0.1: v1(166.97,78.89) 166.66,78.58 166.66,78.31 166.73,78.23 C5G23.2 ; R5E37.2 135.78,145.69 136.2,145.69 136.62,145.26 136.62,140.08 128.7,132.15 128.7,130.02 128.45,129.78 128.25,129.78 v1(127.97,129.5)
  BOTTOM w0.1: v1(127.97,129.5) 128.27,129.8 128.79,129.8 130.42,128.17 130.42,127.31 132.38,125.35 132.38,119.03 128.83,115.47 128.83,98.09 130.22,96.69 130.22,83.4 135.6,78.02 140.25,78.02 142.15,76.13 152.19,76.13 152.72,75.59 163.98,75.59 166.66,78.27 166.66,78.58 v1(166.97,78.89)
PCIE8_U2_TX_DP: length 114.5
  TOP w0.1: C5G22.2 166.37,78.23 166.46,78.32 166.46,78.58 v1(166.15,78.89) ; R5E39.2 135.28,145.04 135.28,145.31 135.46,145.49 136.11,145.49 136.42,145.18 136.42,140.16 128.5,132.24 128.5,130.1 128.37,129.98 128.12,129.98 127.97,130.13 v1(127.97,130.31)
  BOTTOM w0.1: v1(127.97,130.31) 128.27,130 128.87,130 130.62,128.25 130.62,127.4 132.58,125.44 132.58,118.94 129.03,115.39 129.03,98.17 130.42,96.77 130.42,83.48 135.68,78.22 140.34,78.22 142.24,76.33 152.27,76.33 152.8,75.79 163.9,75.79 166.46,78.35 166.46,78.58 v1(166.15,78.89)
PCIE9_SLOT3_RX_DN: length 172.4
  TOP w0.1: v1(47.59,229.01) 47.49,229.11 46.86,229.11 R8B37.2 ; U6E1.G36 v1(110.78,140.9)
  LAY6 w0.115: v1(110.78,140.9) 110.85,140.98 111.62,140.98 111.73,140.86 111.96,140.86 112.26,140.56 114.47,140.56 117.27,137.77 117.27,130.1 113.07,125.91 88.21,125.91 86.92,127.2 84.12,127.2 82.8,128.52 82.8,129.19 80.23,131.75 80.23,132.69 79.9,133.02 79.9,135.1 76.07,138.94 76.07,140.52 72.92,143.67 72.92,145.14 70.58,147.47 68.61,147.47 67.2,148.87 67.2,155.22 63.77,158.65 63.77,166.85 62.99,167.64 62.99,169.67 61.97,170.69 61.97,173.41 59.58,175.8 59.58,176.5 60.19,177.11 60.19,179.32 58,181.52 58,184.87 51.68,191.19 51.68,199.55 51.3,199.93 51.3,201.98 48.79,204.5 48.79,214.14 49.55,214.91 49.55,217.71 48.28,218.98 48.28,229.04 48.14,229.18 47.76,229.18 v1(47.59,229.01)
PCIE9_SLOT3_RX_DP: length 172.4
  TOP w0.1: U6E1.F36 v1(111.44,140.52) ; R8B35.2 46.29,229.69 46.29,229.43 46.41,229.31 47.24,229.31 47.59,229.66 v1(47.59,229.84)
  LAY6 w0.115: v1(111.44,140.52) 111.55,140.64 111.56,140.63 111.86,140.63 112.16,140.33 114.38,140.33 117.04,137.67 117.04,130.2 112.98,126.13 88.31,126.13 87.01,127.43 84.22,127.43 83.03,128.62 83.03,129.28 80.46,131.85 80.46,132.79 80.13,133.12 80.13,135.2 76.3,139.03 76.3,140.61 73.15,143.76 73.15,145.23 70.68,147.7 68.7,147.7 67.43,148.97 67.43,155.32 64,158.75 64,166.95 63.22,167.73 63.22,169.77 62.2,170.78 62.2,173.5 59.81,175.89 59.81,176.4 60.42,177.01 60.42,179.42 58.23,181.61 58.23,184.97 51.91,191.29 51.91,199.64 51.53,200.02 51.53,202.08 49.02,204.6 49.02,214.05 49.78,214.81 49.78,217.8 48.51,219.07 48.51,229.14 48.23,229.41 47.82,229.41 47.59,229.65 v1(47.59,229.84)
PCIE9_SLOT3_RX_R_DN: length 4.4
  TOP w0.1: R8B37.1 45.72,229.12 45.62,229.22 45.07,229.22 44.45,228.6 43.6,228.6 43.16,229.04 42.58,229.04 J8B1.A17
PCIE9_SLOT3_RX_R_DP: length 4.4
  TOP w0.1: R8B35.1 45.72,229.54 45.6,229.42 44.99,229.42 44.37,228.8 43.69,228.8 43.37,229.11 43.37,229.43 43.59,229.65 J8B1.A16
PCIE9_SLOT3_TX_C_DN: length 9.2
  TOP w0.1: C8B30.2 45.72,231.48 45.55,231.65 45.36,231.65 45.15,231.44 45.15,231.08 44.7,230.63 43.25,230.63 42.44,231.45 39.26,231.45 39.08,231.27 39.08,230.86 39.3,230.65 J8B1.B15
PCIE9_SLOT3_TX_C_DP: length 9.2
  TOP w0.1: J8B1.B14 42.52,231.65 43.33,230.83 44.62,230.83 44.95,231.17 44.95,231.52 C8B28.2
PCIE9_SLOT3_TX_DN: length 193.8
  TOP w0.088: U6E1.C34 112.76,142.22 112.89,142.34 113.14,142.34 113.15,142.35 117.58,142.35 117.69,142.25 118.38,142.25 119.58,141.05 119.73,141.05 119.86,141.17 119.86,141.38 v1(119.72,141.52)
  TOP w0.1: C8B30.1 46.35,231.39 46.35,231.58 46.55,231.78 47.26,231.78 47.59,231.46 v1(47.59,231.3)
  LAY6 w0.115: v1(119.72,141.52) 119.83,141.4 119.83,141.15 119.72,141.03 119.72,140.37 122.07,138.02 122.07,136.29 122,135.82 121.05,132.49 121.05,129.36 114.83,123.14 103.22,123.14 102.64,122.55 97.91,122.55 95.6,120.24 90.9,120.24 90.24,120.9 84.07,120.9 82.04,122.93 82.04,124.89 79.01,127.92 78.29,127.92 74.67,131.54 74.67,133.8 68.55,139.92 68.55,142.77 64.35,146.97 64.35,149.58 60.68,153.26 60.68,164.74 60.19,165.23 60.19,167.71 54.48,173.42 54.48,176.4 52.45,178.43 52.45,183.51 49.02,186.94 49.02,187.39 48.39,188.03 47.93,188.03 47.43,188.53 47.43,192.28 46.58,193.13 46.58,200.88 45.54,201.92 45.54,230.28 47.06,231.8 47.24,231.8 47.59,231.45 v1(47.59,231.3)
PCIE9_SLOT3_TX_DP: length 193.8
  TOP w0.088: v1(120.27,140.97) 120.15,140.86 119.51,140.86 118.3,142.06 117.61,142.06 117.51,142.17 113.23,142.17 112.94,141.88 112.58,141.88 U6E1.D34
  TOP w0.1: v1(47.59,232.12) 47.44,231.98 47.44,231.98 46.9,231.98 C8B28.1
  LAY6 w0.115: v1(120.27,140.97) 119.95,140.65 119.95,140.46 122.3,138.12 122.3,136.27 122.23,135.77 121.28,132.46 121.28,129.26 114.92,122.91 103.32,122.91 102.73,122.32 98.01,122.32 95.7,120.01 90.8,120.01 90.14,120.67 83.97,120.67 81.81,122.84 81.81,124.8 78.92,127.69 78.2,127.69 74.44,131.44 74.44,133.71 68.32,139.83 68.32,142.67 64.12,146.87 64.12,149.49 60.45,153.16 60.45,164.65 59.96,165.13 59.96,167.61 54.25,173.33 54.25,176.31 52.22,178.34 52.22,183.42 48.79,186.85 48.79,187.3 48.29,187.8 47.84,187.8 47.2,188.43 47.2,192.19 46.35,193.04 46.35,200.79 45.31,201.83 45.31,230.37 46.96,232.03 47.49,232.03 v1(47.59,232.12)
PCIE10_SLOT3_RX_DN: length 156.7
  TOP w0.1: v1(49.91,223.65) 49.91,223.67 49.62,223.95 49.09,223.95 48.29,224.75 47.08,224.75 R8C6.2 ; U6E1.K37 v1(109.4,140.4)
  LAY6 w0.089: v1(109.4,140.4) 109.17,140.16 109.17,139.99 109.41,139.75 109.79,139.75 109.93,139.61 109.93,139.33 110.12,139.14 110.12,138.59 110.45,138.26 110.45,137.89 110.71,137.62 110.71,136.79 111.04,136.46 111.04,136.3 111.02,136.27
  LAY6 w0.115: 111.02,136.27 111.02,135.54 111.66,134.9 112.29,134.9 113.36,133.84 113.36,130.07 112.02,128.73 109.77,128.73 109.37,129.13 107.77,129.13 107.47,128.83 100.56,128.83 100.18,128.45 96.46,128.45 95.8,129.11 89.2,129.11 86.74,131.57 85.34,131.57 83.05,133.86 83.05,134.06 83.43,134.44 83.43,138.05 80.28,141.2 80.28,143.1 77.61,145.77 76.85,145.77 70.96,151.66 70.96,155.16 66.27,159.86 66.27,163.42 66.52,163.68 66.52,172.56 65.91,173.17 65.91,177.16 64.49,178.58 64.49,179.67 63.6,180.56 63.6,183.66 55.24,192.02 55.24,199.13 54.86,199.52 54.86,202.51 53.82,203.55 53.82,205.13 52.07,206.88 52.07,215.14 51.3,215.9 51.3,219.96 50.67,220.6 50.67,221.92 49.34,223.25 49.34,223.85 49.51,224.02 49.75,224.02 49.91,223.87 v1(49.91,223.65)
PCIE10_SLOT3_RX_DP: length 156.7
  TOP w0.1: v1(49.91,224.46) 49.6,224.15 49.17,224.15 48.37,224.95 47.08,224.95 R8C3.2 ; U6E1.J37 v1(110.13,140.05)
  LAY6 w0.089: 111.25,136.27 111.25,136.55 110.92,136.88 110.92,137.71 110.65,137.97 110.65,138.34 110.32,138.67 110.32,139.23 110.13,139.42 v1(110.13,140.05)
  LAY6 w0.115: v1(49.91,224.46) 49.7,224.25 49.41,224.25 49.11,223.94 49.11,223.15 50.44,221.82 50.44,220.5 51.07,219.87 51.07,215.8 51.84,215.04 51.84,206.79 53.59,205.03 53.59,203.45 54.63,202.41 54.63,199.42 55.01,199.04 55.01,191.93 63.37,183.57 63.37,180.47 64.26,179.58 64.26,178.49 65.68,177.07 65.68,173.08 66.29,172.46 66.29,163.77 66.04,163.52 66.04,159.76 70.73,155.07 70.73,151.57 76.76,145.54 77.52,145.54 80.05,143 80.05,141.1 83.2,137.95 83.2,134.54 82.82,134.16 82.82,133.76 85.24,131.34 86.64,131.34 88.48,129.5 89.1,128.88 95.71,128.88 96.37,128.22 100.27,128.22 100.65,128.6 107.56,128.6 107.87,128.9 109.27,128.9 109.68,128.5 112.11,128.5 113.59,129.97 113.59,133.93 112.39,135.13 111.76,135.13 111.25,135.63 111.25,136.27
PCIE10_SLOT3_RX_R_DN: length 4.2
  TOP w0.1: J8B1.A22 43.52,223.65 43.27,223.9 43.27,224.15 43.65,224.53 44.65,224.53 44.88,224.77 45.23,224.77 R8C6.1
PCIE10_SLOT3_RX_R_DP: length 4.2
  TOP w0.1: J8B1.A21 42.58,224.25 43.09,224.25 43.57,224.73 44.57,224.73 44.8,224.97 45.26,224.97 R8C3.1
PCIE10_SLOT3_TX_C_DN: length 9.1
  TOP w0.1: C8C1.2 45.23,227.05 44.96,227.05 44.43,226.52 43.66,226.52 42.76,225.61 39.04,225.61 38.74,225.91 37.95,225.91 J8B1.B20
PCIE10_SLOT3_TX_C_DP: length 9.1
  TOP w0.1: C8B37.2 45.26,227.25 44.88,227.25 44.34,226.72 43.58,226.72 42.68,225.81 39.12,225.81 38.84,226.09 38.84,226.46 39.03,226.65 J8B1.B19
PCIE10_SLOT3_TX_DN: length 184.4
  TOP w0.088: U6E1.C35 112.78,141.53 113.38,141.53 113.6,141.75 117.16,141.75 117.37,141.54 118.06,141.54 119.65,139.96 120.02,139.96 120.84,139.14 120.84,138.37 v1(120.49,138.02)
  TOP w0.1: C8C1.1 46.38,226.8 46.38,226.99 46.56,227.17 47.31,227.17 47.59,226.89 v1(47.59,226.72)
  LAY6 w0.115: v1(47.59,226.72) 47.29,227.02 46.93,227.02 46.28,226.36 46.28,204.04 47.49,202.82 47.49,199.01 47.75,198.75 47.75,193.55 48.86,192.44 48.86,189.14 55.22,182.78 55.22,173.73 60.93,168.02 60.93,165.7 61.44,165.19 61.44,155.47 61.97,154.94 61.97,153.16 65.15,149.99 65.15,147.7 67.36,145.49 68.88,145.49 69.97,144.4 69.97,141.35 71.37,139.95 71.37,138.14 75.43,134.08 75.43,132.33 77.72,130.05 78.99,130.05 79.94,129.09 79.94,128.08 82.86,125.16 82.86,123.2 84.39,121.66 88.51,121.66 89.33,122.48 95.93,122.48 97.35,123.9 114.48,123.9 120.16,129.58 120.16,135.6 120.78,136.23 120.78,137.72 v1(120.49,138.02)
PCIE10_SLOT3_TX_DP: length 184.4
  TOP w0.088: U6E1.B35 113.35,141.76 113.43,141.85 113.52,141.93 117.24,141.93 117.44,141.73 118.14,141.73 119.73,140.14 120.1,140.14 121.02,139.22 121.02,138.24 121.24,138.02 v1(121.31,138.02)
  TOP w0.1: C8B37.1 46.95,227.37 47.4,227.37 v1(47.59,227.55)
  LAY6 w0.115: v1(47.59,227.55) 47.29,227.25 46.84,227.25 46.05,226.46 46.05,203.94 47.26,202.72 47.26,198.91 47.52,198.66 47.52,193.45 48.63,192.34 48.63,189.04 54.99,182.68 54.99,173.64 60.7,167.92 60.7,165.61 61.21,165.1 61.21,155.38 61.74,154.84 61.74,153.07 61.81,153 64.92,149.89 64.92,147.6 64.98,147.54 67.26,145.26 68.78,145.26 69.74,144.3 69.74,141.25 71.14,139.86 71.14,138.05 75.2,133.98 75.2,132.24 77.62,129.82 78.89,129.82 79.71,129 79.71,127.98 82.63,125.06 82.63,123.1 84.3,121.43 88.61,121.43 89.42,122.25 96.03,122.25 97.45,123.67 114.58,123.67 120.39,129.48 120.39,135.51 121.01,136.13 121.01,137.72 v1(121.31,138.02)
PCIE11_SLOT3_RX_DN: length 159.2
  TOP w0.1: R8C17.2 46.95,220.05 49.13,220.05 v1(49.31,219.87) ; U6E1.G38 v1(110.78,139.58)
  LAY6 w0.115: v1(49.31,219.87) 49.58,220.14 49.73,220.14 50.31,219.56 50.31,214.52 49.75,213.96 49.75,204.75 52.19,202.31 52.19,200.1 52.98,199.32 52.98,191.67 58.8,185.86 58.8,181.86 60.96,179.7 60.96,177.42 62.48,175.89 62.48,173.99 63.75,172.72 63.75,168.08 64.54,167.29 64.54,159.03 67.96,155.61 67.96,151.41 74.44,144.94 74.44,143.61 77.31,140.74 78.13,140.74 79.33,139.54 79.33,138.02 80.79,136.56 80.79,133.25 81.68,132.36 81.68,131.48 83.82,129.34 83.82,128.58 84.46,127.94 87.25,127.94 87.79,127.4 95.07,127.4 95.84,126.64 112.66,126.64 116.43,130.41 116.43,136.73 113.35,139.8 112.21,139.8 111.98,140.03 111.23,140.03 v1(110.78,139.58)
PCIE11_SLOT3_RX_DP: length 159.2
  TOP w0.1: U6E1.F39 v1(111.44,139.25) ; R8C14.2 46.4,220.65 46.4,220.42 46.57,220.25 48.87,220.25 v1(49.31,220.69)
  LAY6 w0.115: v1(111.44,139.25) 111.29,139.25 111.22,139.32 111.22,139.7 111.32,139.8 111.88,139.8 112.11,139.57 113.26,139.57 116.2,136.63 116.2,130.5 112.57,126.87 95.93,126.87 95.17,127.63 87.88,127.63 87.35,128.17 84.55,128.17 84.05,128.67 84.05,129.44 81.91,131.57 81.91,132.46 81.02,133.35 81.02,136.65 79.56,138.11 79.56,139.64 78.23,140.97 77.41,140.97 74.67,143.71 74.67,145.03 68.19,151.51 68.19,155.7 64.77,159.13 64.77,167.38 63.98,168.17 63.98,172.81 62.71,174.08 62.71,175.99 61.19,177.51 61.19,179.8 59.03,181.96 59.03,185.95 53.21,191.77 53.21,199.41 52.42,200.2 52.42,202.4 49.98,204.84 49.98,213.87 50.54,214.43 50.54,219.65 49.83,220.37 49.64,220.37 v1(49.31,220.69)
PCIE11_SLOT3_RX_R_DN: length 4.2
  TOP w0.1: J8B1.A26 43.49,219.65 43.27,219.87 43.27,220.15 43.62,220.51 44.58,220.51 44.92,220.17 45.26,220.17 R8C17.1
PCIE11_SLOT3_RX_R_DP: length 4.2
  TOP w0.1: J8B1.A25 42.58,220.25 43.09,220.25 43.54,220.71 44.66,220.71 45,220.37 45.23,220.37 R8C14.1
PCIE11_SLOT3_TX_C_DN: length 8.8
  TOP w0.1: J8B1.B24 37.95,221.91 38.74,221.91 39.04,221.61 42.85,221.61 43.69,222.46 45.25,222.46 C8C10.2
PCIE11_SLOT3_TX_C_DP: length 8.8
  TOP w0.1: C8C7.2 45.23,222.66 43.61,222.66 42.76,221.81 39.12,221.81 38.87,222.07 38.87,222.49 39.03,222.65 J8B1.B23
PCIE11_SLOT3_TX_DN: length 173.1
  TOP w0.088: U6E1.B36 113.5,141.1 113.72,141.32 116.81,141.32 117.11,141.02 117.8,141.02 119.5,139.31 119.5,138.83 119.17,138.5 v1(118.96,138.5)
  TOP w0.1: v1(47.59,222.15) 47.59,222.31 47.31,222.59 46.56,222.59 46.38,222.41 46.38,222.22 C8C10.1
  LAY6 w0.115: v1(47.59,222.15) 47.59,222.39 47.44,222.53 47.15,222.53 47.01,222.39 47.01,215.49 47.54,214.95 47.54,203.91 48.26,203.2 48.26,199.77 49.78,198.25 49.78,189.43 55.98,183.23 55.98,177.51 60.42,173.07 60.42,169.64 61.69,168.37 61.69,166.08 62.2,165.57 62.2,158.39 63.27,157.32 63.27,153.01 65.91,150.37 65.91,148.08 67.76,146.23 69.41,146.23 70.73,144.91 70.73,141.8 74.52,138.02 74.52,136.24 76.32,134.44 76.32,132.59 77.97,130.94 79.24,130.94 81.4,128.77 81.4,127.89 83.33,125.96 86.38,125.96 88.64,123.7 92.07,123.7 93.04,124.66 113.79,124.66 118.87,129.74 118.87,135.84 119.56,136.53 119.56,137.89 119.42,138.02 118.92,138.02 118.82,138.12 118.82,138.35 v1(118.96,138.5)
PCIE11_SLOT3_TX_DP: length 173.1
  TOP w0.088: v1(119.79,138.5) 119.69,138.6 119.69,139.39 117.87,141.21 117.19,141.21 116.88,141.51 113.65,141.51 113.47,141.34 113.18,141.34 112.95,141.1 U6E1.C36
  TOP w0.1: C8C7.1 46.95,222.79 47.4,222.79 v1(47.59,222.98)
  LAY6 w0.115: v1(47.59,222.98) 47.36,222.76 47.05,222.76 46.78,222.48 46.78,215.39 47.31,214.86 47.31,203.81 48.03,203.1 48.03,199.67 49.55,198.15 49.55,189.33 55.75,183.13 55.75,177.42 60.19,172.97 60.19,169.54 61.46,168.27 61.46,165.99 61.97,165.48 61.97,158.29 63.04,157.23 63.04,152.91 65.68,150.27 65.68,147.99 65.75,147.92 67.67,146 69.32,146 70.5,144.81 70.5,141.71 74.29,137.92 74.29,136.14 76.09,134.34 76.09,132.49 77.88,130.71 79.14,130.71 81.17,128.68 81.17,127.79 83.24,125.73 86.29,125.73 88.55,123.47 92.17,123.47 93.13,124.43 113.89,124.43 119.1,129.64 119.1,135.75 119.79,136.44 v1(119.79,138.5)
PCIE12_SLOT3_RX_DN: length 151.2
  TOP w0.1: v1(51.3,213.31) 51.3,213.49 51.07,213.72 49.77,213.72 47.75,215.74 46.79,215.74 46.6,215.55 R8C23.2 ; U6E1.H42 v1(111.09,138.16)
  LAY6 w0.115: v1(111.09,138.16) 111.09,137.88 111.25,137.72 111.38,137.72 111.68,138.02 111.68,138.17 111.45,138.4 111.45,138.53 111.5,138.58 111.7,138.58 112.24,138.05 113.23,138.05 115.46,135.82 115.46,130.8 112.5,127.84 107.54,127.84 107.29,128.09 101.24,128.09 100.83,127.68 96.19,127.68 95.5,128.37 88.29,128.37 87.69,128.97 87.37,128.97 85.56,130.78 83.78,130.78 82.67,131.9 82.67,133.07 82.32,133.42 82.32,134.39 82.55,134.62 82.55,137.79 79.43,140.91 79.43,142.91 77.44,144.91 76.63,144.91 70.23,151.31 70.23,154.81 65.53,159.51 65.53,164.01 65.76,164.24 65.76,172.23 63.75,174.24 63.75,179.32 62.71,180.36 62.71,182.47 62.07,183.1 62.07,184.05 53.97,192.15 53.97,202.25 53.08,203.14 53.08,204.03 50.73,206.38 50.73,213.48 50.85,213.6 51.01,213.6 v1(51.3,213.31)
PCIE12_SLOT3_RX_DP: length 151.2
  TOP w0.1: U6E1.J41 v1(110.77,138.87) ; R8C21.2 46.95,215.94 47.83,215.94 49.85,213.92 51.1,213.92 v1(51.3,214.12)
  LAY6 w0.115: v1(110.77,138.87) 110.82,138.81 111.8,138.81 112.33,138.28 113.33,138.28 115.69,135.91 115.69,130.71 112.59,127.61 107.44,127.61 107.19,127.86 101.33,127.86 100.93,127.45 96.09,127.45 95.4,128.14 88.19,128.14 87.59,128.74 87.28,128.74 85.47,130.55 83.69,130.55 82.44,131.8 82.44,132.98 82.09,133.33 82.09,134.49 82.32,134.71 82.32,137.7 79.2,140.81 79.2,142.82 77.34,144.68 76.53,144.68 70,151.21 70,154.72 65.3,159.42 65.3,164.11 65.53,164.34 65.53,172.14 63.52,174.15 63.52,179.22 62.48,180.26 62.48,182.37 61.84,183.01 61.84,183.95 53.74,192.05 53.74,202.16 52.85,203.05 52.85,203.94 50.5,206.28 50.5,213.58 50.75,213.83 51.01,213.83 v1(51.3,214.12)
PCIE12_SLOT3_RX_R_DN: length 4.4
  TOP w0.1: R8C23.1 45.72,215.52 45.46,215.77 45.11,215.77 44.37,216.51 43.81,216.51 43.39,216.09 43.39,215.9 43.65,215.65 J8B1.A30
PCIE12_SLOT3_RX_R_DP: length 4.4
  TOP w0.1: J8B1.A29 42.65,216.18 43.2,216.18 43.73,216.71 44.45,216.71 45.19,215.97 45.4,215.97 R8C21.1
PCIE12_SLOT3_TX_C_DN: length 9
  TOP w0.1: C8C14.2 45.25,217.88 45.02,217.88 44.47,218.44 43.79,218.44 42.97,217.61 39.04,217.61 38.74,217.91 37.95,217.91 J8B1.B28
PCIE12_SLOT3_TX_C_DP: length 9
  TOP w0.1: J8B1.B27 39.03,218.65 38.87,218.49 38.87,218.07 39.12,217.81 42.88,217.81 43.71,218.64 44.55,218.64 45.1,218.08 45.23,218.08 C8C12.2
PCIE12_SLOT3_TX_DN: length 165
  TOP w0.088: v1(117.77,139.66) 117.99,139.66 118.11,139.78 118.11,139.93 117.54,140.49 116.93,140.49 116.53,140.89 113.84,140.89 113.61,140.66 112.72,140.66 112.53,140.48 U6E1.D38
  TOP w0.1: C8C14.1 46.45,217.58 46.45,217.89 46.68,218.12 47.1,218.12 47.29,217.92 47.29,217.59 47.54,217.35 48.04,217.35 48.22,217.17 v1(48.22,216.96)
  LAY6 w0.115: v1(48.22,216.96) 48.22,217.19 48.08,217.33 47.89,217.33 47.75,217.19 47.75,215.98 48.28,215.45 48.28,204.26 49.78,202.76 49.78,199.52 50.8,198.5 50.8,190.37 55.01,186.16 55.72,186.16 56.74,185.13 56.74,177.89 61.19,173.45 61.19,170.15 62.48,168.85 62.48,167.33 63.24,166.57 63.24,158.37 66.67,154.94 66.67,148.59 68.3,146.96 70.2,146.96 72.39,144.78 72.39,141.86 75.54,138.71 75.54,136.36 77.31,134.59 77.31,134.21 78.2,133.32 78.86,133.32 79.7,132.49 79.7,131.52 82.14,129.08 82.14,128.42 83.86,126.7 86.68,126.7 87.98,125.4 113.39,125.4 117.85,129.86 117.85,138.91 117.73,139.04 117.5,139.04 117.32,139.22 117.32,139.47 117.51,139.66 v1(117.77,139.66)
PCIE12_SLOT3_TX_DP: length 165
  TOP w0.088: U6E1.E37 112.05,140.74 112.53,140.74 112.64,140.85 113.54,140.85 113.58,140.9 113.58,140.9 113.77,141.08 116.61,141.08 117.01,140.68 117.62,140.68 118.29,140 118.29,139.14 v1(118.32,139.12)
  TOP w0.1: C8C12.1 46.85,218.32 47.18,218.32 47.49,218 47.49,217.68 47.62,217.55 47.99,217.55 v1(48.22,217.77)
  LAY6 w0.115: v1(48.22,217.77) 48.01,217.56 47.79,217.56 47.52,217.28 47.52,215.88 48.05,215.35 48.05,204.17 49.55,202.67 49.55,199.42 50.57,198.4 50.57,190.28 54.91,185.93 55.62,185.93 56.51,185.04 56.51,177.8 60.96,173.35 60.96,170.05 62.25,168.76 62.25,167.23 63.01,166.47 63.01,158.27 66.44,154.84 66.44,148.49 68.2,146.73 70.11,146.73 72.16,144.68 72.16,141.76 75.31,138.61 75.31,136.27 77.08,134.49 77.08,134.11 78.1,133.09 78.77,133.09 79.47,132.39 79.47,131.42 81.91,128.98 81.91,128.32 83.77,126.47 86.59,126.47 87.89,125.17 113.48,125.17 118.08,129.77 118.08,138.88 v1(118.32,139.12)
PCIE13_LAN_RX_C_DN: length 2.1
  TOP w0.1: EU4B1.39 185.54,256.03 185.44,255.93 185.44,255.68 184.95,255.19 184.95,254.97 C4B10.2
PCIE13_LAN_RX_C_DP: length 2.1
  TOP w0.1: C4B9.2 184.75,254.99 184.75,255.27 185.24,255.76 185.24,255.95 185.14,256.05 EU4B1.38
PCIE13_LAN_RX_DN: length 188.6
  TOP w0.1: U6E1.C45 v1(112.58,137.2) ; C4B10.1 184.94,253.4 184.94,252.69 v1(185.29,252.35)
  LAY6 w0.115: v1(185.29,252.35) 185.04,252.09 185.04,251.73 184.79,251.48 176.48,251.48 175.84,250.84 172.35,250.84 171.74,250.23 161.96,250.23 158.75,247.01 149.73,247.01 147.55,244.83 147.55,241.02 147.16,240.64 147.16,234.03 148.59,232.61 148.59,229.87 147.27,228.55 145.23,228.55 144.14,227.46 140.84,227.46 139.95,226.57 138.93,226.57 138.45,226.09 138.45,153.19 135.99,150.72 135.99,140.44 127.76,132.21 127,132.21 126.49,131.7 126.49,131.29 v1(126.79,130.99)
  BOTTOM w0.1: v1(126.79,130.99) 126.31,131.47 126.31,131.62 126.03,131.9 119.48,131.9 113.74,137.64 113.25,137.64 112.81,137.2 v1(112.58,137.2)
PCIE13_LAN_RX_DP: length 188.6
  TOP w0.1: v1(113.42,136.76) U6E1.C46 ; C4B9.1 184.64,253.74 184.74,253.64 184.74,252.69 v1(184.4,252.35)
  LAY6 w0.115: v1(184.4,252.35) 184.64,252.35 184.81,252.18 184.81,251.83 184.69,251.71 176.39,251.71 175.75,251.07 172.26,251.07 171.64,250.46 161.86,250.46 158.65,247.24 149.63,247.24 147.32,244.93 147.32,241.12 146.93,240.73 146.93,233.93 148.36,232.51 148.36,229.96 147.17,228.78 145.14,228.78 144.04,227.69 140.74,227.69 139.85,226.8 138.84,226.8 138.22,226.18 138.22,153.28 135.76,150.82 135.76,140.53 127.66,132.44 126.9,132.44 126.26,131.79 126.26,131.26 v1(125.99,130.99)
  BOTTOM w0.1: v1(125.99,130.99) 126.11,131.11 126.11,131.54 125.95,131.7 119.4,131.7 113.66,137.44 113.33,137.44 113.03,137.13 113.03,136.95 113.21,136.76 v1(113.42,136.76)
PCIE13_LAN_TX_C_DN: length 1.9
  TOP w0.1: C4B12.2 186.68,255.02 186.68,255.7 186.74,255.76 EU4B1.42
PCIE13_LAN_TX_C_DP: length 1.9
  TOP w0.1: EU4B1.41 186.34,255.76 186.48,255.62 186.48,254.93 C4B11.2
PCIE13_LAN_TX_DN: length 184.1
  TOP w0.089: U6E1.B38 113.51,140.37 116.08,140.37 116.66,139.78
  TOP w0.1: 116.66,139.78 118.75,137.69 119.81,137.69 121.54,135.96 130.98,135.96 133.8,138.79 133.8,140.94 v1(133.5,141.23) ; v1(187.07,252.98) 186.72,253.33 186.72,253.64 186.82,253.74 C4B12.1
  LAY6 w0.115: v1(187.07,252.98) 186.78,252.98 186.66,253.1 186.66,253.51 186.39,253.79 183.41,253.79 182.09,252.47 176.13,252.47 175.45,251.79 171.78,251.79 171.17,251.17 161.23,251.17 159.84,249.78 149.32,249.78 148.71,249.17 148.71,248.48 146.58,246.35 146.58,243.1 146.3,242.82 145.28,242.82 144.27,241.81 143.25,241.81 142.36,240.92 142.36,240.16 141.98,239.77 140.84,239.77 140.2,239.14 140.2,237.18 137.49,234.46 137.49,153.69 134.79,151 134.79,143.81 133.8,142.82 133.8,141.53 v1(133.5,141.23)
PCIE13_LAN_TX_DP: length 184.1
  TOP w0.089: 116.47,139.7 116.47,139.71 116,140.18 113.33,140.18 113.12,140.39 U6E1.C38
  TOP w0.1: C4B11.1 186.42,253.74 186.52,253.64 186.52,253.33 v1(186.18,252.98) ; v1(134.33,141.23) 134,140.91 134,138.7 131.06,135.76 121.46,135.76 119.73,137.49 118.67,137.49 116.47,139.7
  LAY6 w0.115: v1(186.18,252.98) 186.32,252.98 186.43,253.1 186.43,253.42 186.29,253.56 183.5,253.56 182.19,252.24 176.22,252.24 175.54,251.56 171.88,251.56 171.26,250.94 161.33,250.94 159.94,249.55 149.42,249.55 148.94,249.08 148.94,248.39 146.81,246.25 146.81,243.01 146.39,242.59 145.38,242.59 144.36,241.58 143.35,241.58 142.59,240.82 142.59,240.06 142.08,239.54 140.93,239.54 140.43,239.04 140.43,237.08 137.72,234.37 137.72,153.59 135.02,150.9 135.02,143.72 134.03,142.73 134.03,141.54 v1(134.33,141.23)
PCIE14_SATA1B_RX_DN: length 77
  TOP w0.1: R6G10.1 125.93,70.23 125.83,70.33 125.83,72.47 v1(126.12,72.77) ; U6E1.D46 v1(112.1,136.39)
  BOTTOM w0.1: v1(126.12,72.77) 125.93,72.96 125.93,76.4 124.38,77.95 124.38,83.44 124,83.82 124,117.38 125.54,118.93 125.54,127.21 123.9,128.85 121.57,128.85 114.43,135.99 113.41,135.99 113.01,136.39 112.59,136.39 112.58,136.39 v1(112.1,136.39)
PCIE14_SATA1B_RX_DP: length 77
  TOP w0.1: U6E1.C47 v1(112.42,135.69) ; C6G11.1 125.52,70.23 125.63,70.33 125.63,72.57 125.42,72.77 v1(125.33,72.77)
  BOTTOM w0.1: v1(125.33,72.77) 125.5,72.77 125.73,73.01 125.73,76.32 124.18,77.87 124.18,83.36 123.8,83.74 123.8,117.47 125.34,119.01 125.34,127.13 123.82,128.65 121.48,128.65 114.35,135.79 113.32,135.79 112.92,136.19 112.59,136.19 112.42,136.02 v1(112.42,135.69)
PCIE14_SATA1B_TX_DN: length 79.9
  TOP w0.088: 119.25,136.65 118.79,136.65 115.65,139.79 112.9,139.79 U6E1.C39
  TOP w0.1: v1(123.58,130.97) 123.87,131.27 123.87,132.28 119.5,136.65 119.25,136.65 ; v1(129.26,74.64) 129.49,74.64 129.61,74.51 129.61,72.09 129.41,71.88 129.15,71.88 R6G5.1
  BOTTOM w0.1: v1(123.58,130.97) 123.85,130.7 123.85,129.99 126.03,127.81 126.03,118.69 124.48,117.14 124.48,84.53 125.78,83.23 125.78,79.29 125.84,79.23 129.69,75.38 129.69,74.91 129.41,74.63 129.27,74.63 v1(129.26,74.64)
PCIE14_SATA1B_TX_DP: length 79.9
  TOP w0.088: U6E1.D39 112.38,140.16 112.92,140.16 113.1,139.98 115.73,139.98 118.87,136.84 119.16,136.84 119.17,136.84 119.23,136.84 119.23,136.85 119.25,136.85
  TOP w0.1: v1(130.06,74.64) 129.81,74.39 129.81,72.54 130.22,72.13 R6G6.1 ; 119.25,136.85 119.59,136.85 124.07,132.36 124.07,131.27 v1(124.37,130.97)
  BOTTOM w0.1: v1(130.06,74.64) 129.89,74.81 129.89,75.46 125.98,79.37 125.98,83.31 124.68,84.61 124.68,117.06 126.23,118.61 126.23,127.89 124.05,130.07 124.05,130.65 v1(124.37,130.97)
PCIE15_SATA2_RX_DN: length 81.8
  TOP w0.1: C6G8.1 107.87,72.26 107.61,72.52 107.61,72.76 v1(107.84,72.99) ; U6E1.F44 v1(111.9,137.6)
  BOTTOM w0.1: v1(111.9,137.6) 111.81,137.51 111.81,136.7 111.63,136.52 111.63,135.76 112.26,135.13 114.3,135.13 121.41,128.01 123.69,128.01 124.86,126.85 124.86,119.2 123.33,117.66 123.33,96.84 119.2,92.71 118.77,92.71 116.71,90.65 116.71,88.39 114.37,86.05 114.37,80.69 107.54,73.86 107.54,73.29 v1(107.84,72.99)
PCIE15_SATA2_RX_DP: length 81.8
  TOP w0.1: U6E1.E45 v1(111.35,137.06) ; C6G7.1 107.31,72.26 107.41,72.36 107.41,72.77 107.19,72.99 v1(107.04,72.99)
  BOTTOM w0.1: v1(107.04,72.99) 107.34,73.29 107.34,73.94 114.17,80.77 114.17,86.13 116.51,88.47 116.51,90.73 118.69,92.91 119.11,92.91 123.13,96.92 123.13,117.74 124.66,119.28 124.66,126.76 123.61,127.81 121.32,127.81 114.21,134.93 112.18,134.93 111.43,135.68 111.43,136.61 111.61,136.78 111.61,136.94 111.49,137.06 v1(111.35,137.06)
PCIE15_SATA2_TX_DN: length 83.5
  TOP w0.088: 119.12,135.48 119.12,135.89 115.41,139.59 114.4,139.59 113.28,139.6 U6E1.B40
  TOP w0.1: v1(121.2,90.48) 121.2,90.68 121.38,90.85 121.84,90.85 124.02,93.04 124.02,117.9 126.31,120.18 126.31,127.97 124.48,129.79 123.16,129.79 121.33,131.62 121.33,133.07 119.12,135.29 119.12,135.48 ; v1(110.78,74.65) 111.08,74.35 111.08,74.01 110.98,73.91 C6G5.1
  BOTTOM w0.1: v1(121.2,90.48) 121.2,90.6 121.41,90.8 121.59,90.8 121.72,90.68 121.72,89.36 120.82,88.46 117.77,88.46 116.13,86.82 116.13,81.33 113.91,79.12 113.91,77.6 112.72,76.4 112.18,76.4 111.08,75.3 111.08,74.95 v1(110.78,74.65)
PCIE15_SATA2_TX_DP: length 83.5
  TOP w0.088: 118.92,135.48 118.92,135.5 118.92,135.5 118.92,135.56 118.93,135.57 118.93,135.81 115.34,139.41 113.47,139.41 113.41,139.34 112.89,139.34 112.83,139.41 U6E1.C40
  TOP w0.1: 118.92,135.48 118.92,135.21 121.13,132.99 121.13,131.54 123.08,129.59 124.4,129.59 126.11,127.89 126.11,120.27 123.82,117.98 123.82,93.12 121.75,91.05 121.43,91.05 v1(121.2,91.28) ; v1(111.58,74.65) 111.28,74.35 111.28,74.01 111.38,73.91 C6G6.1
  BOTTOM w0.1: v1(111.58,74.65) 111.28,74.95 111.28,75.22 112.26,76.2 112.8,76.2 114.11,77.51 114.11,79.04 116.33,81.25 116.33,86.74 117.85,88.26 120.9,88.26 121.92,89.28 121.92,90.76 121.67,91 121.48,91 v1(121.2,91.28)
PCIE16_SATA3_RX_DN: length 70.4
  TOP w0.1: C6G4.2 107.75,83.62 107.54,83.62 107.31,83.85 107.31,84.33 107.69,84.71 108.93,84.71 109.14,84.5 109.14,84.28 v1(108.84,83.98) ; U6E1.L41 v1(109.61,138.78)
  BOTTOM w0.089: v1(109.61,138.78) 109.45,138.78 109.29,138.94 109.29,139.17 109.43,139.31 109.98,139.31 110.13,139.16 110.13,138.57 110.43,138.28 110.43,137.88 110.77,137.54 110.77,137.41 110.72,137.36 110.72,136.79 110.82,136.69 110.82,135.14 110.82,135.05
  BOTTOM w0.1: 110.82,135.05 110.82,134.33 111.12,134.03 111.12,128.75 119.73,120.14 119.73,108.71 120.38,108.06 120.38,96.76 109.14,85.53 109.14,84.28 v1(108.84,83.98)
PCIE16_SATA3_RX_DP: length 70.4
  TOP w0.1: v1(109.64,83.98) 109.34,84.28 109.34,84.58 109.02,84.91 107.61,84.91 107.11,84.41 107.11,84.13 C6G3.2 ; U6E1.M40 v1(108.96,139.51)
  BOTTOM w0.089: v1(108.96,139.51) 108.98,139.5 110.06,139.5 110.32,139.24 110.32,138.65 110.62,138.36 110.62,137.96 110.96,137.62 110.96,137.34 110.91,137.29 110.91,136.87 111.01,136.77 111.01,135.14 111.02,135.13
  BOTTOM w0.1: 111.02,135.13 111.02,135.05 111.02,135.05 111.02,134.41 111.32,134.11 111.32,128.83 119.93,120.22 119.93,108.79 120.58,108.14 120.58,96.68 109.34,85.45 109.34,84.28 v1(109.64,83.98)
PCIE16_SATA3_TX_DN: length 69.9
  TOP w0.088: 117.78,135.58 117.78,136.25 115.01,139.02 113.64,139.02 113.56,138.94 113.36,138.94 U6E1.B41
  TOP w0.1: 117.78,135.58 117.78,135.08 120.19,132.67 120.19,130.6 121.93,128.86 124.17,128.86 125.4,127.63 125.4,120.6 124.21,119.41 123.95,119.41 123.68,119.69 v1(123.68,119.8) ; v1(110.66,85.82) 110.81,85.82 111.05,85.59 111.05,85.19 110.95,85.09 C6G1.1
  BOTTOM w0.1: v1(110.66,85.82) 110.87,85.82 110.98,85.94 110.98,86.25 121.32,96.59 121.82,96.59 122.45,97.23 122.45,117.09 122.3,117.25 122.3,119.03 122.58,119.31 123.31,119.31 123.68,119.68 v1(123.68,119.8)
PCIE16_SATA3_TX_DP: length 69.9
  TOP w0.088: 117.98,135.58 117.98,135.6 117.97,135.6 117.97,135.66 117.97,135.67 117.97,136.33 115.08,139.21 114.31,139.21 114.31,139.21 113.57,139.21 113.48,139.13 113.05,139.13 U6E1.C41
  TOP w0.1: C6G2.1 111.25,85.34 111.25,85.62 v1(111.46,85.82) ; 117.98,135.58 117.98,135.16 120.39,132.75 120.39,130.68 122.02,129.06 124.25,129.06 125.6,127.71 125.6,120.52 124.29,119.21 123.88,119.21 v1(123.68,119.01)
  BOTTOM w0.1: v1(111.46,85.82) 111.35,85.82 111.18,85.99 111.18,86.17 121.41,96.39 121.9,96.39 122.65,97.14 122.65,117.18 122.5,117.33 122.5,118.94 122.66,119.11 123.57,119.11 v1(123.68,119.01)
PCIE21_SLOT2_RX_DN: length 136.1
  TOP w0.1: v1(53.29,229.84) 53.61,229.53 54.01,229.53 54.22,229.74 54.22,230 ; U6E1.T43 v1(107.03,138.05)
  LAY6 w0.115: v1(107.03,138.05) 107.03,137.72 106.57,137.26 106.57,135.98 104.68,134.09 94.46,134.09 94.1,133.73 90.8,133.73 88.26,136.27 88.26,137.51 89.02,138.27 89.02,143 85.85,146.18 84.65,146.18 83.94,146.88 83.94,148.41 82.67,149.68 82.67,152.27 78.25,156.69 76.29,156.69 75.16,157.83 75.16,162.27 73.85,163.58 73.85,164.78 74.54,165.48 74.54,167.38 73.43,168.5 73.43,180.51 71.47,182.47 71.47,185.51 62.1,194.89 62.1,203.52 57.12,208.5 57.12,226.79 54.37,229.54 53.59,229.54 v1(53.29,229.84)
PCIE21_SLOT2_RX_DP: length 136.1
  TOP w0.1: U6E1.R44 v1(107.41,137.39) ; 54.22,228.85 54.22,229.11 54.01,229.33 53.61,229.33 v1(53.29,229.01)
  LAY6 w0.115: v1(53.29,229.01) 53.59,229.31 54.28,229.31 56.89,226.69 56.89,208.41 61.87,203.43 61.87,194.79 71.24,185.42 71.24,182.37 73.2,180.42 73.2,168.41 74.31,167.29 74.31,165.57 73.62,164.88 73.62,163.49 74.93,162.18 74.93,157.73 76.2,156.46 78.16,156.46 82.44,152.18 82.44,149.58 83.71,148.31 83.71,146.79 84.55,145.95 85.75,145.95 88.79,142.91 88.79,138.36 88.03,137.6 88.03,136.18 90.71,133.5 94.2,133.5 94.55,133.86 104.77,133.86 106.8,135.89 106.8,137.16 107.03,137.39 v1(107.41,137.39)
PCIE21_SLOT2_RX_R_DN: length 11.7
  TOP w0.1: R8B36.1 55.62,229.49 56.26,229.49 56.95,228.8 58.47,228.8 59.56,227.71 63.11,227.71 63.67,228.27 63.67,228.8 63.47,229 62.86,229 J7B1.A17
PCIE21_SLOT2_RX_R_DP: length 11.7
  TOP w0.1: J7B1.A16 63.87,229.01 63.87,228.19 63.2,227.51 59.48,227.51 58.39,228.6 56.86,228.6 56.17,229.29 55.55,229.29 R8B38.1
PCIE21_SLOT2_TX_C_DN: length 5.9
  TOP w0.1: C8B31.2 55.57,231.6 56.02,231.6 57.04,230.58 58.65,230.58 59.1,231.04 59.61,231.04 J7B1.B15
PCIE21_SLOT2_TX_C_DP: length 5.9
  TOP w0.1: J7B1.B14 58.67,231.65 58.92,231.39 58.92,231.14 58.57,230.78 57.12,230.78 56.11,231.8 55.6,231.8 C8B29.2
PCIE21_SLOT2_TX_DN: length 152.7
  TOP w0.088: U6E1.G47 111.47,135.65 111.47,135.12 111.59,135.01 111.59,133.77 v1(112.01,133.35)
  TOP w0.1: v1(53.29,231.3) 53.29,231.48 53.49,231.67 54.05,231.67 54.22,231.49 C8B31.1
  LAY6 w0.115: v1(53.29,231.3) 53.29,231.56 53.18,231.67 52.36,231.67 50.67,229.98 50.67,226.31 51.43,225.55 51.43,221.01 52.07,220.37 52.07,216.22 52.83,215.46 52.83,207.26 54.58,205.51 54.58,203.93 56.11,202.4 56.11,192.3 64.36,184.05 64.36,182.08 65.53,180.92 65.53,178.81 66.67,177.67 66.67,173.73 68.27,172.13 68.27,160.14 70.08,158.34 70.08,157.12 71.75,155.45 71.75,151.96 77.18,146.53 77.87,146.53 82.04,142.37 82.04,140.59 84.3,138.33 84.3,135.05 89.51,129.84 98.22,129.84 98.78,130.4 100.86,130.4 101.7,129.56 107.11,129.56 107.44,129.9 109.82,129.9 110.16,129.56 111.2,129.56 112.62,130.98 112.62,133.52 112.47,133.68 112.2,133.68 112.01,133.49 v1(112.01,133.35)
PCIE21_SLOT2_TX_DP: length 152.7
  TOP w0.088: U6E1.F46 111.66,135.75 111.66,135.2 111.77,135.09 111.77,134.35 v1(112.01,134.11)
  TOP w0.1: v1(53.29,232.12) 53.55,231.87 54.07,231.87 54.22,232.03 C8B29.1
  LAY6 w0.115: v1(53.29,232.12) 53.07,231.9 52.27,231.9 50.44,230.07 50.44,226.22 51.2,225.46 51.2,220.91 51.84,220.28 51.84,216.13 52.6,215.37 52.6,207.17 54.35,205.41 54.35,203.83 55.88,202.31 55.88,192.21 64.13,183.95 64.13,181.99 65.3,180.82 65.3,178.72 66.44,177.58 66.44,173.64 68.04,172.04 68.04,160.04 69.85,158.24 69.85,157.03 71.52,155.35 71.52,151.87 77.08,146.3 77.77,146.3 81.81,142.27 81.81,140.49 84.07,138.23 84.07,134.96 89.41,129.61 98.31,129.61 98.87,130.17 100.76,130.17 101.6,129.33 107.21,129.33 107.54,129.67 109.73,129.67 110.06,129.33 111.3,129.33 112.85,130.88 112.85,133.62 112.56,133.91 112.21,133.91 v1(112.01,134.11)
PCIE22_SLOT2_RX_DN: length 135.9
  TOP w0.1: v1(53.45,224.44) 53.67,224.66 54.12,224.66 54.22,224.56 54.22,224.28 ; U6E1.U40 v1(106.45,139.51)
  LAY6 w0.115: v1(106.45,139.51) 106.54,139.42 107.15,139.42 107.67,138.9 107.67,138.4 108.2,137.86 108.2,137.21 107.69,136.71 107.69,135.44 105.37,133.12 95.04,133.12 94.68,132.76 90.4,132.76 87.27,135.9 87.27,139.03 87.9,139.67 87.9,142.14 84.83,145.22 84.14,145.22 82.95,146.41 82.95,148.01 80.31,150.65 80.31,151.64 79.52,152.43 79.52,153.95 78.29,155.19 76.33,155.19 74.19,157.33 74.19,160.88 72.28,162.79 72.28,174.91 70.1,177.09 70.1,180.59 70.48,180.97 70.48,185.09 61.11,194.46 61.11,203.05 56.13,208.02 56.13,223.32 54.91,224.53 53.54,224.53 v1(53.45,224.44)
PCIE22_SLOT2_RX_DP: length 135.9
  TOP w0.1: v1(53.45,225.27) 53.45,225.06 53.64,224.86 54.07,224.86 54.22,225.01 54.22,225.42 ; v1(106.68,138.78) U6E1.U41
  LAY6 w0.115: v1(106.68,138.78) 106.62,138.84 106.62,139.06 106.75,139.19 107.06,139.19 107.44,138.81 107.44,138.3 107.97,137.77 107.97,137.31 107.46,136.8 107.46,135.53 105.28,133.35 94.94,133.35 94.59,132.99 90.5,132.99 87.5,135.99 87.5,138.94 88.13,139.57 88.13,142.24 84.92,145.45 84.23,145.45 83.18,146.5 83.18,148.11 80.54,150.75 80.54,151.74 79.75,152.53 79.75,154.05 78.38,155.42 76.42,155.42 74.42,157.42 74.42,160.98 72.51,162.88 72.51,175 70.33,177.19 70.33,180.5 70.71,180.88 70.71,185.18 61.34,194.56 61.34,203.14 56.36,208.12 56.36,223.42 55.01,224.76 53.79,224.76 53.45,225.11 v1(53.45,225.27)
PCIE22_SLOT2_RX_R_DN: length 10.4
  TOP w0.1: J7B1.A22 64.11,224.04 63.6,224.04 63.15,223.58 59.47,223.58 58.46,224.59 57.35,224.59 57.2,224.74 55.57,224.74 R8C7.1
PCIE22_SLOT2_RX_R_DP: length 10.4
  TOP w0.1: J7B1.A21 63.17,224.65 63.42,224.39 63.42,224.14 63.07,223.78 59.55,223.78 58.54,224.79 57.43,224.79 57.28,224.94 55.6,224.94 R8C4.1
PCIE22_SLOT2_TX_C_DN: length 5.6
  TOP w0.1: C8C2.2 55.57,227.02 56.58,227.02 57.12,226.48 58.57,226.48 58.85,226.2 58.85,225.83 58.66,225.65 J7B1.B20
PCIE22_SLOT2_TX_C_DP: length 5.6
  TOP w0.1: C8B38.2 55.6,227.22 56.66,227.22 57.21,226.68 58.65,226.68 58.95,226.38 59.74,226.38 J7B1.B19
PCIE22_SLOT2_TX_DN: length 138.8
  TOP w0.088: U6E1.H47 110.31,136 110.18,135.88 110.18,135.52 110.08,135.42 110.08,134.36 v1(109.95,134.24)
  TOP w0.1: v1(53.25,226.72) 53.25,226.84 53.49,227.07 54.09,227.07 54.22,226.94 C8C2.1
  LAY6 w0.115: v1(109.95,134.24) 109.95,134.35 109.81,134.49 109.57,134.49 109.45,134.36 109.45,133.87 109.33,133.76 106.89,133.76 105.74,132.61 95.3,132.61 94.94,132.26 90.19,132.26 86.74,135.71 86.74,139.29 85.97,140.05 85.97,141.6 81.91,145.67 81.91,147.26 79.8,149.37 79.8,150.89 73.53,157.17 73.53,160.65 71.75,162.43 71.75,166.11 71.01,166.85 71.01,174.85 69.34,176.53 69.34,180.72 69.95,181.33 69.95,184.81 66.15,188.61 64.65,188.61 59.56,193.7 59.56,203.83 55.62,207.77 55.62,222.76 54.5,223.88 52.98,223.88 52.19,224.66 52.19,226.75 52.59,227.15 53.01,227.15 53.25,226.91 v1(53.25,226.72)
PCIE22_SLOT2_TX_DP: length 138.8
  TOP w0.088: U6E1.H48 110.26,135.34 110.26,134.56 110.4,134.42 110.4,133.82 v1(110.11,133.53)
  TOP w0.1: C8B38.1 54.22,227.34 54.16,227.27 53.53,227.27 v1(53.25,227.55)
  LAY6 w0.115: v1(53.25,227.55) 53.08,227.38 52.5,227.38 51.96,226.85 51.96,224.57 52.88,223.65 54.41,223.65 55.39,222.66 55.39,207.68 59.33,203.74 59.33,193.6 64.56,188.38 66.05,188.38 69.72,184.71 69.72,181.43 69.11,180.81 69.11,176.43 70.78,174.76 70.78,166.76 71.52,166.02 71.52,162.34 73.3,160.56 73.3,157.07 79.57,150.8 79.57,149.27 81.68,147.17 81.68,145.57 85.74,141.51 85.74,139.96 86.51,139.2 86.51,135.62 90.1,132.03 95.04,132.03 95.39,132.38 105.84,132.38 106.98,133.53 v1(110.11,133.53)
PCIE23_SLOT2_RX_DN: length 125.3
  TOP w0.1: 54.22,219.71 54.33,219.81 54.33,220.14 54.17,220.29 52.98,220.29 52.19,219.51 52.19,213.36 56.06,209.49 57.73,209.49 v1(58.03,209.8) ; U6E1.W43 v1(105.59,138.03)
  LAY6 w0.115: v1(105.59,138.03) 105.59,137.77 105.03,137.21 105.03,135.68 104.17,134.82 93.93,134.82 93.57,134.47 92.1,134.47 90.55,136.01 90.55,142.82 86.2,147.17 85.23,147.17 84.81,147.59 84.81,148.81 83.41,150.21 83.41,152.68 78.63,157.45 76.8,157.45 75.92,158.34 75.92,163.03 75.31,163.65 75.31,164.97 75.54,165.2 75.54,173.63 74.27,174.9 74.27,181.07 72.23,183.1 72.23,185.89 64.26,193.87 64.26,195.58 64.51,195.83 64.51,196.82 63.5,197.84 63.5,205.3 59.29,209.51 58.33,209.51 v1(58.03,209.8)
PCIE23_SLOT2_RX_DP: length 125.3
  TOP w0.1: 54.22,220.85 53.87,220.49 52.9,220.49 51.99,219.59 51.99,213.28 55.97,209.29 57.73,209.29 v1(58.03,208.99) ; U6E1.W44 v1(105.78,137.29)
  LAY6 w0.115: v1(105.78,137.29) 105.43,137.29 105.26,137.11 105.26,135.59 104.26,134.59 94.02,134.59 93.66,134.24 92,134.24 90.32,135.92 90.32,142.72 86.1,146.94 85.14,146.94 84.58,147.5 84.58,148.72 83.18,150.11 83.18,152.58 78.54,157.22 76.7,157.22 75.69,158.24 75.69,162.94 75.08,163.55 75.08,165.07 75.31,165.3 75.31,173.54 74.04,174.81 74.04,180.97 72,183.01 72,185.8 64.03,193.78 64.03,195.67 64.28,195.93 64.28,196.73 63.27,197.74 63.27,205.21 59.19,209.28 58.33,209.28 v1(58.03,208.99)
PCIE23_SLOT2_RX_R_DN: length 10.5
  TOP w0.1: R8C18.1 55.57,220.17 56.84,220.17 57.2,220.52 58.59,220.52 59.53,219.58 63.15,219.58 63.6,220.04 64.11,220.04 J7B1.A26
PCIE23_SLOT2_RX_R_DP: length 10.5
  TOP w0.1: J7B1.A25 63.17,220.65 63.42,220.39 63.42,220.14 63.07,219.78 59.61,219.78 58.67,220.72 57.12,220.72 56.76,220.37 55.6,220.37 R8C15.1
PCIE23_SLOT2_TX_C_DN: length 5.3
  TOP w0.1: C8C11.2 55.6,222.48 58.57,222.48 58.82,222.22 58.82,221.8 58.66,221.65 J7B1.B24
PCIE23_SLOT2_TX_C_DP: length 5.3
  TOP w0.1: J7B1.B23 59.74,222.38 58.95,222.38 58.65,222.68 55.57,222.68 C8C8.2
PCIE23_SLOT2_TX_DN: length 139.8
  TOP w0.088: v1(112.01,131.06) 112.01,131.27 111.85,131.43 111.59,131.43 111.39,131.63 111.39,133 111.11,133.28 111.11,134.73 U6E1.G49
  TOP w0.1: C8C11.1 54.22,222.24 54.12,222.34 52.41,222.34 52.4,222.34 52.36,222.34 v1(52.05,222.03)
  LAY6 w0.115: v1(52.05,222.03) 52.05,222.16 52.16,222.27 52.48,222.27 52.6,222.15 52.6,216.44 53.89,215.14 53.89,206.96 55.11,205.74 55.11,204.21 56.64,202.69 56.64,193.29 66.16,183.77 66.16,178.94 67.33,177.77 67.33,175.54 69.31,173.56 69.31,164.93 69.87,164.37 69.87,162.91 69.36,162.4 69.36,159.92 70.89,158.4 70.89,157.13 72.47,155.54 72.47,153.51 74.73,151.26 76.32,151.26 76.73,150.85 76.73,147.8 77.31,147.22 77.95,147.22 82.67,142.49 82.67,140.77 84.83,138.61 84.83,135.23 89.71,130.35 97.79,130.35 98.34,130.91 109.83,130.91 110.06,130.68 110.74,130.68 111.44,131.38 111.85,131.38 112.01,131.21 v1(112.01,131.06)
PCIE23_SLOT2_TX_DP: length 139.8
  TOP w0.088: U6E1.G48 111.22,135.32 111.22,134.88 111.3,134.81 111.3,133.36 111.58,133.08 111.58,131.71 111.67,131.62 111.8,131.62 v1(112.01,131.82)
  TOP w0.1: v1(52.05,222.85) 52.36,222.54 52.49,222.54 52.49,222.54 53.99,222.54 54.22,222.77 C8C8.1
  LAY6 w0.115: v1(52.05,222.85) 52.4,222.5 52.57,222.5 52.83,222.25 52.83,216.53 54.12,215.24 54.12,207.05 55.34,205.83 55.34,204.31 56.87,202.79 56.87,193.39 66.39,183.86 66.39,179.04 67.56,177.87 67.56,175.64 69.54,173.66 69.54,165.02 70.1,164.46 70.1,162.81 69.59,162.3 69.59,160.02 71.12,158.49 71.12,157.22 72.7,155.64 72.7,153.6 74.82,151.49 76.42,151.49 76.96,150.95 76.96,147.9 77.41,147.45 78.04,147.45 82.9,142.59 82.9,140.87 85.06,138.71 85.06,135.33 89.81,130.58 97.69,130.58 98.25,131.14 109.93,131.14 110.16,130.91 110.64,130.91 111.34,131.61 111.8,131.61 v1(112.01,131.82)
PCIE24_SLOT2_RX_DN: length 119.5
  TOP w0.1: v1(58.03,211.89) 57.73,211.58 54.99,211.58 52.95,213.61 52.95,215.15 53.52,215.72 54.15,215.72 54.33,215.54 54.33,215.24 54.22,215.14 ; U6E1.Y40 v1(105.2,139.51)
  LAY6 w0.115: v1(105.2,139.51) 105.2,139.24 104.29,138.33 104.29,136.24 103.61,135.56 93.62,135.56 93.26,135.2 92.51,135.2 91.31,136.4 91.31,143.89 87.5,147.7 87.5,148.97 85.09,151.38 85.09,152.09 78.93,158.24 77.16,158.24 76.7,158.69 76.7,160.65 77.34,161.29 77.34,163.8 76.55,164.58 76.55,165.77 77.06,166.27 77.06,168.37 76.32,169.11 76.32,174.06 75.33,175.05 75.33,181.27 73,183.61 73,188.05 66.54,194.51 66.54,195.83 64.26,198.12 64.26,206.44 59.12,211.58 58.34,211.58 v1(58.03,211.89)
PCIE24_SLOT2_RX_DP: length 119.5
  TOP w0.1: U6E1.Y41 v1(105.39,138.77) ; v1(58.03,211.07) 57.73,211.38 54.9,211.38 52.75,213.53 52.75,215.24 53.44,215.92 53.87,215.92 54.22,216.28
  LAY6 w0.115: v1(58.03,211.07) 58.31,211.35 59.03,211.35 64.03,206.35 64.03,198.02 66.31,195.74 66.31,194.41 72.77,187.96 72.77,183.51 75.1,181.18 75.1,174.96 76.09,173.96 76.09,169.01 76.83,168.27 76.83,166.37 76.32,165.86 76.32,164.49 77.11,163.7 77.11,161.38 76.47,160.75 76.47,158.6 77.06,158.01 78.84,158.01 84.86,151.99 84.86,151.29 87.27,148.87 87.27,147.6 91.08,143.79 91.08,136.3 92.41,134.97 93.36,134.97 93.72,135.33 103.71,135.33 104.52,136.14 104.52,138.23 105.06,138.77 v1(105.39,138.77)
PCIE24_SLOT2_RX_R_DN: length 10.7
  TOP w0.1: R8C24.1 55.57,215.59 56.71,215.59 57.61,216.49 58.69,216.49 59.59,215.58 63.15,215.58 63.6,216.04 64.11,216.04 J7B1.A30
PCIE24_SLOT2_RX_R_DP: length 10.7
  TOP w0.1: R8C22.1 55.6,215.79 56.63,215.79 57.52,216.69 58.77,216.69 59.67,215.78 63.07,215.78 63.42,216.14 63.42,216.39 63.17,216.65 J7B1.A29
PCIE24_SLOT2_TX_C_DN: length 5.6
  TOP w0.1: C8C15.2 55.57,217.88 56.67,217.88 57.27,218.48 58.57,218.48 58.85,218.2 58.85,217.83 58.66,217.65 J7B1.B28
PCIE24_SLOT2_TX_C_DP: length 5.6
  TOP w0.1: C8C13.2 55.6,218.08 56.59,218.08 57.19,218.68 58.65,218.68 58.95,218.38 59.74,218.38 J7B1.B27
PCIE24_SLOT2_TX_DN: length 131
  TOP w0.088: U6E1.G46 111.11,136.39 111,136.28 111,136.06 110.88,135.94 110.88,135.21 110.7,135.03 110.7,134.72 110.82,134.6 110.82,133.02 110.95,132.89 110.95,132.04 v1(110.46,131.55)
  TOP w0.1: C8C15.1 54.22,217.68 54.04,217.86 53.61,217.86 v1(53.34,217.58)
  LAY6 w0.115: v1(110.46,131.55) 110.36,131.65 95.7,131.65 95.27,131.21 89.89,131.21 85.72,135.38 85.72,138.87 83.43,141.15 83.43,142.75 80.89,145.29 80.89,146.68 78.1,149.48 78.1,151.06 72.41,156.75 72.41,160.3 70.78,161.93 70.78,165.61 70.05,166.35 70.05,173.97 68.09,175.93 68.09,178.31 67.08,179.32 67.08,182.08 67.69,182.7 67.69,185.6 66.85,186.43 65.46,186.43 58.57,193.32 58.57,203.36 54.63,207.29 54.63,217.2 54,217.83 53.58,217.83 v1(53.34,217.58)
PCIE24_SLOT2_TX_DP: length 131
  TOP w0.088: v1(110.46,132.31) 110.59,132.31 110.76,132.48 110.76,132.81 110.63,132.94 110.63,134.52 110.51,134.64 110.51,135.11 110.69,135.29 110.69,136.02 110.81,136.14 110.81,136.81 U6E1.G45
  TOP w0.1: v1(53.34,218.41) 53.69,218.06 54.07,218.06 54.22,218.21 C8C13.1
  LAY6 w0.115: v1(110.46,132.31) 110.46,132.21 110.13,131.88 95.61,131.88 95.18,131.44 89.98,131.44 85.95,135.48 85.95,138.96 83.66,141.25 83.66,142.85 81.12,145.39 81.12,146.78 78.33,149.57 78.33,151.15 72.64,156.84 72.64,160.4 71.01,162.03 71.01,165.71 70.28,166.45 70.28,174.07 68.32,176.02 68.32,178.4 67.31,179.42 67.31,181.99 67.92,182.6 67.92,185.7 66.95,186.66 65.55,186.66 58.8,193.42 58.8,203.45 54.86,207.39 54.86,217.3 54.1,218.06 53.69,218.06 v1(53.34,218.41)
PCIE_SLOT2_B12: length 2.9
  TOP w0.1: J7B1.B12 57.97,233.68 R8B27.2
PCIE_SLOT2_PRSNT2_N: length 19.8
  TOP w0.1: R8C29.2 57.15,213.99 57.8,214.65 J7B1.B31
  BOTTOM w0.1: J7B1.B31 60.83,215.47 60.83,227.82 J7B1.B17
PCIE_SLOT2_PWREN_R: length 42.6
  TOP w0.1: U8B2.2 50.92,229.24 50.16,228.47 49.78,228.47 49.53,228.22 R8B40.2 R8C1.1 R8C2.2 v1(49.53,225.42) ; EU8B1.3 56.53,257.67 v1(56.76,257.43) 56.5,257.17 EU8B1.2
  BOTTOM w0.1: v1(56.76,257.43) 56.76,252.73 53.34,249.3 53.34,241.68 52.42,240.76 52.42,236.06 49.02,232.66 49.02,230.5 48.51,230 48.51,226.44 v1(49.53,225.42)
PCIE_SLOT2_RST_N: length 26.1
  TOP w0.1: v1(81.02,235.2) 81.91,235.2 83.31,236.6 R7B61.2 R7B56.2 R7B53.1
  LAY5 w0.125: v1(81.02,235.2) 78.1,235.2 75.94,237.36 v1(72.39,237.36)
  LAY6 w0.125: J7B1.A11 63.05,236.1 71.12,236.1 v1(72.39,237.36)
PCIE_SLOT2_RST_R_N: length 2
  TOP w0.1: 87.05,237.61 85.22,237.61 R7B56.1
PCIE_SLOT2_SR: length 2.3
  TOP w0.28: C8B27.1 49.78,232.41 50.92,231.26 U8B2.7
PCIE_SLOT3_B12: length 37.7
  TOP w0.1: R8C30.2 47.11,212.47 47.11,211.71 46.48,211.07 44.83,211.07 v1(44.19,211.71) ; J8B1.B12 40.03,233.65 40.51,233.17 41.52,233.17 42.03,233.68 43.05,233.68 43.81,234.44 44.45,234.44 44.89,234 v1(45.14,234) R8B28.2
  BOTTOM w0.1: v1(45.14,234) 45.65,233.49 45.65,212.41 44.95,211.71 v1(44.19,211.71)
PCIE_SLOT3_PRSNT2_N: length 21.6
  TOP w0.1: R8C28.2 45.33,214.37 43.68,214.37 42.54,215.52 40.56,215.52 J8B1.B31
  LAY6 w0.125: J8B1.B31 40.44,215.4 40.44,227.89 J8B1.B17
PCIE_SLOT3_PWREN_R: length 36.8
  TOP w0.1: v1(27.63,228.6) 28.01,228.22 R8B41.2 R8B39.1 R8B42.2 30.09,228.47 29.84,228.73 28.82,228.73 28.45,229.1 U8B1.2 ; EU8B4.3 32.75,253.89 v1(32.51,254.13) 32.77,254.39 EU8B4.2
  LAY6 w0.125: v1(27.63,228.6) 27.63,229.54 26.79,230.38 26.79,233.16 28.46,234.82 28.46,236.69 27.08,238.07 27.08,239.19 30.1,242.22 30.1,243.83 31.11,244.84 31.11,247.65 33.02,249.55 33.02,253.62 v1(32.51,254.13)
PCIE_SLOT3_RST_N: length 54.8
  TOP w0.1: R8C43.2 R8C48.1 R8C51.2 v1(28.82,205.74)
  LAY5 w0.125: J8B1.A11 42.67,236.16 42.67,234.31 40.25,231.9 39.24,231.9 38.48,232.66 37.21,232.66 33.65,229.11 31.62,229.11 29.46,231.27 27.17,231.27 23.11,227.2 v1(23.11,226.69)
  BOTTOM w0.1: v1(28.82,205.74) 28.44,205.74 26.03,208.15 26.03,212.6 24.7,213.93 24.7,216.47 23.49,217.68 23.49,226.31 v1(23.11,226.69)
PCIE_SLOT3_RST_R_N: length 1.4
  TOP w0.1: U9C2.4 26.86,206.44 27.17,206.75 R8C43.1
PCIE_SLOT3_SR: length 2.5
  TOP w0.25: C8B26.1 28.16,232.43 28.16,231.52 28.45,231.24 U8B1.7
PCIEX4_SLOT2_PRSNT2_R_N: length 55.7
  TOP w0.1: R8C9.2 33.14,219.71 33.78,219.71 34.16,219.33 Q8C2.2 34.16,217.11 36.54,214.73 38.57,214.73 39.43,213.87 42,213.87 43.4,212.47 v1(43.43,212.47) ; v1(53.46,233.93) 53.72,233.68 R8B27.1 ; R8C29.1 v1(53.41,213.99)
  BOTTOM w0.1: v1(43.43,212.47) 42.79,211.83 42.77,211.83 42.67,211.73 42.67,210.18 43.3,209.55 47.11,209.55 49.53,211.96 52.7,211.96 53.41,212.67 v1(53.41,213.99) 53.59,213.99 54.22,214.63 54.22,232.66 53.46,233.42 v1(53.46,233.93)
PCIEX4_SLOT3_PRSNT2_R_N: length 53.2
  TOP w0.1: R8B28.1 v1(47.37,233.42) ; R8C28.1 47.37,213.23 47.37,211.58 46.63,210.85 44.29,210.85 v1(43.43,211.71) 42.92,212.22 42.92,212.62 41.91,213.64 39.34,213.64 38.48,214.5 36.44,214.5 34.67,216.28 32.25,216.28 30.73,217.8 Q8C1.2 30.73,221.74 R8C12.2
  BOTTOM w0.1: v1(43.43,211.71) 44.19,210.95 44.95,210.95 45.88,211.87 45.88,231.94 v1(47.37,233.42)
PCIEX16_PRSNT1_N: length 4.2
  TOP w0.38: J5B2.A1 145.8,248.66 R5B16.1
PCIEX16_PRSNT2_N: length 78
  TOP w0.1: J5B2.B17 138.99,228.65 138.43,228.09 138.43,223.65 136.77,221.99 R5C5.2 137.35,220.79 139.76,220.79 140.84,219.71 141.6,219.71 142.36,218.95 142.36,215.9 141.28,214.82 J5B2.B31
  LAY6 w0.125: J5B2.B31 142.24,213.7 142.24,200.28 141.6,199.64 140.84,199.64 139.28,198.09 J5B2.B48 141.68,197.65 142.49,196.85 142.49,166.37 141.28,165.16 J5B2.B81
