# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMB_DATA_MAIN_FRU: length 23.2
  TOP w0.1: v1(58.8,22.73) U8J2.5 62.1,22.73 62.61,22.22 64.51,22.22 64.64,22.35 R7J14.2
  LAY6 w0.125: v1(58.8,22.73) 59.44,22.09 59.44,10.42 58.54,9.52 58.54,8.09 J8J13.35
SMB_DATA_RESUME: length 765
  TOP w0.1: v1(93.09,230.5) 92.07,230.5 90.42,228.85 88.51,228.85 88.01,228.34 R7B81.2 86.29,227.84 Q7B10.3 ; R7E23.1 70.48,145.92 69.84,145.29 C7E11.2 69.24,145.29 v1(68.58,144.63) ; J7B1.B6 57.26,241.65 56.18,240.56 51.53,240.56 51.18,240.92 47.62,240.92 47.11,240.41 43.56,240.41 42.54,241.43 38.48,241.43 37.97,240.92 37.33,240.92 36.37,241.88 28.35,241.88 26.22,239.74 26.22,239.2 25.65,238.63 25.01,238.63 R9B29.1 ; v1(82.17,62.36) 78.9,62.36 R7H12.1
  LAY5 w0.125: v1(78.86,98.3) 77.97,98.3 75.18,101.09 68.58,101.09 68.07,101.6 67.05,101.6 66.13,102.52 66.13,111.12 61.59,115.66 61.59,129.67 64.17,132.24 64.8,132.24 67.2,134.64 67.2,143.25 v1(68.58,144.63) 68.58,145.66 68.31,145.92 68.31,152.39 69.31,153.39 69.31,159.79 68.83,160.27 68.83,164.65 68.66,164.81 68.66,165.76 68.07,166.36 68.07,167.89 67.69,168.27 67.69,172.85 68.07,173.23 68.07,176.28 69.72,177.93 69.72,180.85 69.85,180.97 69.85,190.68 71.42,192.25 71.42,194.92 73.27,196.77 73.27,219.33 68.51,224.09 67.5,224.09 64.89,226.69 63.88,226.69 62.99,227.58 59.69,227.58 58.67,228.6 57.4,228.6 56.64,229.36 56.64,234.06 58.8,236.22 58.8,240.85 J7B1.B6 ; v1(213.97,45.34) 213.97,45.78 211.09,48.65 205.55,48.65 204.63,47.73 202,47.73 196.34,42.07 188.03,42.07 185.38,39.42 176.27,39.42 172.73,35.88 169.6,35.88 168.28,34.55 168.28,30.43 167.6,29.75 167.6,24.03 152.06,8.5 146.29,8.5 144.78,6.98 118.88,6.98 117.34,8.52 113.47,8.52 113.21,8.26 111.9,8.26 111.4,8.76 110.61,8.76 110.36,8.51 110.36,8.25 110.1,8 109.6,8 108.83,8.76 103.9,8.76 103.78,8.89 100.6,8.89 98.94,10.55 86.49,10.55 v1(84.83,8.89) 83.84,8.89 81.22,6.27 71.89,6.27 71.44,6.72 69.33,6.72 65.82,3.22 41.12,3.22 40.18,4.15 11.33,4.15 8.63,6.86 v1(5.96,6.86) ; J5B2.B6 139.16,241.65 136.02,238.51 136.02,235.97 131.31,231.27 130.58,231.27 129.05,229.74 118.99,229.74 117.85,230.88 116.35,230.88 113.56,233.67 108.55,233.67 104.19,229.31 104.19,228.78 103.25,227.84 100.35,227.84 98.58,229.61 93.98,229.61 v1(93.09,230.5) 86.86,230.5 85.47,231.9 83.88,231.9 81.11,234.67 77.49,234.67 76.07,236.09 73.78,236.09 73.15,236.73 71.37,236.73 v1(68.96,239.14)
  LAY6 w0.125: v1(68.96,239.14) 67.81,240.28 67.81,245.5 66.2,247.11 64.38,247.11 63.5,246.23 63.5,242.31 62.83,241.65 J7B1.B6 ; J9F6.3 9.52,95.12 9.52,76.83 10.28,76.07 10.28,75.56 9.72,75 9.72,70.33 9.39,70 9.39,63.83 8.58,63.02 8.58,56.52 8.23,56.16 8.23,49.3 8.5,49.02 8.5,27.18 6.47,25.14 6.47,7.36 v1(5.96,6.86) ; v1(84.83,8.89) 84.83,11.17 82.16,13.84 82.16,17.26 83.7,18.79 83.7,20.19 82.81,21.08 82.81,35.93 80.78,37.96 80.78,43.4 80.13,44.05 80.13,47.44 81.25,48.56 81.25,54.48 82.3,55.53 82.3,62.23 v1(82.17,62.36) 81.95,62.58 81.95,71.38 80.99,72.33 80.99,76.07 82.29,77.37 82.29,78.84 81.88,79.25 81.88,83.72 81.16,84.44 81.16,94.6 78.48,97.28 78.48,97.92 v1(78.86,98.3)
SMB_DATA_RESUME_R: length 19.6
  TOP w0.089: U6E1.BF26 91.98,146.22 88.07,146.22 87.92,146.07 83.88,146.07 83.73,145.92 83.59,145.92 83.11,145.44 82.14,145.44 81.8,145.78
  TOP w0.1: 81.8,145.78 76.04,145.78 75.89,145.92 R7E23.2
SMB_DATA_TTK: length 3.1
  TOP w0.1: J7G1.25 77.25,64.9
SMB_HDMI_CLK: length 4.8
  TOP w0.1: EU2A7.29 252.76,266.53 252.47,266.83 R2A42.2 251.58,267.21 251.46,267.33 249.68,267.33 R2A39.2
SMB_HDMI_DATA: length 5.1
  TOP w0.1: R2A38.2 249.68,268.35 251.46,268.35 251.58,268.22 R2A40.2 251.96,267.84 252.87,266.93 EU2A7.28
SMB_USBC_CLK_EC: length 177.9
  TOP w0.1: v1(126.07,20.78) J6J2.89 ; R8G23.2 30.35,88.77 29.62,89.5 v1(29.62,89.66) U8F6.91 ; v1(39.09,90.68) 39.11,90.65 Q8G2.3
  LAY3 w0.1: v1(126.07,20.78) 124.63,22.22 121.53,22.22 121.12,21.81 115.85,21.81 115.25,21.21 114.59,21.21 114.11,21.69 112.73,21.69 111.44,22.99 106.44,22.99 105.26,24.17 103.78,24.17 102.39,25.56 101.43,25.56 99.7,27.29 97.01,27.29 96.66,26.94 89.51,26.94 88.91,27.54 82.05,27.54 81.35,26.84 77.85,26.84 77.16,26.15 71.35,26.15 70.98,26.51 65.12,26.51 64.42,25.82 62.89,25.82 56.22,32.49 52.61,32.49 51.11,33.99 47.2,33.99 45.62,35.57 36.23,35.57 32.66,39.14 31.67,39.14 30.43,40.38 30.43,41.37 25.52,46.28 25.52,49.53 22.98,52.07 22.98,59.67 27.18,63.86 27.18,71.65 29.08,73.55 29.08,80.64 28.86,80.86 28.86,84.35 27.55,85.65 27.55,87.6 v1(29.62,89.66)
  BOTTOM w0.1: v1(39.09,90.68) 38.58,91.18 36.06,91.18 34.54,89.66 v1(29.62,89.66)
SMB_USBC_DATA_EC: length 184.4
  TOP w0.1: U8F6.89 v1(28.82,89.66) 28.82,89.41 29.46,88.77 R8G22.2 ; Q8G3.3 v1(41.91,89.98) ; J6J2.97 v1(126.31,19.76)
  LAY3 w0.1: v1(28.82,89.66) 27.08,87.92 27.08,85.46 28.38,84.15 28.38,80.67 28.56,80.49 28.56,73.71 26.7,71.85 26.7,68.14 21.5,62.93 21.5,58.64 22.36,57.78 22.36,51.75 23.28,50.83 23.28,47.85 29.95,41.17 29.95,38.23 31.93,36.26 34.87,36.26 36.03,35.1 45.42,35.1 47,33.52 50.91,33.52 52.42,32.01 56.02,32.01 62.69,25.34 63.81,25.34 64.41,24.74 66.64,24.74 66.81,24.91 75.83,24.91 76.36,25.45 80.95,25.45 82.34,26.84 88.59,26.84 89.19,26.24 96.82,26.24 97.28,25.78 97.79,25.78 98.71,24.85 102.1,24.85 104.66,22.29 111.15,22.29 112.44,20.99 113.82,20.99 114.52,20.29 125.78,20.29 v1(126.31,19.76)
  BOTTOM w0.1: v1(41.91,89.98) 40.7,89.98 39.02,91.66 35.87,91.66 34.34,90.14 29.29,90.14 v1(28.82,89.66)
SMC_RST_EC_N: length 245
  TOP w0.1: J9F4.1 6.98,115.82 10.03,115.82 11.04,114.81 R9F10.1 11.68,111.38 12.44,111.38 13.33,112.27 13.33,113.66 17.14,117.47 v1(19.93,117.47) ; v1(25.14,104.77) 26.28,104.77 26.82,105.31 U8F6.13 26.82,106.96 28.32,108.46 C8F10.1 R8F25.2 ; J6J2.70 v1(121.23,13.41)
  LAY3 w0.1: v1(25.14,104.77) 26.12,103.79 26.12,100.85 25.51,100.23 25.2,100.23 23.93,98.97 23.93,97.65 19.61,93.33 19.61,85.03 17.57,82.98 17.57,75.34 14.69,72.46 14.69,61.78 11.34,58.42 11.34,51.61 13.55,49.39 13.55,39.95 14.67,38.83 19.58,38.83 20.12,38.29 20.12,34.7 20.88,33.94 21.58,33.94 22.68,32.84 22.68,31.31 27.05,26.95 27.05,25.02 29.87,22.2 55.9,22.2 56.54,21.56 57.72,21.56 59.64,19.64 63.7,19.64 65.48,17.86 68.5,17.86 68.81,18.16 71.87,18.16 72.81,19.11 84.42,19.11 85.78,17.75 88.9,17.75 89.76,18.61 98.16,18.61 99.68,17.09 105.82,17.09 106.4,17.66 107,17.66 109.34,15.32 109.34,14.86 109.89,14.31 109.89,13.93 111.12,12.7 112.39,12.7 112.9,12.19 117.6,12.19 118.11,12.7 120.52,12.7 v1(121.23,13.41)
  BOTTOM w0.1: v1(25.14,104.77) 25.14,106.44 22.49,109.09 21.08,109.09 19.81,110.36 19.81,113.03 18.92,113.92 18.92,116.46 v1(19.93,117.47)
SMC_RST_N: length 13.7
  TOP w0.1: R9F10.2 11.93,112.39 11.55,112.77 11.55,113.32 14.02,115.79 14.02,116.36 17.29,119.63 20.44,119.63 R9F2.2
SMC_RUNTIME_SCI_EC_N: length 370.1
  TOP w0.1: v1(20.32,100.96) 19.43,100.96 18.9,101.49 U8F6.41 ; v1(107.18,104.39) R6F32.1 ; v1(127.33,10.41) 127.33,12.15 J6J2.103
  LAY3 w0.1: v1(20.32,100.96) 19.61,100.26 19.61,95.91 16.07,92.38 16.07,88.08 15.11,87.12 15.11,86.23 11.27,82.39 11.27,71.1 9.61,69.44 9.61,50.89 11.54,48.96 11.54,38.42 20.27,29.68 20.27,19.86 26.33,13.79 57.53,13.79 57.98,13.33 66.92,13.33 69.67,16.08 71.12,16.08 71.7,15.49 82.55,15.49 83.13,16.08 84.5,16.08 85.7,14.88 105.96,14.88 112.1,8.73 117.6,8.73 118.11,9.24 124.88,9.24 126.05,10.41 v1(127.33,10.41)
  LAY5 w0.125: v1(20.32,100.96) 21.28,99.99 21.28,95 20.5,94.22 20.5,91.57 19.8,90.86 19.8,84.71 20.85,83.66 20.85,81.25 19.68,80.09 19.68,70.79 20.2,70.27 20.2,62.39 22.65,59.95 25.31,59.95 28.36,56.89 41.86,56.89 47.97,63.01 51.95,63.01 52.39,62.57 59.25,62.57 61.83,65.15 67.2,65.15 67.84,64.52 68.55,64.52 69.19,65.15 70.58,65.15 70.84,65.4 72.26,65.4 75.42,68.57 81.26,68.57 85.97,73.28 85.97,75.79 89.37,79.19 90.56,79.19 92.26,80.88 94.38,80.88 107.44,93.94 107.44,102.61 106.8,103.25 106.8,104.01 v1(107.18,104.39)
SMC_RUNTIME_SCI_N: length 31.4
  TOP w0.089: 106.5,128.69 105.71,129.48 105.71,135.27 105.8,135.36 105.8,135.65 106.03,135.89 U6E1.U47
  TOP w0.1: R6F32.2 107.41,106.53 107.41,112.37 R6F12.2 108.36,113.31 108.36,121.19 107.82,121.73 107.82,127.38 106.5,128.69
SMC_SHUTDOWN: length 17.1
  TOP w0.1: R6J4.2 123.57,21.99 v1(123.31,21.74) ; J6J2.143 v1(132.66,13.16)
  LAY6 w0.125: v1(132.66,13.16) 132.66,15.03 131.9,15.8 131.9,17.07 131.21,17.75 126,17.75 124.58,19.18 124.58,20.47 v1(123.31,21.74)
SMC_WAKE_SCI_N: length 231.5
  TOP w0.1: J6J2.111 v1(127.58,13.16) ; R9F35.1 12.7,99.82 12.7,99.22 12.72,99.25 15.04,99.25 15.36,98.93 R9F36.2 15.64,98.8 v1(16.28,99.44) 16.28,99.47 16.7,99.89 U8F6.45
  LAY3 w0.1: v1(130.04,8.25) 129.48,7.69 129.48,6.65 128.01,5.17 115.47,5.17 114.42,6.22 112.29,6.22 111.63,5.57 104.43,5.57 102.74,3.88 91.07,3.88 88.99,1.8 62.39,1.8 58.62,5.57 45.06,5.57 J8J13.19
  LAY6 w0.125: J8J13.19 39.33,2.92 24.63,2.92 16.38,11.17 16.38,21.33 13.97,23.75 13.97,27.22 12.7,28.5 12.7,33.4 13.01,33.71 13.01,60.89 13.97,61.85 13.97,65.39 14.71,66.13 14.71,72.76 15.88,73.93 15.88,81.33 16.41,81.86 16.41,83.94 15.62,84.73 15.62,85.32 16.27,85.97 16.27,88.95 15.75,89.47 15.75,98.91 v1(16.28,99.44)
  LAY8 w0.1: v1(127.58,13.16) 127.81,12.94 127.81,9.58 128.37,9.02 129.28,9.02 v1(130.04,8.25)
SML0_CLK: length 384.5
  TOP w0.089: U6E1.BF25 91.56,146.41 87.99,146.41 87.84,146.26 83.8,146.26 83.69,146.15 82.7,146.15 v1(82.42,145.87)
  TOP w0.1: R5B12.1 R5B11.1 153.03,257.17 v1(152.4,256.54) ; v1(179.95,260.73) 180.84,261.62 R4A23.1 ; v1(61.21,20.11) 60.5,20.11 R8J16.1 R8J15.2
  LAY5 w0.125: v1(68.19,94.23) 68.45,94.23 69.92,95.7 80.23,95.7 80.94,96.41 80.94,97.46 80.36,98.05 80.36,98.82 79.92,99.26 78.59,99.26 76.07,101.78 76.07,108.33 74.8,109.6 74.8,111.72 75.41,112.34 75.41,117.79 76.75,119.12 77.85,119.12 81.07,122.35 81.07,125.96 81.66,126.55 81.66,132.33 80.52,133.47 80.52,135.21 83.18,137.87 83.18,145.11 v1(82.42,145.87) 83.29,146.74 83.29,152.09 85.87,154.67 85.87,160.3 88.4,162.82 88.4,170.24 85.72,172.91 85.72,192.03 88.77,195.07 88.77,196.59 86.67,198.69 86.67,201.99 v1(84.83,203.83) ; v1(84.32,250.82) 84.92,250.23 89.84,250.23 89.9,250.17 96.26,250.17 96.53,250.44 97.15,250.44 97.84,249.75 103.24,249.75 103.73,249.26 110.97,249.26 111.81,248.42 115.92,248.42 116.34,248.84 124.97,248.84 127.21,251.09 129.23,251.09 130.58,252.44 133.41,252.44 136.52,255.55 145.93,255.55 146.7,256.31 150.05,256.31 150.82,257.08 151.85,257.08 v1(152.4,256.54) 152.89,256.04 157.78,256.04 158.92,257.18 160.09,257.18 161.28,258.36 163.31,258.36 163.68,258.74 172.31,258.74 175.33,261.75 178.93,261.75 v1(179.95,260.73)
  LAY6 w0.125: v1(68.19,94.23) 67.69,93.72 67.69,93.22 66.23,91.77 66.23,87.93 66.65,87.52 66.65,75.03 65.74,74.12 65.74,69.81 61.68,65.76 61.68,64.94 60.53,63.79 60.53,62.5 63.5,59.53 63.5,57.78 63.65,57.63 63.65,55.35 63.88,55.12 63.88,52.07 63.61,51.81 63.61,42.35 61.6,40.34 61.6,20.5 v1(61.21,20.11) ; v1(84.32,250.82) 84.7,250.44 84.7,240.16 82.87,238.32 82.87,236.91 84.07,235.71 84.07,222.97 84.48,222.56 84.48,204.18 v1(84.83,203.83)
SML0_CLK_FOX_LAN: length 173.6
  TOP w0.1: R5B12.2 153.79,258.82 152.96,259.66 v1(152.96,261.36) ; v1(33.04,243.97) 33.55,243.46 R8B15.1 ; R7B14.2 96.39,253.52 v1(96.01,253.9) 95.47,254.43 95.47,255.34 95.88,255.75 EU7A3.11
  LAY5 w0.125: v1(152.96,261.36) 152.65,261.67 152.65,262.56 152.34,262.86 150.02,262.86 148.62,261.46 140.42,261.46 139.56,260.6 132.26,260.6 128.13,256.47 126.99,256.47 126.09,257.37 125.78,257.37 124.3,258.86 115.9,258.86 115.55,258.5 109.77,258.5 107.38,256.11 102.46,256.11 100.83,257.73 100.15,257.73 99.06,258.82 92.45,258.82 90.55,256.92 85.21,256.92 v1(84.96,256.67) 83.49,258.13 77.75,258.13 75.14,260.75 75.14,263.45 74.46,264.13 69.56,264.13 68.12,262.69 64.76,262.69 64,261.92 43.9,261.92 43.09,261.11 v1(39.11,261.11)
  LAY6 w0.125: v1(33.04,243.97) 33.74,243.97 35.18,245.41 35.18,246.12 36.71,247.65 36.71,248.67 40.89,252.86 40.89,259.71 39.49,261.11 v1(39.11,261.11)
  BOTTOM w0.1: v1(96.01,253.9) 94.33,252.22 92.2,252.22 91.74,252.68 91.74,254.71 90.17,256.28 88.39,256.28 87.63,255.52 85.21,255.52 84.96,255.78 v1(84.96,256.67)
SML0_CLK_LAN: length 2.6
  TOP w0.1: R4A23.2 182.62,261.62 182.84,261.4 182.84,261.02 183.72,260.14 EU4B1.28
SML0_CLK_TR: length 7.5
  TOP w0.1: R5A39.1 152.65,264.54 152.65,262 152.47,261.82 152.47,260.93 152.31,260.78 152.31,259.79 153.03,259.08 R5B11.2
SML0_DATA: length 369.1
  TOP w0.089: U6E1.BE24 92.26,147.38 92.19,147.46 91.88,147.46 91.8,147.38 88.27,147.38 88.15,147.5 85.68,147.5 85.38,147.8 v1(85.38,147.83)
  TOP w0.1: v1(61.34,17.91) 61.34,17.14 R8J17.2 R8J18.1 ; R5B9.1 R5B10.1 152.27,257.3 v1(151.51,256.54) ; v1(179.95,259.84) 180.72,259.08 R4B1.1
  LAY5 w0.125: v1(97.05,249.6) 97.23,249.42 103.1,249.42 103.59,248.93 110.83,248.93 111.67,248.09 116.07,248.09 116.49,248.52 125.11,248.52 127.36,250.76 129.38,250.76 130.73,252.11 133.55,252.11 136.66,255.22 146.08,255.22 146.83,255.98 150.95,255.98 v1(151.51,256.54) 152.34,255.71 157.92,255.71 159.06,256.85 160.23,256.85 161.41,258.03 163.45,258.03 163.82,258.4 172.45,258.4 174.65,260.6 179.19,260.6 v1(179.95,259.84) ; v1(92.32,193.8) 91.18,192.66 90.17,192.66 88.26,190.75 88.26,178.81 91.21,175.87 91.21,161.57 89.4,159.77 89.4,152.27 85.35,148.22 85.35,147.85 v1(85.38,147.83) 85.38,147.8 85.84,147.34 85.84,143.38 85.34,142.87 85.34,137.03 84.2,135.89 84.2,131.95 82.55,130.3 82.55,126.97 81.4,125.82 81.4,120.11 80.01,118.72 80.01,112.54 81.53,111.02 81.53,101.85 81.03,101.36 81.03,97.84 81.27,97.61 81.27,96.27 80.37,95.38 74.16,95.38 73.27,94.49 69.46,94.49 68.45,93.47 v1(68.19,93.47)
  LAY6 w0.125: v1(61.34,17.91) 62.1,18.67 62.1,40.13 64.11,42.15 64.11,51.6 64.51,52 64.51,52.45 65.02,52.96 65.02,55.62 64.77,55.88 64.77,58.16 64,58.93 64,59.5 60.87,62.63 60.87,63.66 62.02,64.81 62.02,65.62 66.8,70.41 66.8,74.72 66.97,74.89 66.97,87.77 66.56,88.19 66.56,91.33 68.19,92.96 v1(68.19,93.47) ; v1(92.32,193.8) 92.71,194.18 92.71,195.2 92.96,195.45 93.47,195.45 94.48,196.46 94.48,198.03 93.34,199.18 93.34,208.19 91.69,209.84 91.69,240.28 94.23,242.82 94.23,248.16 95.68,249.6 v1(97.05,249.6)
SML0_DATA_FOX_LAN: length 194.3
  TOP w0.1: v1(22.22,241.81) 22.6,241.81 24.38,240.03 R9B26.1 ; R7B13.2 95.5,253.62 v1(95.12,254) 95.17,254.05 95.17,255.36 95.66,255.85 95.66,256.13 95.48,256.3 EU7A3.10 ; R5B9.2 151.51,259.08 151,259.59 v1(151,261.36)
  LAY5 w0.125: v1(151,261.36) 149.09,261.36 148.86,261.13 140.56,261.13 139.7,260.28 132.41,260.28 128.27,256.14 126.85,256.14 125.95,257.04 125.64,257.04 124.15,258.53 116.04,258.53 115.68,258.18 109.93,258.18 107.53,255.78 102.31,255.78 100.69,257.41 100,257.41 99.77,257.64 91.82,257.64 90.77,256.59 85.9,256.59 v1(85.47,256.16) 84.78,256.16 83.13,257.81 77.61,257.81 74.81,260.6 74.81,263.31 74.31,263.8 71.01,263.8 68.82,261.61 67.57,261.61 66.92,262.26 64.86,262.26 64.21,261.6 44.04,261.6 43.03,260.6 38.89,260.6 38.22,261.27 38.22,268.47 38.43,268.68 v1(38.43,269.42)
  LAY6 w0.125: v1(38.43,269.42) 37.84,270 32.76,270 31.75,268.98 30.35,268.98 24.33,262.96 24.33,245.11 22.22,243 v1(22.22,241.81)
  BOTTOM w0.1: v1(95.12,254) 94.91,253.79 93.55,253.79 R7M2.1 92.53,254.81 92.07,254.81 90.29,256.58 88.26,256.58 87.5,255.82 85.8,255.82 v1(85.47,256.16)
SML0_DATA_LAN: length 1.8
  TOP w0.1: EU4B1.31 182.5,258.94 R4B1.2
SML0_DATA_TR: length 9
  TOP w0.1: v1(152.14,262.38) 151.51,261.75 151.51,259.71 152.27,258.95 R5B10.2
  BOTTOM w0.1: R5L12.1 153.79,265.56 153.03,264.79 153.03,263.78 152.14,262.89 v1(152.14,262.38)
SML1_CLK: length 198.2
  TOP w0.089: U6E1.BF27 91.77,145.5 91.62,145.65 88.3,145.65 88.16,145.5 84.12,145.5 83.93,145.31 83.8,145.31 83.23,144.74
  TOP w0.1: 40.25,23.62 R8J14.1 R8J13.1 v1(38.35,21.72) ; 83.23,144.74 79.95,144.74 79.56,144.35 77.16,144.35 76.7,143.89 76.7,143.64 76.45,143.38 72.51,143.38 72.24,143.11 67.05,143.11 65.67,141.73 64.89,141.73 64.12,142.49 v1(62.71,142.49)
  LAY5 w0.125: v1(38.35,21.72) 38.48,21.84 46.04,21.84 46.51,21.37 50.67,21.37 51.86,22.56 54.31,22.56 v1(54.48,22.73)
  LAY6 w0.125: v1(54.48,22.73) 54.43,22.78 54.43,33.86 55.43,34.86 55.43,43.32 56.51,44.39 56.51,47.21 56.01,47.71 56.01,50.46 55.63,50.85 55.63,56.43 55.24,56.82 55.24,58.55 54.34,59.44 54.34,66.72 56.09,68.46 56.09,69.3 60.33,73.54 60.33,76.6 54.48,82.45 54.48,85.34 55.11,85.97 55.11,92.08 52.66,94.52 52.66,110.56 59.56,117.46 59.56,134.24 60.45,135.13 61.84,135.13 63.24,136.52 63.24,141.35 62.71,141.88 v1(62.71,142.49) ; J8J13.14 37.97,9.56 37.97,21.33 v1(38.35,21.72)
SML1_CLK_EC: length 211.5
  TOP w0.1: v1(28.95,104.01) 28.42,104.54 U8F6.9 ; R8J13.2 v1(37.46,21.72) ; J6J2.168 v1(136.98,10.54)
  LAY3 w0.1: v1(37.46,21.72) 38.1,21.08 57.52,21.08 59.44,19.16 63.51,19.16 65.29,17.38 68.7,17.38 69,17.69 72.07,17.69 73.01,18.63 84.22,18.63 85.58,17.27 89.1,17.27 89.96,18.13 97.96,18.13 99.49,16.61 106.02,16.61 106.59,17.19 106.8,17.19 108.71,15.28 v1(108.71,15.26)
  LAY5 w0.125: v1(29.46,21.46) 30.6,21.46 31.36,22.22 36.95,22.22 v1(37.46,21.72)
  LAY6 w0.125: v1(28.95,104.01) 28.44,103.5 28.44,101.85 26.53,99.94 26.53,96.39 27.61,95.31 28,95.31 28.48,94.83 28.48,91.59 27.43,90.54 27.43,89.15 27.24,88.97 27.24,83.17 27.8,82.61 27.8,80.2 28.76,79.25 28.76,70.1 28.13,69.47 28.13,67.22 29.58,65.77 29.58,57.24 30.47,56.35 30.47,54.67 27.92,52.12 27.92,42.15 26.91,41.14 26.91,40 27.54,39.37 28.7,39.37 29.09,38.98 29.09,35.35 29.36,35.08 29.36,23.65 29.21,23.49 29.21,21.72 v1(29.46,21.46) ; v1(108.71,15.26) 109.55,16.11 114.04,16.11 114.45,16.51 115.28,16.51 115.69,16.11 116.74,16.11 117.08,16.45 121.57,16.45 121.91,16.11 128.99,16.11 130.43,14.67 130.43,13.05 131.83,11.65 136.05,11.65 136.98,10.71 v1(136.98,10.54)
SML1_CLK_HDR: length 2.7
  TOP w0.1: R8J14.2 41.14,20.7 J8J8.1
SML1_DATA: length 198.2
  TOP w0.089: U6E1.BE27 92.34,145.5 92.11,145.73 91.8,145.73 91.69,145.84 88.23,145.84 88.08,145.69 84.04,145.69 83.88,145.54 83.75,145.54 83.24,145.03
  TOP w0.1: J8J13.12 36.29,9.11 39.75,12.57 R8J21.1 39.87,13.33 37.71,15.49 37.71,20.7 36.7,21.72 v1(35.81,21.72) R8J12.1 R8J10.2 ; 83.24,145.03 79.96,145.03 79.75,144.82 74.24,144.82 73.14,143.73 72.37,143.73 72.1,143.46 66.73,143.46 65.5,142.24 65.05,142.24 64.29,143 62.53,143 v1(62.02,142.49)
  LAY5 w0.125: v1(46.73,20.45) 46.1,21.08 37.21,21.08 36.57,21.72 v1(35.81,21.72)
  LAY6 w0.125: v1(46.73,20.45) 48.26,21.97 48.26,24.13 46.99,25.4 46.99,37.6 51.35,41.96 51.35,47.85 51.66,48.16 51.66,50.9 51.17,51.39 51.17,53.53 52.7,55.07 52.7,61.87 52.07,62.51 52.07,66.8 51.68,67.18 51.68,68.77 51.5,68.96 51.5,72.48 50.91,73.06 50.91,78.12 52.3,79.5 53.82,79.5 54.47,80.16 54.47,80.85 52.14,83.19 52.14,93.35 51.53,93.95 51.53,111.03 57.53,117.02 57.53,130.73 57.91,131.12 57.91,139.45 60.2,141.73 61.26,141.73 v1(62.02,142.49)
SML1_DATA_EC: length 211.1
  TOP w0.1: v1(28.95,104.78) 28.82,104.91 U8F6.8 ; J6J2.160 v1(135.71,10.54) ; v1(29.71,23.11) 29.84,22.99 34.41,22.99 R8J12.2
  LAY3 w0.1: v1(110.23,14.73) 110.23,15.1 107.19,18.14 106.2,18.14 105.62,17.56 99.88,17.56 98.36,19.08 89.57,19.08 88.7,18.22 85.97,18.22 84.61,19.58 72.62,19.58 71.67,18.64 68.61,18.64 68.3,18.33 65.68,18.33 63.9,20.11 61.92,20.11 61.44,20.59 60.17,20.59 59.05,21.72 58.42,21.72 58.1,22.03 56.74,22.03 55.56,23.21 54.2,23.21 53.66,22.67 30.15,22.67 v1(29.71,23.11)
  LAY6 w0.125: v1(135.71,10.54) 134.98,11.27 131.67,11.27 130.06,12.89 130.06,14.52 128.95,15.62 119.25,15.62 118.74,15.11 114.34,15.11 114.21,15.24 110.74,15.24 v1(110.23,14.73) ; v1(29.71,23.11) 29.86,23.26 29.86,35.29 29.59,35.56 29.59,39.23 28.95,39.86 28.95,41.91 28.42,42.44 28.42,51.91 30.84,54.34 30.84,56.53 30.6,56.77 30.6,61.09 29.95,61.73 29.95,65.92 29.13,66.75 29.13,79.4 28.3,80.23 28.3,82.64 27.62,83.32 27.62,88.81 27.8,89 27.8,90.38 28.85,91.43 28.85,94.99 28.15,95.69 27.76,95.69 26.9,96.55 26.9,99.78 28.82,101.7 28.82,103.12 29.48,103.77 29.48,104.25 v1(28.95,104.78)
SML1_DATA_HDR: length 2.5
  TOP w0.1: R8J21.2 40.76,14.73 J8J8.3
SMLINK0_CLK_HDR: length 2.4
  TOP w0.1: R8J16.2 J8J12.1
SMLINK0_DATA_HDR: length 2.4
  TOP w0.1: R8J18.2 J8J12.3
SNDW1_CLK_HDR: length 10.9
  TOP w0.1: R9A7.2 14.69,273.07 12.96,273.07 7.65,278.38 7.49,278.38
SNDW1_DATA_HDR: length 12.1
  TOP w0.1: R9A6.2 13.89,272.6 12.77,272.6 8.76,276.6 6.73,276.6 J9A1.1
SNDW2_CLK: length 132.6
  TOP w0.1: v1(125.47,274.57) 125.47,274.83 124.95,275.35 EU6A1.9 ; v1(17.01,264.67) 16.25,263.9 R9A18.2
  LAY5 w0.125: v1(125.47,274.57) 124.08,273.18 122,273.18 119.94,271.13 116.18,271.13 115.4,271.91 109.99,271.91 107.31,269.24 96.13,269.24 94.6,270.78 93.99,270.78 93.36,271.41 88.73,271.41 87.87,270.55 87.87,269.79 86.82,268.74 85.58,268.74 85.03,269.29 85.03,271.02 81.85,274.2 67.87,274.2 65.35,271.68 43.02,271.68 v1(41.4,273.3)
  LAY6 w0.125: v1(17.01,264.67) 16.64,265.04 16.64,269.9 17.03,270.29 17.03,271.14 18.69,272.8 18.69,273.85 19.26,274.42 20.39,274.42 21.39,275.42 23.1,275.42 23.63,275.95 27.18,275.95 30.26,272.87 40.96,272.87 v1(41.4,273.3)
SNDW2_DATA: length 163.9
  TOP w0.1: v1(124.71,274.83) 124.55,274.99 EU6A1.8 ; v1(25.65,214.76) 25.4,214.5 R8C27.2
  LAY5 w0.125: v1(124.71,274.83) 123.57,273.68 121.79,273.68 119.74,271.63 116.39,271.63 115.61,272.41 108.6,272.41 107.59,271.4 96.26,271.4 96.13,271.28 94.2,271.28 93.57,271.91 88.52,271.91 87.37,270.76 87.37,269.99 86.61,269.24 85.79,269.24 85.53,269.49 85.53,271.23 82.06,274.7 67.66,274.7 65.15,272.18 47.6,272.18 v1(47.11,272.67)
  LAY6 w0.125: v1(25.65,214.76) 25.92,215.03 25.92,220.61 25.27,221.26 25.27,225.93 24.63,226.57 24.63,227.46 23.23,228.86 23.23,234.54 23.99,235.3 23.99,238.11 24.67,238.79 24.67,240.16 25.21,240.7 25.21,242.5 26.41,243.7 26.41,254 27.44,255.02 27.44,261.12 28.7,262.38 31.87,262.38 33.78,264.29 36.19,264.29 38.48,266.57 44.7,266.57 44.95,266.83 44.95,270.51 v1(47.11,272.67)
SOC_DMIC0_SDW3_DATA: length 177.8
  TOP w0.1: v1(17.65,247.39) 18.66,248.41 24.76,248.41 R8B12.1
  BOTTOM w0.1: R7R19.2 86.96,153.44 86.96,154.61 86.67,154.9 83.58,154.9 81.84,156.64 76.12,156.64 75.55,157.21 75.41,157.36 74.14,157.36 73.38,158.11 69.33,158.11 67.8,159.64 65.52,159.64 62.73,162.43 62.73,166.52 59.58,169.67 56.83,169.67 55.51,170.99 55.51,174.62 54.29,175.84 54.29,178.14 48.41,184.02 48.01,184.02 45.85,186.18 45.85,186.69 43.97,188.56 39.96,188.56 38.03,190.5 29.8,190.5 28.77,191.54 26,191.54 25.62,191.92 23.98,191.92 23.62,192.28 22.35,192.28 21.85,192.77 21.23,192.77 21.13,192.87 21.13,193.88 21.03,193.98 20.83,193.98 20.73,193.88 20.73,192.87 20.63,192.77 20.3,192.77 18.86,194.22 18.86,194.47 18.96,194.57 21.07,194.57 21.17,194.67 21.17,194.87 21.07,194.97 18.96,194.97 18.86,195.07 18.86,195.27 18.96,195.37 21.07,195.37 21.17,195.47 21.17,195.67 21.07,195.77 18.96,195.77 18.86,195.87 18.86,196.07 18.96,196.17 21.07,196.17 21.17,196.27 21.17,196.47 21.07,196.57 18.96,196.57 18.86,196.67 18.86,196.87 18.96,196.97 21.07,196.97 21.17,197.07 21.17,197.27 21.07,197.37 18.96,197.37 18.86,197.47 18.86,197.75 18.96,197.85 19.6,197.85 19.7,197.95 19.7,198.15 19.6,198.25 18.96,198.25 18.86,198.35 18.86,200.84 16.06,203.64 16.06,205.75 14.67,207.15 14.67,217.17 15.49,217.99 15.49,219.65 15.1,220.04 15.1,238.05 17.65,240.6 v1(17.65,247.39)
SOC_DMIC0_SDW4_CLK: length 164.5
  TOP w0.1: C8B1.1 R8B3.1 23.87,257.68 23.74,257.81 21.84,257.81 21.2,257.17 21.2,255.9 18.19,252.89 18.19,250.6 v1(16.25,248.66) ; R7E18.2 C7E9.1 82.55,152.65 81.91,153.29 77.85,153.29 77.21,153.92 75.05,153.92 C7E7.1 74.42,154.3 72.13,154.3 R7E15.1 71.59,153.8 68.7,156.68 67.62,156.68 60.73,163.57 v1(59.94,163.57) ; C9D1.1 v1(25.27,189.99)
  BOTTOM w0.1: v1(16.25,248.66) 17.14,247.78 17.14,240.76 14.63,238.25 14.63,219.84 15.01,219.45 15.01,218.18 14.19,217.36 14.19,206.95 15.59,205.55 15.59,203.44 18.38,200.65 18.38,194.02 20.11,192.3 21.65,192.3 22.15,191.8 23.42,191.8 25.23,189.99 v1(25.27,189.99) 25.59,189.67 37.69,189.67 40.29,187.07 41.6,187.07 43.38,185.29 45.57,185.29 47.15,183.72 47.15,182.94 47.93,182.15 49.11,182.15 52.62,178.64 52.62,177.75 53.46,176.91 53.46,175.5 54.68,174.27 54.68,170.64 56.48,168.84 58.64,168.84 60.42,167.07 60.42,164.06 v1(59.94,163.57)
SOC_DMIC0_SDW4_DATA: length 168.5
  TOP w0.1: v1(59.94,164.31) 60.66,164.31 67.82,157.16 68.9,157.16 71.24,154.81 C7E5.1 72.06,155.25 74.49,155.25 C7E6.1 75.78,154.81 76.19,154.4 78.95,154.4 79.71,153.64 83.46,153.64 R7E17.2 ; C9D2.1 v1(25.27,188.72) ; v1(16.27,247.67) 18.66,250.06 18.66,250.57 19.3,251.2 22.98,251.2 R9B9.1
  BOTTOM w0.1: v1(16.27,247.67) 16.67,247.27 16.67,240.96 14.15,238.44 14.15,224.02 13.64,223.51 13.64,213.35 12.75,212.46 12.75,207.72 15.11,205.36 15.11,203.24 17.91,200.45 17.91,199.35 17.81,199.25 16.59,199.25 16.49,199.15 16.49,198.95 16.59,198.85 17.81,198.85 17.91,198.75 17.91,198.55 17.81,198.45 16.59,198.45 16.49,198.35 16.49,198.15 16.59,198.05 17.81,198.05 17.91,197.95 17.91,197.75 17.81,197.65 16.59,197.65 16.49,197.55 16.49,197.35 16.59,197.25 17.81,197.25 17.91,197.15 17.91,196.95 17.81,196.85 16.59,196.85 16.49,196.75 16.49,196.55 16.59,196.45 17.81,196.45 17.91,196.35 17.91,193.67 20.57,191.01 23.49,191.01 25.27,189.23 v1(25.27,188.72) 25.4,188.72 25.87,189.2 37.11,189.2 38.22,188.09 38.22,187.78 41.28,184.72 42.6,184.72 43.3,184.02 45.39,184.02 47.73,181.67 48.92,181.67 52.07,178.53 52.07,176.02 52.7,175.39 52.9,175.39 54.21,174.08 54.21,170.45 56.29,168.37 58.45,168.37 59.94,166.88 v1(59.94,164.31)
SOC_DMIC1_SDW3_CLK: length 168.3
  TOP w0.1: R8B17.1 26.41,242.7 25.78,242.06 23.11,242.06 22.86,242.31 20.06,242.31 v1(19.81,242.06)
  BOTTOM w0.1: v1(19.81,242.06) 19.33,242.06 18.71,241.44 18.71,238.76 16.51,236.55 16.51,230 15.58,229.07 15.58,220.24 15.96,219.85 15.96,217.79 15.14,216.97 15.14,207.34 16.54,205.95 16.54,203.83 17.13,203.24 17.27,203.24 17.48,203.45 17.62,203.45 17.76,203.31 17.76,203.17 17.55,202.96 17.55,202.82 17.7,202.68 17.84,202.68 18.04,202.89 18.19,202.89 18.33,202.74 18.33,202.6 18.12,202.39 18.12,202.25 18.26,202.11 18.4,202.11 18.61,202.32 18.75,202.32 18.89,202.18 18.89,202.04 18.69,201.83 18.69,201.69 18.83,201.55 18.97,201.55 19.18,201.75 19.32,201.75 19.46,201.61 19.46,201.47 19.25,201.26 19.25,201.12 19.39,200.98 19.53,200.98 19.74,201.19 19.88,201.19 20.02,201.05 20.02,200.91 19.82,200.7 19.82,200.56 19.96,200.41 20.1,200.41 20.31,200.62 20.45,200.62 20.59,200.48 20.59,200.34 20.38,200.13 20.38,199.99 20.52,199.85 20.67,199.85 20.87,200.06 21.01,200.06 21.16,199.92 21.16,199.77 20.95,199.57 20.95,199.42 21.65,198.73 21.65,197.88 22.36,197.16 22.36,196.94 22.46,196.84 22.91,196.84 23.01,196.74 23.01,196.54 22.91,196.44 22.46,196.44 22.36,196.34 22.36,196.14 22.46,196.04 22.91,196.04 23.01,195.94 23.01,195.74 22.91,195.64 22.46,195.64 22.36,195.54 22.36,195.34 22.46,195.24 22.91,195.24 23.01,195.14 23.01,194.94 22.91,194.84 22.46,194.84 22.36,194.74 22.36,193.73 22.84,193.25 23.82,193.25 24.67,192.39 25.82,192.39 26.2,192.01 31.5,192.01 32.54,190.97 38.23,190.97 40.16,189.04 44.38,189.04 45.46,187.96 45.97,187.96 47.49,186.43 48.38,186.43 49.62,185.2 49.62,185.06 49.02,184.47 49.02,184.32 49.17,184.18 49.31,184.18 49.9,184.78 50.04,184.78 50.18,184.63 50.18,184.49 49.59,183.9 49.59,183.76 49.73,183.62 49.87,183.62 50.47,184.21 50.61,184.21 50.75,184.07 50.75,183.93 50.16,183.33 50.16,183.19 50.3,183.05 50.44,183.05 51.03,183.64 51.17,183.64 51.31,183.5 51.31,183.36 50.72,182.77 50.72,182.63 50.86,182.49 51,182.49 51.6,183.08 51.74,183.08 51.88,182.94 51.88,182.8 51.29,182.2 51.29,182.06 51.43,181.92 51.57,181.92 52.16,182.51 52.3,182.51 52.57,182.24 52.57,180.85 53.46,179.96 53.97,179.96 54.76,179.17 54.76,176.04 55.98,174.81 55.98,171.18 57.02,170.14 59.78,170.14 63.21,166.72 63.21,162.63 65.72,160.12 68.1,160.12 68.96,159.25 72.64,159.25 R7R8.1 73.54,158.62 74.33,157.83 75.65,157.83 76.37,157.12 82.04,157.12 83.77,155.38 87.06,155.38 87.5,154.94 C7R1.1 87.5,153.8
SPD_PRSNT: length 93.9
  TOP w0.1: J9G2.2 8.25,89.41 11.3,92.45 R9G6.1 ; v1(24.25,152.49) U8E3.7
  LAY6 w0.125: v1(9.27,154.56) 10.42,153.41 10.42,142.11 9.65,141.34 9.65,138.15 8.32,136.82 8.32,119.85 9.22,118.94 9.22,108.89 7.41,107.08 7.41,100.13 7.74,99.8 7.74,93.98 9.27,92.45 9.27,89.16 J9G2.2
  BOTTOM w0.1: v1(24.25,152.49) 16.8,152.49 15.74,153.54 14.77,153.54 13.5,154.81 9.52,154.81 v1(9.27,154.56)
SPD_PRSNT_PU: length 9
  TOP w0.1: R9G5.2 10.41,93.6 10.41,92.33 8.63,90.55 8.12,90.55 J9G2.1
SPI1_TCHPNL_CLK: length 107.9
  TOP w0.089: U6E1.BE19 92.31,149.58 92.23,149.65 91.88,149.65 91.79,149.57 90.65,149.57 90.5,149.57 89.93,149.57 89.55,149.57 89.14,149.57 89.02,149.68 87.96,149.68 87.48,150.16 85.77,150.16
  TOP w0.1: v1(63.75,153.29) 65.27,151.76 69.64,151.76 70.33,151.08 77.06,151.08 77.33,151.35 78.99,151.35 80.18,150.16 83.03,150.16 83.29,149.9 85.51,149.9 85.77,150.16 ; R9D20.2 v1(15.62,179.2)
  BOTTOM w0.1: v1(15.62,179.2) 16,178.81 16,176.66 15.69,176.35 14.93,176.35 13.08,174.5 13.08,167.29 14.2,166.17 14.2,160.59 15.62,159.17 16.29,159.17 19.14,156.32 24.5,156.32 24.91,156.73 27.68,156.73 28.09,156.32 30.97,156.32 31.08,156.2 33.02,156.2 33.5,156.68 41.55,156.68 42.15,156.08 46.22,156.08 46.51,156.37 46.51,157 46.95,157.45 48,157.45 48.67,158.11 52.45,158.11 56.54,154.02 59.75,154.02 60.48,153.29 v1(63.75,153.29)
SPI1_TCHPNL_CS_N: length 103.1
  TOP w0.089: 85.87,149.96 87.41,149.96 87.88,149.49 88.94,149.49 89.06,149.37 91.87,149.37 91.92,149.42 U6E1.BF19
  TOP w0.1: R9D26.1 v1(15.36,175.89) ; 85.87,149.96 85.61,149.7 83.21,149.7 82.94,149.96 78.51,149.96 78.3,150.16 76.94,150.16 76.81,150.03 73.87,150.03 73.53,150.37 70.35,150.37 70.1,150.11 69.28,150.11 69.18,150.21 66.06,150.21 63.24,153.03 63.24,153.67 v1(63.75,154.18)
  BOTTOM w0.1: v1(15.36,175.89) 13.55,174.08 13.55,167.49 14.67,166.37 14.67,160.79 15.82,159.64 16.49,159.64 19.34,156.79 24.3,156.79 24.71,157.2 27.88,157.2 28.29,156.79 31.16,156.79 31.28,156.68 32.82,156.68 33.3,157.15 42.38,157.15 43.2,157.97 44.2,157.97 44.22,157.96 46.4,157.96 46.88,158.44 48.27,158.44 48.47,158.65 52.58,158.65 56.74,154.49 59.95,154.49 60.14,154.3 63.62,154.3 v1(63.75,154.18)
SPI1_TCHPNL_IO2: length 99.4
  TOP w0.089: U6E1.BD17 92.66,150.71 92.51,150.55 92.01,150.55 91.98,150.52 91.67,150.52 91.48,150.33 90.34,150.33 89.45,150.33 89.34,150.44 88.38,150.44 87.85,150.98 85.19,150.98 84.88,150.67 83.77,150.67 83.46,150.98 83.28,150.98
  TOP w0.1: v1(65.4,154.24) 67.62,154.24 68.77,153.1 69.95,153.1 70.81,152.24 79.53,152.24 80.79,150.98 83.28,150.98 ; R9D28.2 v1(15.36,174.88)
  BOTTOM w0.1: v1(15.36,174.88) 15.87,174.37 15.87,173.17 15.18,172.48 15.18,167.49 16.02,166.65 16.02,160.76 19.53,157.24 24.11,157.24 24.53,157.66 28.27,157.66 28.57,157.35 31.36,157.35 31.59,157.13 32.64,157.13 33.11,157.61 42.19,157.61 43.01,158.43 44.39,158.43 44.4,158.42 46.21,158.42 46.69,158.9 48.08,158.9 48.29,159.1 54.67,159.1 58.83,154.95 60.14,154.95 60.27,154.81 63.12,154.81 63.27,154.97 64.68,154.97 v1(65.4,154.24)
SPI1_TCHPNL_IO2_R: length 6.5
  TOP w0.1: R9D28.1 C9D8.1 12.82,175.13 12.06,175.89 12.06,178.18 11.24,178.99 J9D2.8
SPI1_TCHPNL_IO3: length 98.9
  TOP w0.089: 83.5,150.54 83.57,150.48 85.07,150.48 85.36,150.77 87.73,150.77 88.25,150.25 89.26,150.25 89.37,150.14 90.42,150.14 91.56,150.14 91.75,150.33 92.08,150.33 92.11,150.36 92.78,150.36 92.86,150.44 93.24,150.44 U6E1.BC17
  TOP w0.1: 83.5,150.54 83.27,150.77 80.61,150.77 79.38,152.01 70.71,152.01 69.85,152.87 68.67,152.87 67.77,153.77 65.04,153.77 v1(64.64,154.18) ; R9D30.2 v1(15.36,173.86)
  BOTTOM w0.1: v1(64.64,154.18) 64.08,154.74 63.37,154.74 63.19,154.56 60.21,154.56 60.05,154.72 58.74,154.72 54.58,158.88 48.38,158.88 48.17,158.67 46.79,158.67 46.31,158.19 44.31,158.19 44.3,158.2 43.1,158.2 42.28,157.38 33.21,157.38 32.73,156.9 31.43,156.9 31.32,157.02 28.38,157.02 27.97,157.43 24.62,157.43 24.21,157.02 19.43,157.02 15.79,160.66 15.79,166.56 14.95,167.39 14.95,173.45 v1(15.36,173.86)
SPI1_TCHPNL_IO3_R: length 9
  TOP w0.1: J9D2.9 11.36,178.49 11.81,178.05 11.81,177.04 10.54,175.77 10.54,174.75 10.92,174.37 12.34,174.37 12.44,174.27 12.44,174.24 C9D9.1 R9D30.1
SPI1_TCHPNL_MISO: length 109.6
  TOP w0.089: 83.33,150.14 83.38,150.1 85.42,150.1 85.69,150.37 87.54,150.37 88.04,149.87 89.1,149.87 89.21,149.76 90.42,149.76 90.58,149.76 90.58,149.76 91.72,149.76 91.8,149.84 92.11,149.84 92.34,150.08 U6E1.BE18
  TOP w0.1: R9D6.2 v1(11.55,183.64) ; v1(64.64,153.29) 65.51,152.41 69.66,152.41 70.52,151.55 79.07,151.55 80.26,150.37 83.11,150.37 83.33,150.14
  BOTTOM w0.1: v1(64.64,153.29) 64.13,152.78 60.32,152.78 59.56,153.54 53.21,153.54 52.45,154.3 40.45,154.3 40.09,154.66 19.46,154.66 13.72,160.39 13.72,165.94 10.66,169 10.66,182.75 v1(11.55,183.64)
SPI1_TCHPNL_MOSI: length 111.1
  TOP w0.089: 83.42,150.34 83.47,150.29 85.34,150.29 85.62,150.57 87.61,150.57 88.12,150.06 89.18,150.06 89.29,149.95 90.34,149.95 90.5,149.95 91.64,149.95 91.77,150.08 U6E1.BF18
  TOP w0.1: R9D5.2 v1(10.79,185.55) ; 83.42,150.34 83.19,150.57 80.44,150.57 79.23,151.78 70.62,151.78 69.76,152.64 68.58,152.64 67.93,153.29 v1(65.4,153.29)
  BOTTOM w0.1: v1(10.79,185.55) 10.44,185.19 10.44,168.9 13.5,165.84 13.5,160.3 19.36,154.43 40,154.43 40.35,154.08 52.35,154.08 53.11,153.31 59.46,153.31 60.23,152.55 64.67,152.55 v1(65.4,153.29)
SPI_CLK: length 89.9
  TOP w0.089: 92.15,130.29 92.15,131.01 95.39,134.24 95.39,135.29 95.33,135.35 95.33,135.35 95.29,135.4 95.29,135.76 95.37,135.84 U6E1.AW47
  TOP w0.1: 92.15,130.29 92.15,129.07 90.41,127.32 90.41,121.55 87.66,118.81 87.66,115.12 87.31,114.77 87.31,113.71 86.52,112.92 86.52,109.52 86.2,109.2 86.2,105.61 86.52,105.28 86.52,102.91 85.56,101.94 85.56,96.52 85.66,96.42 85.86,96.42 85.96,96.52 85.96,101.7 86.06,101.8 86.26,101.8 86.36,101.7 86.36,94.19 86.46,94.09 86.66,94.09 86.76,94.19 86.76,102.2 86.86,102.3 87.06,102.3 87.16,102.2 87.16,93.54 86.52,92.91 86.52,91.42 85.31,90.21 83.28,90.21 83.18,90.11 83.18,89.76 83.28,89.66 84.83,89.66 84.96,89.53 84.96,88.39 84.83,88.26 83.05,88.26 82.67,87.88 R7G7.1 82.52,87.47 U7G1.12
SPI_CLK_EC: length 94.7
  BOTTOM w0.1: R9U9.2 22.73,79.88 25.14,79.88 27.59,82.33 30.67,82.33 31.78,83.43 36.01,83.43 36.11,83.33 36.11,83.13 36.01,83.03 32,83.03 31.9,82.93 31.9,82.73 32,82.63 45.51,82.63 45.72,82.42 45.72,81.12 45.82,81.02 46.12,81.02 46.22,81.12 46.22,82.53 46.32,82.63 48.43,82.63 48.64,82.42 48.64,81.15 48.76,81.03 53.84,81.03 53.94,81.13 53.94,81.33 53.84,81.43 49.93,81.43 49.83,81.53 49.83,81.73 49.93,81.83 53.84,81.83 53.94,81.93 53.94,82.13 53.84,82.23 49.93,82.23 49.83,82.33 49.83,82.53 49.93,82.63 57.79,82.63 58.41,83.25 66.38,83.25 68.01,84.88 72.05,84.88 72.55,84.38 76.25,84.38 76.58,84.71 76.58,86.69 78.01,88.12 U7U1.2
SPI_CLK_FLASH: length 22.9
  TOP w0.1: EU7G3.6 87.5,84.71 87.63,84.83 87.63,86.87 88.13,87.37 88.13,89.79 88.39,90.04 92.32,90.04 92.45,90.17 92.45,90.55 92.32,90.68 87.12,90.68 86.25,89.81 U7G4.16 86.25,87.27 85.97,86.99 83.82,86.99 R7G8.1
SPI_CLK_PCON: length 13.4
  TOP w0.1: U2B1.6 247.14,258.82 247.26,258.95 247.26,260.39 246.92,260.73 246.12,260.73 245.61,261.24 R2A66.1 246.12,262.13 246.12,263.52 245.49,264.16 245.49,266.06 244.72,266.83 242.76,266.83 242.63,266.97 U3A5.D2
SPI_CLK_SW: length 5.1
  TOP w0.1: R7G9.1 83.43,85.98 R7G8.2 82.55,86.87 v1(81.91,86.87) 81.66,86.87 81.61,86.82 U7G1.11
  BOTTOM w0.1: v1(81.91,86.87) 81.31,87.47 U7U1.3
SPI_CLK_TPM: length 22.7
  TOP w0.1: v1(84.58,85.85) 83.82,85.09 R7G9.2 ; v1(84.3,74.67) 84.3,69.72 84.97,69.05 J7G2.7
  BOTTOM w0.1: v1(84.3,74.67) 85.54,75.92 85.88,75.92 86.82,76.86 86.82,78.66 85.47,80.01 84.32,80.01 84.07,80.26 84.07,85.34 v1(84.58,85.85)
SPI_CS0_EC_N: length 54.2
  BOTTOM w0.1: U7U1.9 67.98,85.52 66.18,83.72 58.21,83.72 57.6,83.11 37.79,83.11 36.83,84.07 31.75,84.07 30.48,82.8 25.83,82.8 R9U7.2
SPI_CS0_FLASH_N: length 30.9
  TOP w0.1: v1(84.55,80.52) 84.55,80.54 83.82,81.28 83.82,82.42 83.56,82.68 80.69,82.68 80.02,83.34 75.4,83.34 75.18,83.56 72.26,83.56 72,83.82 72,85.34 R7G10.1 ; EU7G3.1 94.51,81.56 93.87,80.92 U7G4.7 93.87,78.41 93.77,78.31 90.52,78.31 v1(90.17,77.95)
  BOTTOM w0.1: v1(84.55,80.52) 87.6,80.52 v1(90.17,77.95)
SPI_CS0_N: length 71
  TOP w0.089: 91.9,130.29 91.9,131.02 95.2,134.32 95.2,135.21 95.14,135.27 95.14,135.27 95.09,135.32 95.09,135.77 U6E1.AY47
  TOP w0.1: 91.9,130.29 91.9,129.48 89.93,127.52 89.93,121.75 86.83,118.65 86.83,116.93 86.59,116.7 86.59,115.57 86.83,115.33 86.83,113.9 86.04,113.12 86.04,109.72 83.94,107.62 83.94,106.93 84.67,106.2 84.67,102.29 85.06,101.91 85.06,101.42 84.73,101.09 84.2,101.09 83.94,100.84 83.94,99.32 84.03,99.23 84.45,99.23 84.54,99.14 84.54,96.73 84.45,96.65 84.33,96.65 84.24,96.73 84.24,98.84 84.15,98.93 84.03,98.93 83.94,98.84 83.94,95.45 85.54,93.85 85.54,91.61 84.97,91.04 81.52,91.04 79.99,89.5 79.1,89.5 77.88,88.29 77.88,86.4 77.66,86.17 74.67,86.17
SPI_CS0_SW_N: length 5.2
  TOP w0.1: U7G1.6 72.82,85.52 R7G10.2 72.77,85.35 v1(73.25,84.87) 72.64,84.26 R7G12.2
  BOTTOM w0.1: 74.67,84.87 v1(73.25,84.87)
SPI_CS0_TPM_N: length 30.8
  TOP w0.1: R7G12.1 79.79,84.07 80.83,83.03 84.48,83.03 85.37,82.14 85.37,79.15 84.07,77.85 v1(84.07,77.21) ; J7G2.2 81.16,72.97 80.96,73.17 80.36,73.17 80.26,73.27 80.26,75.38 80.36,75.48 80.56,75.48 80.66,75.38 80.66,73.67 80.76,73.57 80.96,73.57 81.06,73.67 81.06,75.22 81.78,75.94 v1(82.29,75.94)
  BOTTOM w0.1: v1(84.07,77.21) 83.56,77.21 v1(82.29,75.94)
SPI_CS1_N: length 103.3
  TOP w0.089: 92.36,130.29 92.36,130.94 95.58,134.16 95.58,135.53 U6E1.AW48
  TOP w0.1: R7G33.2 81.81,75.21 v1(82.34,75.21) ; v1(85.43,87.5) 85.43,89.66 86.99,91.23 86.99,92.71 87.63,93.35 87.63,100.89 87.73,100.99 87.93,100.99 88.03,100.89 88.03,93.44 88.13,93.34 88.33,93.34 88.43,93.44 88.43,98.22 88.53,98.32 88.73,98.32 88.83,98.22 88.83,91.28 88.93,91.18 89.13,91.18 89.23,91.28 89.23,98.62 89.13,98.72 88.6,98.72 88.43,98.89 88.43,101.19 87.63,101.99 87.63,103.12 86.99,103.75 86.99,105.48 86.67,105.8 86.67,109 86.99,109.32 86.99,112.72 87.78,113.51 87.78,114.57 88.14,114.93 88.14,118.61 90.88,121.35 90.88,127.12 92.36,128.6 92.36,130.29
  BOTTOM w0.1: v1(85.43,87.5) 85.43,87.25 84.67,86.49 84.45,86.49 83.18,85.22 83.18,82.29 83.59,81.88 83.59,80.07 84.16,79.5 85.21,79.5 86.34,78.37 86.34,77.84 85.97,77.47 85.29,77.47 84.17,76.35 83.43,76.35 82.34,75.26 v1(82.34,75.21)
SPI_CS1_TPM_N: length 3.2
  TOP w0.1: J7G2.4 82.43,72.37 81.53,73.28 81.53,74.04 R7G33.1
SPI_CS2_N: length 111.3
  TOP w0.089: U6E1.AT40 v1(96.32,139.51)
  TOP w0.1: v1(99.31,96.14) 98.29,96.14 96.01,93.85 96.01,88.24 96.52,87.74 96.52,76.33 95.93,75.74 95.93,64.65 91.47,60.2 88.49,60.2 88.01,60.68 88.01,62.57 v1(88.68,63.24) R7H16.1
  BOTTOM w0.089: v1(96.32,139.51) 95.68,139.51 95.12,138.95 95.12,138.77 94.67,138.33 94.67,138 94.39,137.71 94.39,136.9 94.23,136.74 94.23,136.53
  BOTTOM w0.1: 94.23,136.53 94.23,135.76 92.96,134.49 92.96,131.37 87.94,126.35 87.94,121.85 84.26,118.17 84.26,117.54 83.69,116.97 83.69,116.33 84.35,115.66 84.35,113.79 83.37,112.81 83.37,100.14 84.32,99.19 88.01,99.19 88.26,98.93 92.45,98.93 94.91,96.47 98.97,96.47 v1(99.31,96.14)
SPI_CS2_TPM_N: length 6.2
  TOP w0.1: R7H19.2 89.19,62.99 89.19,64.77 89.06,64.9 88.68,64.9 J7G1.43
SPI_CSN_PCON: length 15.8
  TOP w0.1: v1(244.98,265.68) 244.98,265.9 244.49,266.39 243.21,266.39 ; v1(246.5,265.68) 246.5,264.14 247.14,263.5 247.14,263.27 248.15,262.25 248.15,261.5 248.97,260.68 248.97,257.5 250.19,256.28 U2B1.1
  BOTTOM w0.1: v1(246.5,265.68) v1(244.98,265.68)
SPI_DI_PCON: length 16.7
  TOP w0.1: U3A5.C2 242.01,265.99 242.01,265.41 242.23,265.18 243.38,265.18 243.58,264.97 243.58,264.47 v1(243.76,264.3) ; U2B1.2 250.44,257.55 249.2,258.8 249.2,260.78 248.38,261.59 248.38,263.07 248.15,263.3 247.81,263.3 247.01,264.09 v1(247.01,264.67)
  BOTTOM w0.1: v1(243.76,264.3) 243.88,264.41 246.76,264.41 v1(247.01,264.67)
SPI_DO_PCON: length 11.2
  TOP w0.1: 243.21,267.19 245.12,267.19 245.99,266.32 v1(245.99,264.92) ; v1(244.98,264.92) 244.98,263.78 245.11,263.65 245.11,260.6 245.61,260.09 U2B1.5
  BOTTOM w0.1: v1(244.98,264.92) v1(245.99,264.92)
SPI_DQ2_TPM: length 44.5
  TOP w0.1: R7G24.1 72.29,77.12 74.3,77.12 74.38,77.03 74.38,76.41 74.47,76.33 74.6,76.33 74.68,76.41 74.68,77.03 74.77,77.12 75.69,77.12 75.78,77.03 75.78,76.73 75.87,76.64 75.99,76.64 76.08,76.73 76.08,77.03 76.17,77.12 76.29,77.12 76.38,77.03 76.38,76.73 76.47,76.64 76.59,76.64 76.68,76.73 76.68,77.03 76.77,77.12 77.18,77.12 77.27,77.21 77.27,77.33 77.18,77.42 73.59,77.42 73.51,77.51 73.51,77.63 73.59,77.72 76.63,77.72 76.72,77.81 76.72,79.67 76.81,79.75 76.93,79.75 77.02,79.67 77.02,77.81 77.11,77.72 77.23,77.72 77.32,77.81 77.32,79.67 77.41,79.75 77.53,79.75 77.62,79.67 77.62,77.43 77.71,77.34 77.83,77.34 77.92,77.43 77.92,79.67 78.01,79.75 78.13,79.75 78.22,79.67 78.22,77.43 78.31,77.34 78.68,77.34 78.77,77.43 78.77,78.48 78.86,78.57 78.98,78.57 79.07,78.48 79.07,77.81 79.16,77.72 79.75,77.72 79.91,77.56 79.91,77.44 79.51,77.04 79.51,76.92 79.6,76.83 79.73,76.83 80.12,77.23 80.25,77.23 80.39,77.09 80.61,77.09 80.7,77 80.7,76.79 80.79,76.71 80.91,76.71 81,76.79 81,77 81.09,77.09 82.7,77.09 84.87,74.92 J7G1.38
SPI_DQ3_TPM: length 34.2
  TOP w0.1: v1(85.47,73.53) 85.55,73.45 85.55,69.76 86.24,69.07 J7G2.9 ; R7G17.2 70.86,80.77 70.61,80.77 v1(70.05,81.33)
  BOTTOM w0.1: v1(85.47,73.53) 84.83,74.17 82.67,74.17 81.78,75.06 81.78,76.58 82.51,77.31 82.51,79.15 81.85,79.82 81.85,82.25 81.38,82.71 79.64,82.71 78.45,81.52 77.53,81.52 75.84,83.2 72.51,83.2 72.39,83.09 71.4,83.09 71.12,82.8 71.12,82.4 v1(70.05,81.33)
SPI_HOLD0_FLASH_N: length 34.1
  TOP w0.1: v1(85.85,78) 86.25,78.41 U7G4.1 86.25,81 86.1,81.15 86.1,83.31 86.23,83.44 EU7G3.7 ; v1(70.05,82.02) 70.53,81.53 70.86,81.53 R7G16.2
  BOTTOM w0.1: v1(85.85,78) 85.36,78.48 83.82,78.48 82.2,80.1 82.2,82.39 81.53,83.06 80.68,83.06 80.58,83.16 80.58,83.36 80.68,83.46 81.97,83.46 82.07,83.56 82.07,83.76 81.97,83.86 80.3,83.86 78.31,81.87 77.74,81.87 76.06,83.55 72.36,83.55 72.25,83.44 70.35,83.44 69.97,83.06 69.97,82.09 v1(70.05,82.02)
SPI_HOLD_PCON: length 5.8
  TOP w0.1: U2B1.7 247.01,257.55 247.74,258.28 247.74,260.58 247.12,261.2 246.88,261.2 246.63,261.46 R2A60.2
SPI_HOLD_TPM_N: length 3.1
  TOP w0.1: 87.41,64.9 J7G1.41
SPI_IO2: length 77.7
  TOP w0.089: 91.65,130.29 91.65,131.04 94.97,134.36 94.97,135.17 94.86,135.27 94.86,135.32 U6E1.AY48
  TOP w0.1: v1(70.1,84.4) 69.57,83.87 69.57,80.75 70.51,79.8 70.94,79.8 71.18,79.57 U7G2.5 ; v1(71.42,84.4) 71.42,85.9 71.69,86.17 71.69,89.91 73.02,91.25 73.02,94.99 73.4,95.38 80.39,95.38 83.59,98.58 83.59,105.95 83.24,106.3 83.24,108.04 85.34,110.14 85.34,113.41 85.97,114.04 85.97,115.19 R7F39.1 85.89,116.38 85.89,117.68 R7F33.2 R7F34.2 86.36,118.66 89.58,121.89 89.58,127.66 91.65,129.72 91.65,130.29
  BOTTOM w0.1: v1(70.1,84.4) v1(71.42,84.4)
SPI_IO2_EC: length 85.7
  BOTTOM w0.1: R9U3.2 18.18,80.63 20.81,78.01 31.6,78.01 31.95,78.36 36.45,78.36 36.93,77.88 39.51,77.88 40.41,78.78 51.48,78.78 51.58,78.68 51.58,78.48 51.48,78.38 40.63,78.38 40.53,78.28 40.53,78.08 40.63,77.98 52.74,77.98 53.82,79.06 55.44,79.06 56.24,79.86 56.93,79.86 57.18,80.1 58.27,80.1 58.37,80.2 58.37,80.4 58.27,80.5 58.09,80.5 57.99,80.6 57.99,80.8 58.09,80.9 67.94,80.9 69.97,78.87 73.02,78.87 73.07,78.92 U7U2.9
SPI_IO2_SW: length 7
  TOP w0.1: R7G19.1 72.26,78.61 R7G24.2 72.79,77.98 v1(73.05,77.72) 73.27,77.95 73.27,78.36 73.83,78.92 U7G2.6
  BOTTOM w0.1: R7U35.2 72.51,78.26 v1(73.05,77.72) 73.59,78.27 U7U2.8
SPI_IO3: length 76
  TOP w0.089: U6E1.BA46 94.36,136.21 94.36,135.72 94.42,135.66 94.42,135.18 94.58,135.01 94.58,134.51 91.14,131.07 91.14,130.29
  TOP w0.1: 74.67,81.52 72.89,81.52 72.37,82.04 71.37,82.04 71.07,82.34 70.39,82.34 69.97,82.75 69.97,83.18 70.59,83.81 70.59,86.09 70.99,86.49 70.99,90.2 72.32,91.54 72.32,95.28 73.14,96.11 80.13,96.11 81.81,97.79 81.81,100.61 82.54,101.34 82.54,108.55 84.44,110.44 84.44,114.44 R7F38.1 83.61,116.38 83.61,117.68 R7F31.2 84.17,119.35 86.05,119.35 88.88,122.18 88.88,127.95 91.14,130.21 91.14,130.29
SPI_IO3_EC: length 90.3
  BOTTOM w0.1: R9U1.2 19.32,79.98 20.95,78.36 31.1,78.36 32.24,79.5 35.94,79.5 37.21,78.23 39.37,78.23 40.29,79.15 42.56,79.15 42.81,79.41 55.3,79.41 56.1,80.21 56.79,80.21 58.2,81.62 65.61,81.62 65.71,81.72 65.71,81.92 65.61,82.02 58.75,82.02 58.65,82.12 58.65,82.32 58.75,82.42 66.72,82.42 67.3,83.01 69.52,83.01 69.62,82.9 69.62,82.71 69.52,82.61 67.47,82.61 67.37,82.51 67.37,82.31 67.47,82.21 69.49,82.21 69.59,82.11 69.59,81.91 69.49,81.81 66.72,81.81 66.62,81.71 66.62,81.51 66.72,81.41 69.32,81.41 69.86,80.87 70.51,80.87 70.61,80.97 70.61,81.2 70.71,81.3 70.91,81.3 71.01,81.2 71.01,80.97 71.11,80.87 72.21,80.87 72.31,80.97 72.31,81.45 72.41,81.55 72.61,81.55 72.71,81.45 72.71,80.97 72.81,80.87 73.01,80.87 73.11,80.97 73.11,81.45 73.21,81.55 73.41,81.55 73.51,81.45 73.51,80.97 73.61,80.87 U7U2.12
SPI_IO3_SW: length 6.4
  TOP w0.1: U7G2.3 73.78,80.87 v1(73.17,80.26) 72.67,80.77 R7G16.1 R7G17.1
  BOTTOM w0.1: U7U2.11 73.22,80.22 v1(73.17,80.26) R7U33.2 R7U34.1
SPI_MISO: length 82
  TOP w0.089: 91.39,130.29 91.39,131.05 94.77,134.44 94.77,135.09 94.61,135.26 94.61,135.74 94.55,135.8 94.55,136.29 94.46,136.37 94.46,136.5 94.45,136.51 U6E1.BA45
  TOP w0.1: U7G2.9 78.94,78.92 78.66,79.2 78.66,82.37 78.04,82.99 75.26,82.99 75.03,83.21 71.72,83.21 70.94,83.99 70.94,85.93 71.34,86.33 71.34,90.06 72.67,91.39 72.67,95.14 73.29,95.76 80.27,95.76 83.24,98.73 83.24,105.8 82.89,106.15 82.89,108.29 84.79,110.19 84.79,117.65 R7F32.2 84.96,119 86.19,119 89.23,122.04 89.23,127.81 91.39,129.97 91.39,130.29
SPI_MISO_EC: length 98.7
  BOTTOM w0.1: R9U6.2 16.05,82.24 20.63,77.66 21.59,77.66 22.28,76.96 24.89,76.96 25.14,77.21 30.35,77.21 32.71,74.85 36.24,74.85 38.12,76.73 46.43,76.73 46.53,76.83 46.53,77.03 46.43,77.13 36.16,77.13 36.06,77.23 36.06,77.43 36.16,77.53 52.78,77.53 53.96,78.71 55.59,78.71 56.39,79.51 61.6,79.51 62.64,80.55 67.8,80.55 70.62,77.73 71.87,77.73 72.46,77.14 73.66,77.14 74.11,77.6 79.3,77.6 79.93,76.96 81.66,76.96 82.16,77.47 82.16,78.74 81.34,79.57 U7U2.5
SPI_MISO_FLASH: length 19.2
  TOP w0.1: v1(93.59,83.44) EU7G3.2 94.74,83.44 95.14,83.03 U7G4.8 ; v1(84.58,81.28) 85.02,80.84 85.02,80.32 83.31,78.61 R7G20.2
  BOTTOM w0.1: v1(93.59,83.44) 93.59,83.06 92.2,81.66 84.96,81.66 v1(84.58,81.28)
SPI_MISO_SW: length 5.3
  TOP w0.1: U7G2.8 80.73,78.27 v1(81.4,77.6) 81.66,77.85 R7G21.2 R7G20.1
  BOTTOM w0.1: v1(81.4,77.6) 81.66,77.85 81.66,78.74 81.48,78.92 U7U2.6
SPI_MISO_TPM: length 19
  TOP w0.1: J7G1.40 86.14,73.02 85.97,73.19 85.97,75.16 84.42,76.71 84.3,76.71 84.21,76.63 84.21,76.5 85.56,75.15 85.56,74.16 85.46,74.06 85.32,74.06 85.22,74.16 85.22,75.06 83.56,76.72 83.56,77.84 85.01,79.28 85.01,79.43 84.9,79.54 84.75,79.54 83.07,77.85 R7G21.1
SPI_MOSI: length 87
  TOP w0.089: v1(95.68,138.78) U6E1.AU41
  TOP w0.1: U7G1.9 79.32,85.52 78.23,86.61 78.23,88.14 79.24,89.15 80.13,89.15 81.67,90.69 85.11,90.69 85.89,91.47 85.89,94 85.69,94.2 85.69,95.66 84.91,96.44 84.91,100.16 v1(84.48,100.58)
  BOTTOM w0.089: v1(95.68,138.78) 95.39,138.78 94.87,138.25 94.87,137.92 94.58,137.63 94.58,136.82 94.49,136.73 94.49,136.36
  BOTTOM w0.1: v1(84.48,100.58) 83.82,101.24 83.82,111.7 83.92,111.8 84.12,111.8 84.22,111.7 84.22,107.87 84.32,107.77 84.52,107.77 84.62,107.87 84.62,111.7 84.72,111.8 84.92,111.8 85.02,111.7 85.02,107.87 85.12,107.77 85.32,107.77 85.42,107.87 85.42,112.1 85.32,112.2 83.92,112.2 83.82,112.3 83.82,112.77 84.7,113.65 84.7,115.19 R7T17.1 84.7,116.46 84.7,117.6 R7T15.2 R7T14.2 86.36,119.51 88.29,121.44 88.29,126.14 93.34,131.19 93.34,133.97 94.49,135.13 94.49,136.36
SPI_MOSI_EC: length 96
  BOTTOM w0.1: 80.51,86.17 79.27,86.17 79.12,86.32 77.95,86.32 77.05,85.43 77.05,85.28 77.19,85.14 77.33,85.14 78.08,85.89 78.22,85.89 78.36,85.74 78.36,85.6 78.03,85.27 78.03,85.13 78.45,84.7 78.45,84.56 77.17,83.28 77.03,83.28 76.89,83.42 76.89,83.56 77.88,84.56 77.88,84.7 77.74,84.84 77.6,84.84 76.66,83.9 72.22,83.9 72.13,83.82 67.62,83.82 66.57,82.77 58.61,82.77 57.99,82.16 54.53,82.16 54.42,82.04 54.42,81.86 54.52,81.76 57.4,81.76 57.5,81.66 57.5,81.46 57.4,81.36 54.52,81.36 54.42,81.26 54.42,81.06 54.52,80.96 56.64,80.96 56.74,80.86 56.74,80.66 56.64,80.56 54.04,80.56 53.94,80.46 53.94,80.26 54.04,80.16 55.05,80.16 55.15,80.06 55.15,79.86 55.05,79.76 42.67,79.76 42.41,79.5 38.86,79.5 37.94,80.42 32.67,80.42 31.62,79.37 26.79,79.37 26.69,79.47 26.69,79.67 26.79,79.77 31.11,79.77 31.21,79.87 31.21,80.07 31.11,80.17 26.39,80.17 26.29,80.07 26.29,79.47 26.19,79.37 22.6,79.37 22.55,79.32 21.55,79.32 21.1,79.77 R9U12.2
SPI_MOSI_FLASH: length 14.7
  TOP w0.1: U7G4.15 87.52,87.53 86.82,86.83 EU7G3.5 86.22,85.98 85.46,85.21 85.46,85.09 85.76,84.79 85.76,84.66 85.13,84.03 85,84.03 84.91,84.12 84.91,84.24 85.34,84.66 85.34,84.79 85.25,84.88 85.12,84.88 84.48,84.23 84.35,84.23 84.27,84.32 84.27,84.44 85.98,86.16 85.98,86.28 85.89,86.37 85.77,86.37 83.73,84.33 R7G11.2
SPI_MOSI_SW: length 4.8
  TOP w0.1: R7G13.2 R7G11.1 82.02,84.98 v1(81.83,84.98) 81.72,84.87 80.51,84.87
  BOTTOM w0.1: v1(81.83,84.98) 81.8,84.98 81.26,85.52 U7U1.6
SPI_MOSI_TPM: length 14.8
  TOP w0.1: R7G13.1 84.58,83.56 85.72,82.42 85.72,78.99 85.09,78.36 85.09,76.58 86.78,74.89 86.78,73.79 87.41,73.15 J7G1.42
SPI_TPM_GPIO: length 102.4
  TOP w0.1: R8E3.1 41.4,161.03 40.51,160.15 v1(33.14,160.15) ; v1(31.62,77.47) 31.13,76.98 31.13,75.04 31.62,74.55 R8G57.2
  LAY6 w0.125: v1(31.62,77.47) 31.62,77.6 32.25,78.23 32.63,78.23 33.4,78.99 33.4,87.62 32.76,88.26 32.76,92.72 33.23,93.19 33.23,105.6 32.02,106.81 31.62,106.81 31.36,107.06 31.36,109.73 31.24,109.85 31.24,115.65 29.79,117.09 29.79,120.87 32.89,123.96 32.89,129.04 32.05,129.88 32.05,135.06 30.09,137.01 30.09,140.7 31.54,142.15 31.54,158.54 v1(33.14,160.15)
SPI_TPM_GPIO_LT: length 85.9
  TOP w0.1: R8G83.1 v1(35.05,64.9) ; v1(31.62,76.71) 31.62,76.07 32,75.69 R8G57.1 ; R7H14.1 v1(83.05,64.01)
  LAY5 w0.125: v1(35.66,51.43) 35.66,50.95 36.42,50.19 41.23,50.19 43.22,52.19 46.19,52.19 47.38,53.38 47.38,53.69 48.92,55.23 48.92,56.2 49.59,56.87 53.18,56.87 54,57.68 62.31,57.68 62.77,58.14 65.81,58.14 66.76,59.08 70.71,59.08 72.08,60.45 73.69,60.45 75.27,62.03 76.33,62.03 78.31,64.01 v1(83.05,64.01)
  LAY6 w0.125: v1(31.62,76.71) 31.62,76.46 33.7,74.39 33.7,72.15 33.12,71.57 33.12,68.58 32.74,68.2 32.74,67.09 34.36,65.47 34.48,65.47 v1(35.05,64.9) 35.18,64.77 35.18,55.37 36.32,54.23 36.32,52.09 v1(35.66,51.43)
SPI_TPM_GPIO_R1: length 3.1
  TOP w0.1: EU8G3.3 34.3,67.86 35.05,67.11 R8G83.2 R8G76.1
