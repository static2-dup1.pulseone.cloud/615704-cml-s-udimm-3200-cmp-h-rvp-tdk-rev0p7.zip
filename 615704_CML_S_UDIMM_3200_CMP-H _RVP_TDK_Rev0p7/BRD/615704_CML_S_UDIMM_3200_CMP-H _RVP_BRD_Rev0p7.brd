# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Nets (continued)
VCORE_ISEN4P: C3M21.2(B) EU3M2.4 R3M28.2(B) R3M33.2(B)
VCORE_ISEN4P_SUM: EU1B1.9 EU4M1.15
VCORE_ISEN5N: C2M6.1 C2M8.1 EU2M1.2 ISO2B5.2(B<0>) R2M11.1
VCORE_ISEN5P: C2M6.2(B) EU2M1.1 R2M11.2(B) R2M12.2(B)
VCORE_ISEN6N: C2M5.1 C2M9.1 EU2M1.3 ISO2B4.2(B<0>) R2M10.1
VCORE_ISEN6P: C2M5.2(B) EU2M1.4 R2M10.2(B) R2M13.2(B)
VCORE_ISEN7N: C4M16.1 C4M19.1 EU4M1.2 ISO4B4.2(B<0>) R4M18.1
VCORE_ISEN7P: C4M16.2(B) EU4M1.1 R4M18.2(B) R4M20.2(B)
VCORE_ISEN8N: C4M17.1 C4M20.1 EU4M1.3 ISO4B3.2(B<0>) R4M19.1
VCORE_ISEN8P: C4M17.2(B) EU4M1.4 R4M19.2(B) R4M21.2(B)
VCORE_NTC1N: ISO2B3.2(B<0>) RT2B1.1
VCORE_NTC1P: R2B49.1 RT2B1.2(B<0>)
VCORE_PH1: EU2B3.7 R3B35.1
VCORE_PH1_SNB: C2M10.1 R2M17.2(B)
VCORE_PH1_VDRV: C2B13.1 EU2B3.29 R2B16.1
VCORE_PH1_VIN: C2B8.1 EU2B3.3 R2B6.2(B)
VCORE_PH2: EU3B2.7 R3B34.1
VCORE_PH2_SNB: C3M27.1 R3M36.2(B)
VCORE_PH2_VCIN: EU3B2.3 R3B27.2(B) R3B36.1
VCORE_PH2_VDRV: C3B33.1 EU3B2.29 R3B42.1
VCORE_PH3: EU3B3.7 R3B33.1
VCORE_PH3_SNB: C3M28.1 R3M37.2(B)
VCORE_PH3_VCIN: C3B22.1 EU3B3.3 R3B28.2(B)
VCORE_PH3_VDRV: C3B32.1 EU3B3.29 R3B40.1
VCORE_PH4: EU3B1.7 R4B26.1
VCORE_PH4_SNB: C4M21.1 R4M24.2(B)
VCORE_PH4_VCIN: C3B24.1 EU3B1.3 R3B26.2(B)
VCORE_PH4_VDRV: C3B29.1 EU3B1.29 R3B41.1
VCORE_PH5: EU2B4.7 R2B11.1
VCORE_PH5_SNB: C2B19.1 R2B31.2(B)
VCORE_PH5_VCIN: EU2B4.3 R2B7.2(B) R2B9.1
VCORE_PH5_VDRV: C2B16.1 EU2B4.29 R2B19.1
VCORE_PH6: EU2B2.7 R2B10.1
VCORE_PH6_SNB: C2M11.1 R2M16.2(B)
VCORE_PH6_VCIN: C2B11.1 EU2B2.3 R2B5.2(B)
VCORE_PH6_VDRV: C2B14.1 EU2B2.29 R2B17.1
VCORE_PH7: EU4B4.7 R4B25.1
VCORE_PH7_SNB: C4M22.1 R4M25.2(B)
VCORE_PH7_VCIN: C4B22.1 EU4B4.3 R4B21.2(B)
VCORE_PH7_VDRV: C4B30.1 EU4B4.29 R4B28.1
VCORE_PH8: EU4B3.7 R4B24.1
VCORE_PH8_SNB: C4M23.1 R4M23.2(B)
VCORE_PH8_VCIN: C4B24.1 EU4B3.3 R4B20.2(B)
VCORE_PH8_VDRV: C4B28.1 EU4B3.29 R4B29.1
VCORE_PSYS: C2C1.2(B) EU1B1.32 R2C15.2(B)
VCORE_PWM1: EU1B1.55 R3M15.2(B)
VCORE_PWM1_R: EU3M1.13 R3M13.1 R3M15.1
VCORE_PWM2: EU1B1.54 R3M14.2(B)
VCORE_PWM2_R: EU3M2.13 R3M14.1
VCORE_PWM3: EU1B1.56 R2M3.2(B)
VCORE_PWM3_R: EU2M1.13 R2M3.1
VCORE_PWM4: EU1B1.53 R4M11.2(B)
VCORE_PWM4_R: EU4M1.13 R4M11.1
VCORE_PWM_PH1: EU2B3.1 R2M8.2(B)
VCORE_PWM_PH1_R: EU3M1.6 R2M8.1
VCORE_PWM_PH2: EU3B2.1 R3M17.2(B)
VCORE_PWM_PH2_R: EU3M1.7 R3M17.1
VCORE_PWM_PH3: EU3B3.1 R3M23.2(B)
VCORE_PWM_PH3_R: EU3M2.6 R3M23.1
VCORE_PWM_PH4: EU3B1.1 R3M18.2(B)
VCORE_PWM_PH4_R: EU3M2.7 R3M18.1
VCORE_PWM_PH5: EU2B4.1 R2B18.2(B)
VCORE_PWM_PH5_R: EU2M1.6 R2B18.1
VCORE_PWM_PH6: EU2B2.1 R2M5.2(B)
VCORE_PWM_PH6_R: EU2M1.7 R2M5.1
VCORE_PWM_PH7: EU4B4.1 R4M16.2(B)
VCORE_PWM_PH7_R: EU4M1.6 R4M16.1
VCORE_PWM_PH8: EU4B3.1 R4M13.2(B)
VCORE_PWM_PH8_R: EU4M1.7 R4M13.1
VCORE_SENSE_IC_N: EU1B1.16 R2B24.1 R2B34.1
VCORE_SENSE_IC_P: EU1B1.15 R2B20.2(B) R2B25.2(B) R2B32.1
VCORE_SET1: EU1B1.23 R2B39.1 R2B42.2(B) R2B46.1
VCORE_SET2: EU1B1.24 R2B48.2(B) R2B50.1
VCORE_SET3: EU1B1.28 R2B60.1 R2B62.2(B)
VCORE_SET4: EU1B1.29 R2C3.2(B) R2C5.1
VCORE_SET5: EU1B1.31 R2C11.1 R2C14.2(B)
VCORE_SM_SCL: EU1B1.34 J1D9.2 R2C20.1 R2C24.2(B)
VCORE_SM_SDA: EU1B1.35 J1D9.1 R2C21.1 R2C25.2(B)
VCORE_TSEN: EU1B1.22 R2B37.2(B) RT3B1.1
VCORE_VCC_IC: C2B23.1 EU1B1.33 R1B20.2(B) R1B31.2(B) R2C22.2(B) R2C23.2(B)
VCORE_VREF: EU1B1.26 ISO2B3.1 ISO2C1.1 R2B38.1 R2B40.1 R2B45.1 R2B53.1 R2B55.1 R2B61.1 R2C1.1 R2C2.1 R2C18.1 R2C19.1
VCORE_VRHOT_IC: EU1B1.17 R5B45.2(B)
VCORE_VSWH_PH1: EU2B3.16 EU2B3.24 ISO3B4.1 L3B4.1 R2M17.1
VCORE_VSWH_PH2: EU3B2.16 EU3B2.24 ISO3B3.1 L3B3.1 R3M36.1
VCORE_VSWH_PH3: EU3B3.16 EU3B3.24 ISO3B2.1 L3B2.1 R3M37.1
VCORE_VSWH_PH4: EU3B1.16 EU3B1.24 ISO3B1.1 L3B1.1 R4M24.1
VCORE_VSWH_PH5: EU2B4.16 EU2B4.24 ISO2B2.1 L2B3.1 R2B31.1
VCORE_VSWH_PH6: EU2B2.16 EU2B2.24 ISO2B1.1 L2B2.1 R2M16.1
VCORE_VSWH_PH7: EU4B4.16 EU4B4.24 ISO4B2.1 L4B4.1 R4M25.1
VCORE_VSWH_PH8: EU4B3.16 EU4B3.24 ISO4B1.1 L4B3.1 R4M23.1
VCORE_ZCD#_PH1: EU2B3.2(ZCD_EN_N) R2M4.2(B)
VCORE_ZCD#_PH2: EU3B2.2(ZCD_EN_N) R3M19.2(B)
VCORE_ZCD#_PH3: EU3B3.2(ZCD_EN_N) R3M16.2(B)
VCORE_ZCD#_PH4: EU3B1.2(ZCD_EN_N) R3M20.2(B)
VCORE_ZCD#_PH5: EU2B4.2(ZCD_EN_N) R2B12.2(B)
VCORE_ZCD#_PH6: EU2B2.2(ZCD_EN_N) R2M6.2(B)
VCORE_ZCD#_PH7: EU4B4.2(ZCD_EN_N) R4M12.2(B)
VCORE_ZCD#_PH8: EU4B3.2(ZCD_EN_N) R4M14.2(B)
VCT_PINL1: C4A6.2(B) J4A2.19
VCT_PINL10: J4A2.28 R4A11.2(B)
VHV_TYPEC_FB_BP: EU6A2.7(VSENSE) R6A78.1 R6A81.2(B) R6A82.2(B)
VN_ELVSS_EDP_AMOLED: J1A4.1 R1A4.2(B)
VOL_DOWN: J9D4.3 R9D35.2(B) R9D36.2(B) R9D37.2(B)
VOL_DOWN_EC: J6J2.216 R9D36.1 U8F6.25
VOL_DOWN_PCH: R9D37.1 R9G32.2(B)
VOL_UP: J9D4.2 R9D32.2(B) R9D33.2(B) R9D34.2(B)
VOL_UP_EC: J6J2.208 R9D33.1 U8F6.11
VOL_UP_PCH: R9D34.1 U6E1.AD48
VPP_EN: R2G30.2(B) R5F20.1
VPP_EN_L: R2G30.1 U2G2.4
VPP_PG_PS: EU5F1.6 R2G38.2(B) R5F10.2(B) U2G2.2
VPP_VR_EN: EU5F1.1 R5F20.2(B)
VPP_VR_FB: EU5F1.4 R5F18.1 R5F21.2(B)
VR_ENABLE: C5C37.1 Q8C9.6 R5B27.1 R5C53.1 R5C57.2(B) R5C61.2(B) R5C62.2(B) R5C63.2(B) R8D12.2(B) R8D50.1 TP8D1.1(TP) U5C2.3
VR_ENABLE_C10: R5B91.1 R5C46.2(B) U5C2.4(Y)
VR_ENABLE_DIODE: CR8D2.1 R8D50.2(B)
VR_ENABLE_IC_R: C2B21.1 EU1B1.21 R5C46.1 R5C53.2(B)
VR_ENABLE_PU: R2G23.1 U2G2.11
VR_READY: R8C37.1 R8C42.1 R8C44.2(B) R8C46.1 R8C80.1 R8N2.2(B) R9F37.1 TP9F4.1(TP)
VR_READY_C10: R8N2.1 U8N1.4(Y)
VR_READY_EC: J6J2.24 J8J13.2 R6J5.1 R9F37.2(B) U8F6.48
VR_READY_IMVP: R2C6.1 R5B80.2(B) R8C41.2(B) R8C44.1 R8C45.1 U8N1.3
VR_READY_PWRGD_PS: J6J2.133 R6J5.2(B)
VR_SVID_ALERT_N: EU1B1.19 R2B27.2(B)
VR_SVID_ALERT_N_R: J1G4.3 Q5M4.3 R1G6.2(B) R2B22.2(B) R2B27.1 R5B85.2(B)
VR_SVID_CLK: EU1B1.18 R2B28.2(B)
VR_SVID_CLK_R: J1G5.3 R1H2.2(B) R2B23.2(B) R2B28.1 R5B83.2(B)
VR_SVID_DATA: EU1B1.20 R2B26.2(B)
VR_SVID_DATA_R: J1G3.3 R1G5.2(B) R2B21.2(B) R2B26.1 R5B87.2(B)
VR_TEMP_V_1P05_PCH_EC: J6J2.37 R6J24.2(B) R6J25.2(B)
VR_THERM_IN: R6J25.1 R8G4.1 U8F6.116
VR_THERM_IN_R: C8G4.1 R8G4.2(B) R8G6.2(B) RT8G1.1
VR_VCCSFR_OC_EN_R: C5C23.1 EU5C2.1 R8C58.2(B) R8C60.2(B) R8C72.2(B) R8D96.2(B) U4C1.2
VR_VCCSFR_OC_PWRGD_R: C5C27.1 EU5C2.6 R5C25.1 R5C33.2(B)
VREF_ADC_SENSE_SMC: EU8F1.8 R9F3.1 R9F5.2(B)
VREG_5VDUAL_NCH: C4G16.1 EU4G2.4 R4G15.2(B)
VREG_5VDUAL_PCH_EC: J6J2.125 R6J13.1
VREG_HD_ACT_LED_R: CR9G4.1 R9G33.2(B)
VREG_NGFF_NCH: C7A11.2(B) EU7B1.4 EU7B2.4 Q7B1.3 Q7B3.3 R7A14.2(B) R7B2.2(B)
VREG_NGFF_PCH: C7B3.1 CR7B1.2 Q7B4.4 R7B8.2(B)
VSW_TYPEC_HV: C6A36.2(B) EU6A2.11 EU6A2.12 L6A1.1
VTT_EN: R2G19.2(B) R2G24.2(B) R2G28.1
VTT_EN_L: R2G24.1 U2G2.5(VTT_EN)
VTT_RAIL_SENSE: EU2G1.2(VTTSNS) R2G14.1
WAKE_SLTA_L: J5J1.5 R5B52.1 R5V8.2(B) R6H35.2(B)
WAKE_SLTA_PEG_L: J5B2.B11(WAKE_N) R5B52.2(B) R5B53.2(B)
WAKE_SLTB_L: J5J1.6 R5H13.2(B) R5V1.2(B) R6H3.2(B)
WAKE_SLTC_L: J5J1.13 R5J3.1 R5J4.2(B)
WAKE_SLTD_L: J5J1.14 R5H13.1
WIFI_RF_KILL_N: J8H5.1 Q7B7.2(S) R7B31.2(B) R7B42.2(B)
WIFI_RF_KILL_N_HDR: J8H5.2 R8H68.1
WIFI_RF_KILL_R_N: R7B31.1 U6E1.AL9
WLAN_LED1: CR7C1.2(C) J7C1.6
WLAN_LED1_R: CR7C1.1 R7C10.1
WLAN_LED2: CR7C4.2(C) J7C1.16
WLAN_LED2_R: CR7C4.1 R7C11.1
WLAN_PERST0_N: J7C1.52 R7B48.1
WLAN_PEWAKE_N: J7C1.55 R7B27.1 R7B28.2(B)
WLAN_RST_N: R7B48.2(B) R8E52.1 R8E58.2(B) R8E59.2(B)
WLAN_RST_R_N: R8E59.1 U8F1.4(Y)
XCLK_RBIAS: R6D65.2(B) U6E1.T3
XDP_BMP0_N: J1C1.21 R1C79.2(B)
XDP_BMP1_N: J1C1.23 R1C74.2(B)
XDP_BOOT_HALT_N_SYS_PWROK: C1C11.1 J1C1.47 R1C36.2(B) R1C37.2(B)
XDP_FN0: J6H2.9 R6H24.2(B)
XDP_FN1: J6H2.11 R6H25.2(B)
XDP_FN2: J6H2.15 R6H26.2(B)
XDP_FN3: J6H2.17 R6H27.2(B)
XDP_FN4: J6H2.27 R6H28.2(B)
XDP_FN5: J6H2.29 R6H29.2(B)
XDP_FN6: J6H2.33 R6H30.2(B)
XDP_FN7: J6H2.35 R6H31.2(B)
XDP_FN8: J6H2.10 R6H10.2(B)
XDP_FN9: J6H2.12 R6H11.2(B)
XDP_FN10: J6H2.16 R6H12.2(B)
XDP_FN11: J6H2.18 R6H18.1
XDP_FN12: J6H2.28 R6H14.2(B)
XDP_FN13: J6H2.30 R6H15.2(B)
XDP_FN14: J6H2.34 R6H16.2(B)
XDP_FN15: J6H2.36 R6H17.2(B)
XDP_FN_CLK1: J6H2.4 R6H9.2(B)
XDP_FN_CLK2: J6H2.24 R6H13.2(B)
XDP_HOOK2_EAR_N: J1C1.45 R1C38.2(B) R1C94.2(B)
XDP_PM_RSMRSTN_VCCSTPWRGD: J1C1.39 R1C46.2(B) R1C47.2(B)
XDP_PMODE_PLTRST_N: J1C1.46 R1C44.2(B) R1C45.2(B)
XDP_POWER_BTN_N: C1C14.1 J1C1.41 R1C43.2(B)
XDP_PRDY_N: J1C1.5 R1C97.2(B) R1C99.1
XDP_PREQ_N: J1C1.3 R1C101.2(B) R1C102.1
XDP_PRESENT1_N: C1D14.1(CATHODE) J1C1.60 J1D4.1 R1D3.1 R7G18.1
XDP_PRESENT2_N: J1C1.1 R1D1.2(B)
XDP_PRS_BJT: Q7G2.2 R7G18.2(B)
XDP_RESET_BTN_N: C1C13.1 J1C1.48 R1C40.1
XDP_SPI0_IO2: C1D14.2 R7F34.1
XDP_SPI0_MOSI: R1C36.1 R7T14.1
XDP_TCLK: J1C1.57 R1C32.2(B) R1C34.1
XDP_TCLK1: J1C1.55 R1C35.1
XDP_TDI: J1C1.56 R1C23.2(B) R1C28.1
XDP_TDO: J1C1.52 R1C25.2(B) R1C30.1
XDP_TMS: J1C1.58 R1C22.2(B) R1C27.1
XDP_TRST_N: J1C1.54 R1C24.2(B) R1C29.1
XDP_VCCST_OVERRIDE: Q7G2.6 R7G15.2(B) U5D1.2 U7G5.2
XTAL1_32K_R: R8F45.2(B) U8F6.123
XTAL2_32K_R: R8F42.2(B) R8F43.2(B) U8F6.125(XTAL2)
XTAL_32K_C: C8F15.1 R8F43.1 Y8F1.2
XTAL_32K_EC: C8F17.1 R8F45.1 Y8F1.1
XTAL_IN_D: R6D59.2(B) R6D62.2(B)
XTAL_IN_PCON: C3A18.2(B) U3A5.E8 Y3A1.1
XTAL_OUT_PCON: C3A17.2(B) U3A5.F8 Y3A1.3(XTAL2)
XTAL_PCH_24M_IN: R6D59.1 R6D60.1 U6E1.U10
XTAL_PCH_24M_IN_R: C6D21.1 R6D57.1 R6D60.2(B) Y6D1.3
XTAL_PCH_24M_OUT: R6D61.1 R6D62.1 U6E1.U9
XTAL_PCH_24M_OUT_R: C6D22.1 R6D57.2(B) R6D61.2(B) Y6D1.1
XTAL_PCON_C: C3A17.1 C3A18.1 R3L1.2(B) R3L4.2(B)

Pads without a net: CR2A1 6; CR6J1 2; CR8F3 1; E4C1 3 4; E4C2 3 4; EU1B1 52 57 60; EU1D1 4 6 30 31; EU1D2 4 6 30 31; EU1E2 8; EU2A6 5 6; EU2A7 25; EU2B1 4; EU2B2 4 6 30 31; EU2B3 4 6 30 31; EU2B4 4 6 30 31; EU2M1 8; EU3B1 4 6 30 31; EU3B2 4 6 30 31; EU3B3 4 6 30 31; EU3B4 37 38 39 40 41; EU3M1 8; EU3M2 8; EU4B3 4 6 30 31; EU4B4 4 6 30 31; EU4B5 37 38 39 40 41; EU4M1 8; EU5B2 14 15; EU5C4 4; EU5D3 4; EU6A1 40 41 44 45 46; EU6B1 8; EU6D1 9 10 12 13 15 16 18 19 24 25; EU7A1 2 4 6 8 10; EU7A2 2 4 6 8 10; EU8B1 8; EU8B4 8; J1B2 11 12 30; J1C1 40 42; J1G3 2 4; J1G4 2 4; J1G5 2 4; J3D1 A12 AA4 AA5 AA7 AA8 AB3 AB4 AH32 AH33 AL18 AN25 AU32 B9 B11 B12 C9 C10 C11 D8 D10 E4 E15 F8 F13 F15 G4 G13 G14 G16 H8 H14 H15 J15 K16 L33 M8 M16 M33 N4 P8 T33 V4 V5 W2 W3 W5 W6 Y3 Y4 Y6 Y7; J4G1 20; J4R1 22 23 24 25 27 28 29 30 32 33 34 35 37 38 39 40; J5B3 5 6 7 8 10 11 13 17 19 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 38 40 41 42 43 44 46 47 48 49 67 68 69; J5J2 8 9 20 21 22; J6G1 MH1 MH2; J6G2 MH1 MH2; J6H1 MH1 MH2; J6H2 3 5 21 23 40 41 42 45 46 47 48 51 52 53 54 55 56 57 58; J7C1 MH1 MH2; J7C7 1; J7H1 6 MH1 MH2; J7J6 2 6 8 12; J8H1 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67 MP1 MP2; J8H2 11 15 17 22 24 31 32 33 35 40 47 48 50 51 52 53; J8J13 15 18 20 27 29 38; J9B7 1 2 7 8; J9E9 4 8 9 11 13 15 16 17 18 19 20; NOREF#15 1; Q5C2 1 2 6; Q7G2 3 4 5; R1E32 3 4; R2A47 3 4; R2A58 3 4; R2B3 3 4; R2G8 3 4; R2G12 3 4; R4B10 3 4; R4C16 3 4; R4C19 3 4; R4C23 3 4; R4C24 3 4; R5A19 3 4; R5C14 3 4; R5D27 3 4; R5D29 3 4; R5F12 3 4; R5G14 3 4; R6A3 3 4; R6A4 3 4; R6A18 3 4; R6A29 3 4; R6A34 3 4; R6A77 3 4; R6A83 3 4; R6B20 3 4; R6B24 3 4; R6D34 3 4; R6D40 3 4; R6F16 3 4; R6F30 3 4; R6J1 3 4; R6T12 3 4; R7B25 3 4; R7C43 3 4; R7F5 3 4; R7G26 3 4; R7P6 3 4; R7R5 3 4; R7R36 3 4; R7R37 3 4; R7R48 3 4; R7T4 3 4; R7T22 3 4; R8A11 3 4; R8B5 3 4; R8B10 3 4; R8B30 3 4; R8B31 3 4; R8B32 3 4; R8C78 3 4; R8F50 3 4; R8F54 3 4; R8G17 3 4; R8G28 3 4; R8G69 3 4; R8G85 3 4; R8H29 3 4; R9A23 3 4; R9F34 3 4; TP1A1 1; TP1J1 1; TP1L1 1; TP1W1 1; TP3B4 1; TP3M1 1; TP4J1 1; TP4W1 1; TP5E1 1; TP5H1 1; TP5T1 1; TP8A1 1; TP8L1 1; TP9A1 1; TP9J1 1; TP9J2 1; TP9L1 1; TP9W1 1; TP9W2 1; TP4811 1; U1B2 1; U2G3 6 7; U5A2 A3 A5 A7 A9 A11 A13 AB3 AB5 AB23 AC3 AC5 B3 B5 B7 B9 B11 B13 B23 C1 C2 E1 E2 H5 J9 J11 L4 L5 P1 P2 V8; U5D1 5; U6E1 A25 AH14 AH15 B25 B26 B27 BC1 BC33 C26 C27 D29 E28 F26 G26 K29 L26 M26 M29 N32 P24 R13 R15 R24 R32 U35 U37 Y14 Y15 Y35 Y36; U7G2 11 12 13; U7G4 4 5 6 11 12 13 14; U7G5 5; U7H1 1; U7H4 10 11 13 14 15 16 17 18 19 20 21 22 23; U7U2 1 2 3; U8C2 1; U8C4 1; U8D1 1; U8D5 5; U8D6 3; U8D7 1; U8E1 6; U8E2 6; U8E4 6; U8E5 6; U8F3 1; U8F4 6; U8H5 6 8; U8H6 1 5 8; U8J1 1 5 8; U8L1 9 10; XY7F1 1 2

## Via types
v1: diameter 0.559, hole 0.305, TOP to BOTTOM, 9654 vias
v2: diameter 0.406, hole 0.203, TOP to BOTTOM, 154 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 842 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
5V_YLW_LED_BRD: length 1.8
  TOP w0.1: 26.76,43.78 27.71,43.78 27.94,43.56 R8H48.1
5V_YLW_LED_BRD_EN_N: length 1.8
  TOP w0.1: Q8H5.5 27.67,44.43 27.94,44.7 R8H44.2
5V_YLW_LED_BRD_R_N: length 3.5
  TOP w0.1: Q8H5.6 27.43,45.08 28.19,45.85 R8H41.2 28.82,45.46 28.82,45.21 R8H44.1
5V_YLW_LED_HDR: length 2
  TOP w0.1: R8H36.2 28.32,47.12 27.58,47.85 Q8H1.4
5V_YLW_LED_HDR_N: length 1.8
  TOP w0.1: R8H34.2 27.94,48.26 27.7,48.5 Q8H1.5
5V_YLW_LED_HDR_R_N: length 3.3
  TOP w0.1: Q8H1.6 27.68,49.15 27.94,49.4 R8H33.2 28.82,49.02 28.82,48.77 R8H34.1
5VDUAL_GATE: length 2.3
  TOP w0.2: Q4G3.1 R4G18.1 R4G17.2
5VDUAL_NCH: length 37.5
  TOP w0.5: R4G17.1 194.05,78.61 v1(194.05,79.25) R4G15.1
  TOP w0.508: Q4H1.6 180.08,59.05 180.97,59.94 v1(181.1,59.94) 181.1,59.05 R4H7.2
  BOTTOM w0.5: v1(181.1,59.94) 181.1,60.07 179.88,61.29 179.88,65.1 178.68,66.29 178.68,74.29 182.62,78.23 193.04,78.23 v1(194.05,79.25)
5VDUAL_PCH: length 44.9
  TOP w0.5: R4H47.2 175.51,48.89 v1(176.14,49.53)
  TOP w0.508: R4H50.1 R4H47.2 ; v1(178.43,79.5) 178.68,79.25 R4G16.1 ; R4H27.2 v1(183.13,55.37)
  BOTTOM w0.38: v1(183.13,55.37) 182.24,56.26 180.59,56.26 177.16,59.69 176.02,59.69 174.11,61.59 174.11,70.36 176.4,72.64 176.4,76.96 178.43,78.99 v1(178.43,79.5)
  BOTTOM w0.5: v1(176.14,49.53) 176.4,49.53 181.22,54.35 182.11,54.35 v1(183.13,55.37)
5VDUAL_SRC: length 10.5
  TOP w0.508: R4G10.1 R4G14.1 197.99,81.28 199.51,79.75 Q4G3.3
+5VDUAL_PCH: length 105.9
  TOP w0.38: C4G14.1 172.72,82.8 ; C4G14.1 170.43,82.8 ; C4G14.1 171.57,81.79 ; C4G14.1 171.57,84.2
  TOP w0.5: R2G18.1 v1(267.97,79.37)
  LAY5 w0.5: v1(177.41,86.74) 179.78,89.11 186.56,89.11 187.06,89.61 197.78,89.61 199.26,88.14 206.5,88.14 209.25,85.39 209.25,85.05 211.44,82.86 218.25,82.86 219.07,83.67 220.6,83.67 220.95,84.02 224.58,84.02 226.08,82.52 228.49,82.52 231.09,79.93 242.23,79.93 244.83,82.53 253.13,82.53 256.7,78.96 257.77,78.96 258.79,77.94 266.15,77.94 267.58,79.37 v1(267.97,79.37)
+V1.05A_CPU_XDP_AB: length 7.9
  TOP w0.2: R1C41.1 299.31,211.96 298.8,212.47 297.43,212.47 C1C12.1 296.41,211.45 296.41,210.44 295.21,209.24 J1C1.43
+V1.05A_CPU_XDP_CD: length 6.4
  TOP w0.3: J1C1.44 285.55,209.24 C1C15.1
  TOP w0.4: C1C15.1 285.11,209.55 284.6,209.04 283.08,209.04 R1C48.1
+V1.8DX_3.3DX_DMIC_SDW: length 9.3
  TOP w0.5: R8B9.2 C8B6.1 26.54,249.93 J9B1.4
+V1.8DX_CORE_CODEC_FIL: length 6.4
  TOP w0.2: 127.82,277.81 127.6,278.04 EU6A1.17
  TOP w0.3: FB6A2.2 131.52,275.97 129.41,275.97 129.03,276.35 C6A25.1 128.77,276.86 C6A20.1 128.01,277.62 127.82,277.81
+V1P2_PCON_AVDD: length 13
  TOP w0.305: v1(240.41,265.18) 240.81,265.58 240.81,265.59 ; v1(240.41,269.99) U3A5.G5 240.01,269.59 240.81,268.79 ; U3A5.G7 v1(238.81,269.99) ; v1(239.62,265.19) 240.01,265.58 U3A5.B5 ; v1(238.81,267.59) 239.21,267.19 239.21,267.19
  TOP w0.38: R3A44.1 234.18,263.9 233.8,264.29 v1(233.8,264.79)
  BOTTOM w0.38: v1(240.41,265.18) 240.28,265.05 C3L12.1 C3L14.1 ; C3L9.1 R3L4.1 234.06,264.79 v1(233.8,264.79) ; v1(239.62,265.19) 239.39,264.96 239.39,264.41 ; C3L2.1 238.76,270.04 v1(238.81,269.99) ; C3L1.1 v1(240.41,269.99) ; C3L7.1 238.88,267.51 v1(238.81,267.59)
+V1P2_PCON_DVDD: length 6.5
  TOP w0.305: U3A5.F5 v1(239.59,268.38) ; v1(238.81,265.18) 238.41,265.59 U3A5.B7
  TOP w0.38: R2A58.2 263.9,263.65
  LAY6 w0.38: v1(263.65,263.9) v1(263.65,264.67)
  BOTTOM w0.38: v1(239.59,268.38) 239.62,268.4 C3L4.1 ; C3L13.1 FB3L1.1 238.81,264.72 v1(238.81,265.18) 238.88,265.25 C3L8.1
  vias: v1(238.88,263.65)
+V1P2S_ALS_D: length 20.1
  TOP w0.2: v1(252.22,266.32) 252.4,266.13 EU2A7.30 ; EU2A7.6 v1(259.84,265.73) ; v1(257.55,269.75) 257.5,269.7 EU2A7.15 ; EU2A7.18 v1(256.3,269.75) ; EU2A7.11 259.44,267.73 259.74,267.44 v1(259.74,267.21)
  TOP w0.38: 264.18,266.11 264.18,265.68 264.56,265.3 R2A47.2 264.99,266.24
  BOTTOM w0.38: v1(256.3,269.75) 255.9,269.34 C2L2.1 ; 259.84,266.44 259.74,266.55 v1(259.74,267.21) ; C2L8.1 C2L7.1 259.79,265.68 v1(259.84,265.73) ; C2L2.1 C2L1.1 256.92,269.11 v1(257.55,269.75) ; C2L2.1 C2L3.1 253.49,268.98 252.98,268.48 C2L4.1 252.73,266.83 v1(252.22,266.32) 252.6,265.94 C2L6.1 ; C2L5.1 259.08,266.7 ; 252.98,264.92 253.36,264.54
  vias: v1(263.29,265.81) v1(264.05,265.95)
+V1P2S_ALS_RX: length 7.7
  TOP w0.2: EU2A7.46 v1(257.5,262.13) ; EU2A7.43 v1(256.3,262.13)
  BOTTOM w0.38: C2L10.1 257.42,262.21 v1(257.5,262.13) ; C2L10.1 C2L11.1 ; C2L10.1 C2L9.1 ; C2L11.1 256.54,262.36 v1(256.3,262.13) ; C2L11.1 C2L12.1 254.5,262.89 FB2L2.2
+V1P2S_HDMI_VR: length 9
  TOP w0.2: R2A57.2 270.89,264.16 270.63,264.41 268.35,264.41 267.97,264.03 C2A25.1
  TOP w0.38: 267.2,265.3 R2A47.1 R2A58.1 ; R2A58.1 266.44,262.51 ; R2A58.1 C2A25.1
+V1P05A: length 140
  TOP w0.3: 128.9,102.11 R6F37.2 131.57,102.11 ; 128.9,105.54 R6F30.1 131.82,105.54
  TOP w0.38: R6J30.1 v1(112.52,9.52)
  LAY5 w0.38: v1(120.14,92.45) 120.14,94.49 129.23,103.58 v1(130.42,103.58)
  LAY6 w0.38: v1(120.14,92.45) 119.76,92.07 118.11,92.07 116.85,90.82 116.85,90.28 117.47,89.66 118.08,89.66 119.61,88.13 119.61,86.9 120.4,86.12 120.4,84.04 120.96,83.48 120.96,79.94 123.28,77.62 123.28,71.6 122.4,70.71 122.4,65.02 121.92,64.54 121.92,60.91 125.85,56.98 125.85,55.5 129.28,52.07 129.28,49.27 128.52,48.51 128.52,43.31 126.23,41.02 126.23,33.53 128.65,31.11 128.65,29.21 127,27.56 116.07,27.56 107.82,19.3 107.82,16.49 105.39,14.06 105.39,11.6 106.94,10.05 107.58,10.05 107.78,10.25 111.79,10.25 v1(112.52,9.52)
  vias: v1(130.42,104.47) v1(131.19,104.47) v1(131.19,103.58) v1(131.95,104.47) v1(131.95,103.58) v1(179.9,204.93) v1(180.61,204.93) v1(183.26,204.93) v1(183.99,204.93) v1(185.92,184.93) v1(186.63,184.93) v1(187.35,184.93) v1(188.06,184.94)
+V1P05A_OUT: length 3.3
  TOP w0.38: C6F5.1 R6F37.1 130.3,98.17 ; 131.19,87.37 131.31,87.37
+V1P05A_VAL: length 643.6
  TOP w0.1: R6D33.1 v1(102.36,174.5) v1(102.36,173.73)
  TOP w0.38: R1C41.2 300.25,211.96 300.89,211.33 v1(300.99,211.33)
  TOP w0.4: 183.76,195.71 R4C29.1 R4C30.1 ; R4C27.1 177.54,195.96 177.24,195.96 v1(177.21,195.93)
  TOP w0.5: R1C42.1 301.49,211.33 v1(300.99,211.33) ; R5F11.1 135.86,110.59 v1(136.14,110.59) ; 183.76,195.71 183.12,195.71 182.62,196.21 R4C28.1 v1(182.62,197.36)
  TOP w0.508: R6H33.1 121.15,39.88 123.34,39.88 v1(125.63,42.16) ; v1(106.04,174.62) 105.79,174.88 R6D54.1 ; R6H7.1 v1(121.86,54.35) ; v1(73.53,125.73) 75.69,127.89 75.69,128.01 77.34,129.67 80.51,129.67 81.91,131.06 R7E59.1 ; v1(128.01,51.05) 136.14,51.05 138.3,48.89 143.38,48.89 144.78,50.29 151.96,50.29 163.66,38.59 173.14,38.59 180.78,46.23 189.87,46.23 192.53,48.89 v1(192.53,49.27) ; R1C48.2 v1(280.16,209.04) ; R5F11.1 v1(136.14,109.85)
  TOP w2: 77.34,102.23 73.44,102.23 71.5,104.17 69.51,104.17 62.37,111.3 61.1,111.3 56.64,115.77 56.64,118.74
  LAY5 w0.75: v1(123.44,127) v1(122.42,127) 122.42,131.16 126.21,134.95 131.14,134.95 135.89,139.69 135.89,151.16 128.01,159.03 128.01,161.67 ; 128.01,161.67 127.35,161.67 124.68,164.34 ; 128.01,161.67 125.34,164.34 124.68,164.34 ; 124.07,164.34 124.68,164.34
  LAY6 w0.5: v1(73.53,125.73) 71.75,127.51 71.12,127.51 70.73,127.13 69.97,127.13 69.4,127.7 69.4,129.73 68.19,130.94 68.19,131.95 65.27,134.87 v1(63.37,134.87) ; v1(286.68,65.88) 286.81,65.88 291.84,70.9 291.84,76.71 290.57,77.98 290.57,86.61 294.6,90.64 294.6,95.76 291.85,98.51 291.85,100.71 286.22,106.34 286.22,135.3 285.82,135.7 285.82,140.87 284.95,141.74 284.95,143.67 284.6,144.02 284.6,149.26 286.32,150.98 286.32,156.57 286.96,157.21 286.96,163.47 286.07,164.36 286.07,165.95 290.37,170.25 290.37,173.27 291.4,174.31 291.4,190.22 286.19,195.43 286.19,197.8 284.54,199.45 284.54,204.78 283.97,205.36 282.44,205.36 281.94,205.87 281.94,208.41 281.3,209.04 v1(280.16,209.04)
  LAY6 w0.508: v1(291.21,42.04) 290.39,42.85 246.3,42.85 245.99,42.54 234.41,42.54 228.62,48.34 215.56,48.34 213.49,50.41 206.61,50.41 205.9,51.12 200.09,51.12 198.24,49.27 v1(192.53,49.27) ; 127.63,50.16 127.63,48.39 125.63,46.38 v1(125.63,42.16)
  LAY6 w0.75: 119.76,114.51 119.76,118.87 122.68,121.79 122.68,126.28 ; 118.11,109.62 118.11,102.49 115.82,100.2 115.82,90.33 117.1,89.06 117.1,88.76 ; v1(104.52,181.74) v1(105.66,181.74) 106.29,181.74 106.68,182.12 111.3,182.12 114.3,179.12 114.3,174.37 115.95,172.72 121.42,172.72 123.19,170.95 123.19,166.11
  BOTTOM w0.5: v1(300.99,211.33) 299.97,211.33 299.33,210.69 297.94,210.69 297.04,209.79 295.39,209.79 295.01,209.41 284.86,209.41 283.84,210.44 283.21,210.44 282.57,209.8 R1C48.2 v1(280.16,209.04) ; v1(291.21,42.04) 291.86,42.69 291.86,47.1 289.93,49.03 289.93,52.97 286.68,56.22 v1(286.68,65.88)
  BOTTOM w0.508: v1(56.75,131.56) 59.84,134.65 63.15,134.65 v1(63.37,134.87)
  BOTTOM w0.75: 118.99,84.29 118.99,78.74 118.49,78.23 118.49,61.34 121.86,57.97 v1(121.86,54.35) 121.86,53.14 123.69,51.31 126.11,51.31
  vias: v1(79.5,102.74) v1(79.5,101.73) v1(80.64,102.74) v1(80.64,101.73) v1(118.11,112.52) v1(118.11,111.76) v1(118.46,86.01) v1(118.99,85.47) v1(119.27,112.52) v1(123.34,164.64) v1(123.85,165.15) v1(127.25,51.05) v1(136.14,112.01) v1(136.14,111.3) v1(179.12,191.39) v1(179.19,190.63)
+V1P05A_VAL_OUT: length 4.8
  TOP w0.3: R8E64.1 52.38,131.44 52.85,131.92 52.85,134.59 52.47,134.97 C8E13.1
+V1P8_AUDIO: length 248.6
  TOP w0.2: EU6A1.5 123.35,275.12 123.19,274.95
  TOP w0.38: v1(115.69,280.54) 114.98,280.54 R6A29.2 115.23,279.78 v1(115.69,279.78) 115.82,279.65 R6A33.1 v1(115.82,278.26) 115.82,277.46 Y6A1.4 ; R8A32.1 v1(26.79,259.97) ; v1(30.86,258.92) 31.34,258.92 31.62,259.21 R8B1.1 R8B2.1 ; R6A36.1 v1(117.09,276.1) ; FB6A2.1 131.93,274.46 131.93,273.92 v1(131.69,273.68) ; R6A55.1 R6A51.1 ; 123.19,274.95 123.31,274.83 C6A29.1 123.31,272.55 C6A31.1 123.31,272.53 R6A54.1 v1(123.31,270.86) 123.31,270.25 124.07,269.49 R6A61.1 R6A62.1 R6A63.1 ; v1(18.16,270.89) 18.41,270.64 18.41,268.22 17.27,267.08 15.03,267.08 14.73,266.78 U9A1.1 ; R5A3.1 163.95,283.46 163.44,282.95 R5A7.1 v1(163.44,281.43)
  TOP w0.5: R8B23.1 26.28,235.46 v1(26.28,236.09) ; v1(28.44,252.86) 27.94,253.36 R8B8.1 ; R9A19.2 v1(12.44,263.02) ; R9A9.2 v1(12.31,270.13) ; R8A26.1 28.06,268.86 28.19,268.98 28.19,269.11 v1(28.44,269.37)
  LAY5 w0.75: 114.17,279.27 112.9,279.27 111.76,280.41 105.66,280.41 105.01,279.76 101.34,279.76 100.4,280.7 100.4,284.74 97.59,287.55 67.5,287.55 63.75,283.8 61.55,283.8 58.03,280.29 48.13,280.29 46.99,279.14 v1(46.35,279.14)
  BOTTOM w0.38: v1(163.44,281.43) 163.44,280.54 162.05,279.14 162.05,278.13 159.51,275.59 142.49,275.59 141.73,276.35 137.66,276.35 135.76,278.26 134.62,278.26 133.73,277.37 133.73,275.72 v1(131.69,273.68) ; 131.57,274.45 131.69,274.57
  BOTTOM w0.5: v1(117.09,276.1) 116.84,276.35 115.95,276.35 ; v1(12.44,263.02) 12.52,263.1 12.52,269.92 v1(12.31,270.13) 12.31,270.38 13.97,272.03 16,272.03 17.14,270.89 v1(18.16,270.89) 22.73,270.89 23.24,270.38 25.65,270.38 25.65,270.13 25.67,270.1 27.94,270.1 28.44,269.6 v1(28.44,269.37) 28.44,269.24 26.79,267.59 v1(26.79,259.97) 29.81,259.97 v1(30.86,258.92) 29.71,257.78 29.71,254.76 28.44,253.49 v1(28.44,252.86) 28.44,252.22 29.71,250.95 29.71,246.51 28.82,245.62 28.82,242.57 26.55,240.29 26.55,237.61 27.05,237.1 27.05,236.59 26.55,236.09 v1(26.28,236.09)
  BOTTOM w0.75: v1(46.35,279.14) v1(45.21,279.14) 44.7,279.65 34.51,279.65 ; 31.87,280.54 29.99,280.54 26.16,276.71 26.16,272.92 25.65,272.41 25.65,270.38
  vias: v1(130.98,273.63)
+V1P8_AUDIO_I2S2: length 8.2
  TOP w0.5: J9B4.3 20.95,236.73 24.13,236.73 C8B25.1 R8B23.2 R8B26.2
+V1P8_AUDIO_R: length 1.4
  TOP w0.5: R6A29.1 111.88,280.29
+V1P8_V3P3_AUDIO_DVDD: length 5.3
  TOP w0.5: J9A4.8 8.25,264.03 C9A2.1 R9A19.1 R9A21.1
+V1P8_V3P3_AUDIO_DVDDIO: length 5.5
  TOP w0.5: J9A4.4 8.12,268.98 8.25,269.11 C9A1.1 10.16,269.62 10.03,269.75 R9A9.1 R9A4.1
+V1P8_V3P3_I2S1: length 9.2
  TOP w0.5: R8A26.2 26.67,267.59 C8A5.1 24.44,267.46 22.66,265.68 20.95,265.68 J9A5.5
+V1P8A: length 895.4
  TOP w0.305: EU7H1.16 77.59,55.48 C7H2.1 ; v1(36.7,67.56) 36.3,67.96 EU8G3.7 ; R7D40.1 v1(76.45,175.39)
  TOP w0.38: R7H23.1 v1(80.89,60.7) ; R5J6.2 v1(138.93,22.1) ; R6J22.2 v1(130.81,9.78) ; v1(83.31,55.7) 83.23,55.62 R7H41.1 ; v1(93.72,54.86) 93.72,59.02 97.09,62.38 97.09,87.86 96.5,88.45 96.5,93.65 97.33,94.49 116.45,94.49 119.76,91.18 119.76,89.33 120.14,88.95 122.72,88.95 124.66,90.89 124.66,114.76 130.41,120.52 137.28,120.52 v1(137.41,120.65) ; R5C72.1 161.59,196.34 v1(161.27,196.66) ; v1(157.22,167.62) 156.69,168.15 R5D42.1 ; R7H21.1 73.02,60.7 v1(72.26,59.94) ; R9C14.1 v1(13.2,205.36) 13.33,205.36 14.42,206.45 17.57,206.45 R9C12.1 ; R7H30.1 v1(83.31,58.29) ; v1(132.2,24.13) R6J14.2 ; R7C26.1 v1(65.02,204.34) ; v1(77.21,178.18) R7D20.2 R7D21.2 v1(80.89,178.94) ; R8F38.2 59.94,107.95 ; v1(77.59,53.59) C7H2.1 R7H45.1 ; R8G60.1 v1(36.7,76.2) ; R8C70.1 54.48,197.23 52.95,195.71 Q8C14.2 ; R8D57.2 v1(44.95,177.44)
  TOP w0.5: R9F33.1 10.92,101.47 v1(10.43,101.95) ; R9G4.1 v1(12.95,94.74) ; v1(54.86,73.53) 56.13,72.26 58.42,72.26 60.32,74.17 60.32,76.2 58.54,77.98 58.54,80.64 59.3,81.41 64.51,81.41 65.65,82.55 67.05,82.55 67.94,83.44 67.94,91.95 69.21,93.22 69.21,95.25 68.83,95.63 68.83,100.07 ; R7C49.1 v1(64.84,195.07)
  TOP w0.508: 55.11,189.36 55.11,191.64 52.95,193.8 Q8C14.2 ; 55.11,189.36 55.11,187.6 v1(54.73,187.22) ; 55.11,189.36 R8D14.1 ; J7D3.2 66.37,187.58 v1(66.14,187.35) v1(64.87,186.08) 63.7,184.91 v1(55.49,184.91)
  TOP w1: 69.21,100.46 v1(78.35,100.46) v1(79.5,100.46)
  LAY5 w0.38: v1(161.27,196.66) 161.26,196.66 160.08,195.49 160.08,193.42 155.19,188.53 155.19,177.55 154.55,176.91 154.55,175.51 155.06,175 155.95,175 156.59,174.37 156.59,169.16 157.22,168.53 v1(157.22,167.62) 156.19,167.62 155.82,167.26 155.82,164.21 155.19,163.57 155.19,162.69 154.3,161.8 154.3,160.91 153.41,160.02 153.41,157.61 153.74,157.28 153.74,155.01 153.41,154.68 152.52,154.68 150.36,152.53 150.36,151.9 144.27,145.81 144.27,125.47 140.57,121.78 138.54,121.78 v1(137.41,120.65)
  LAY5 w0.508: 69.9,142.82 69.9,148.57 v1(70.94,149.6)
  LAY5 w1: v1(51.43,275.84) v1(52.7,275.84) 60.07,275.84 60.55,276.33 86.89,276.33 87.88,275.33 92.45,275.33 93.06,274.73 100.23,274.73
  LAY6 w0.38: v1(36.7,67.56) 36.7,69.34 37.33,69.98 37.33,75.56 v1(36.7,76.2)
  LAY6 w0.5: v1(93.72,54.86) 93.72,48.51 95.12,47.12 v1(95.12,30.66)
  LAY6 w0.508: v1(103.12,108.33) 102.74,107.95 96.52,107.95 95.63,108.84 v1(95.63,108.89) 95.17,109.35 85.34,109.35 82.67,106.68 82.67,105.66 80.64,103.63 78.86,103.63 78.35,103.12 v1(78.35,100.46)
  LAY6 w0.75: 86.3,72.35 86.3,71.39 85.65,70.74 85.65,60.75 v1(86.43,59.97) ; v1(79.5,100.46) 82.67,97.28 84.37,97.28 85.85,95.8 85.85,92.57 85.84,92.56 85.84,92.51 85.15,91.82 v1(85.06,91.82) 85.06,90.47 86.23,89.3 86.23,86.99 85.96,86.73 85.97,86.71 85.97,79.88
  LAY6 w1: 13.32,274 11.87,274 10.68,272.81 10.68,264.91 10.09,264.33 10.09,258.41 10.4,258.11 10.4,251.7 7.62,248.92 7.62,232.28 12.31,227.58 12.31,216.91 13.2,216.03 13.2,212.72 12.31,211.83 12.31,206.25 v1(13.2,205.36) ; v1(52.7,275.84) v1(51.43,275.84) 34.31,275.84 32.48,277.68 29.26,277.68 28.29,278.64 23.71,278.64
  BOTTOM w0.38: v1(85.06,91.82) 84.93,91.69 R7U19.1 ; v1(80.89,178.94) 80.89,187.32 J7D3.2 ; v1(77.59,53.59) 79.88,53.59 81.28,54.99 82.6,54.99 v1(83.31,55.7) 83.23,55.7 82.67,56.26 82.67,57.66 v1(83.31,58.29) ; v1(138.93,22.1) 138.3,22.73 134.74,22.73 133.35,24.13 v1(132.2,24.13) ; v1(83.31,58.29) v1(80.89,60.7) 80.26,61.34 76.2,61.34 75.42,60.56 72.88,60.56 v1(72.26,59.94) ; v1(83.31,58.29) 83.94,58.93 83.94,59.56 84.35,59.97 v1(86.43,59.97) ; v1(130.81,9.78) 131.29,10.26 131.29,12.34 129.49,14.15 129.49,17.6 131.19,19.3 131.19,21.97 132.2,22.99 v1(132.2,24.13) ; v1(132.2,24.13) 130.62,22.54 126.93,22.54 124.56,20.17 121.56,20.17 120.01,21.72 118.87,21.72 115.31,25.27 112.88,25.27 111.47,23.86 100.85,23.86 98.67,26.03 98.67,27.56 97.53,28.7 R7W1.1 ; v1(77.21,178.18) 76.45,177.42 v1(76.45,175.39) R7D40.1 ; R7T7.1 v1(67.69,118.62)
  BOTTOM w0.5: R7T24.1 94.79,108.76 95.5,108.76 v1(95.63,108.89) ; R7W1.1 95.12,29.08 v1(95.12,30.66) ; v1(54.86,73.53) 54.86,72.01 53.87,71.02 50.44,71.02 49.53,70.1 40.89,70.1 38.35,67.56 v1(36.7,67.56) 35.56,68.71 32.88,68.71 32.25,68.08 v1(32.25,68.07) 31.75,68.07 27.55,63.88 23.11,63.88 19.93,60.7 7.23,60.7 6.35,61.59 6.35,70.48 6.98,71.12 6.98,92.84 7.86,93.72 11.93,93.72 v1(12.95,94.74) 11.68,96.01 11.68,100.94 10.66,101.95 v1(10.43,101.95) ; v1(70.94,149.6) R7R29.1 ; v1(93.72,54.86) 93.72,58.29 92.04,59.97 v1(86.43,59.97)
  BOTTOM w0.508: v1(69.13,141.98) 70.02,142.87 R7R46.1 ; v1(65.02,204.34) 64.13,203.45 64.13,197.61 64.84,196.9 v1(64.84,195.07) 64.38,194.61 64.38,190.12 63.37,189.1 v1(63.37,187.58) ; R7P10.1 75.94,163.7 75.43,163.19 R7R3.1 74.04,161.29 73.53,161.8 R7R1.1 ; v1(103.12,108.33) 103.5,108.71 R6T16.1 ; R7R28.1 v1(70.94,149.6)
  BOTTOM w1: v1(13.2,205.36) 14.22,204.34 14.22,195.58 20.44,189.36 20.93,189.36 22.47,187.81 24.1,187.81 ; R7P10.1 75.94,165.1 75.05,165.99 75.05,166.37 72.77,168.65 72.77,172.62 66.3,179.09 66.3,180.6
  vias: v1(26.54,186.05) v1(26.54,185.29) v1(52.32,175) v1(52.98,174.62) v1(52.98,173.86) v1(53.23,183.51) v1(53.23,182.75) v1(59.3,109.22) v1(59.94,108.58) v1(60.57,108.08) v1(61.08,107.44) v1(67.05,103) v1(67.33,102.34) v1(110.3,279.5) v1(110.77,278.94)
+V1P8A_CC: length 2.8
  TOP w0.5: U8D7.5 C8D22.1 R8D57.1
+V1P8A_EC: length 215.7
  TOP w0.2: U8F6.54 16.99,96.29 16.76,96.52 v1(16.51,96.52)
  TOP w0.5: v1(16.51,96.52) 16.25,96.52 16,96.26 15.49,96.26 R9G2.1 R9G4.2
  TOP w0.508: J6J2.99 v1(126.31,17.22) 125.8,17.73 J6J2.91
  LAY3 w0.508: v1(106.04,12.8) 105.17,11.93 101.8,11.93 97.91,8.04 81.84,8.04 81.07,8.81 69.25,8.81 66.51,11.55 41.77,11.55 41.39,11.93 22.61,11.93 20.81,13.72 20.81,14.61 18.39,17.04 14.78,17.04 12.57,19.25 12.57,24.51 12.09,24.99 12.09,35.91 10.16,37.84 10.16,48.39 8.63,49.91 7.49,49.91 6.35,51.05 6.35,69.47 6.98,70.1 6.98,88.52 12.44,93.98 13.46,93.98 16,96.52 v1(16.51,96.52)
  LAY6 w0.508: v1(126.31,17.22) 125.02,17.22 124.58,17.65 117.98,17.65 117.34,18.29 112.14,18.29 111.5,17.65 109.78,17.65 106.1,13.96 106.1,12.86 v1(106.04,12.8)
+V1P8A_OUT: length 14.5
  TOP w0.3: C8F16.1 R8F41.1 46.22,105.54 47.62,106.93 52.95,106.93 54.48,105.41 C8F12.1
  TOP w0.38: R8F38.1 59.94,104.52
+V1P8A_PCH_VAL: length 189.5
  TOP w0.5: v1(75.37,194.88) 77.08,196.59 78.23,196.59 78.74,196.09 R7C51.1
  TOP w0.75: v1(79.5,106.04) v1(78.35,106.04) 76.45,106.04 72.77,109.73 69.08,109.73 63.88,114.93 62.61,114.93 60.68,116.86 60.68,127.5 61.46,128.28 61.46,132.24 59.13,134.57 59.13,139.38 57.91,140.6 57.91,142.99 57.02,143.89 57.02,150.11 54.22,152.91 v1(54.22,154.4)
  TOP w1: 57.91,164.72 59.05,164.72 59.56,165.23 63.5,165.23 66.92,168.65 70.65,168.65
  LAY5 w0.5: v1(73.78,165.99) 73.78,166.35 76.07,168.64 76.07,172.85 75.69,173.23 75.69,179.2 76.7,180.21 76.7,184.74 74.29,187.15 74.29,193.42 75.37,194.5 v1(75.37,194.88)
  LAY5 w0.508: v1(92.4,124.69) 92.4,122.48 92.58,122.3 92.58,114.43 93.85,113.16 v1(95.88,113.16) ; v1(73.93,143.87) 73.93,143.89 74.29,144.25 v1(74.29,150.49)
  LAY5 w0.75: 74.42,151.59 74.42,158.02
  LAY6 w0.508: v1(95.88,113.16) 97.79,113.16 98.93,114.3 102.48,114.3 v1(102.99,113.79)
  LAY6 w0.75: v1(95.88,113.16) 92.32,113.16 91.69,112.52 89.15,112.52 88.51,111.89 84.32,111.89 80.76,108.33 80.76,106.94 79.87,106.04 v1(79.5,106.04)
  BOTTOM w0.5: v1(95.88,113.16) 95.25,113.79 R7T20.1 ; v1(74.29,150.49) 72.13,150.49 71.23,151.39 68.38,151.39 67.56,150.57 R7R30.1
  BOTTOM w0.508: R7R45.1 73.78,143.72 v1(73.93,143.87) ; v1(77.21,165.35) 77.47,165.1 R7P11.1 ; v1(73.78,165.99) v1(73.02,165.99) R7P8.1 ; R6T8.1 v1(102.99,113.79) ; v1(74.29,150.49) 73.91,150.11 R7R27.1
  BOTTOM w0.58: R7T1.1 90.29,124.11 91.18,124.99 92.1,124.99 v1(92.4,124.69)
  vias: v1(53.21,154.4) v1(54.22,155.54) v1(56.26,164.49) v1(56.26,163.57)
+V1P8A_PCH_VAL_OUT: length 4.5
  TOP w0.3: C8E4.1 52.47,153.41 52.85,153.03 52.85,150.27 R8E23.1
+V1P8DX_TCH_PNL_IO: length 41.6
  TOP w0.38: R7D5.1 58.46,186.61 54.35,186.61 54.08,186.88 54.08,187.43 54.48,187.83 54.48,191.13 52.07,193.55 50.67,193.55 50.41,193.8 50.41,195.83 51.68,197.1 Q8C14.3 52,197.8 51.66,198.14 C8C23.1 51.86,198.5 52.24,198.88 52.24,200.07 54.99,202.82 54.99,204.72 56.51,206.25 58.29,206.25 60.57,203.96 SW7C1.3
+V1P8S: length 507.8
  TOP w0.2: R7E33.1 70.31,140.71 69.13,139.54 67.18,139.54 66.45,138.81 v1(65.22,138.81)
  TOP w0.38: R7C5.1 v1(96.52,224.53)
  TOP w0.5: R9J1.2 19.05,31.24 17.46,32.83 17.46,33.46 13.33,37.59 10.41,37.59 10.03,37.97 R9H17.2 v1(9.27,38.61) ; R9J9.2 v1(9.27,26.29)
  TOP w0.508: v1(71.95,196.21) 66.09,196.21 65.81,196.49 65.81,198.82 65.45,199.18 57.96,199.18 57.4,198.63 57.4,197.25 v1(57.37,197.23) R8C77.1 ; v1(26.54,182.24) 24.63,182.24 24,182.88 R9D8.1 23.24,183.26 22.92,183.58 22.41,183.58 21.84,184.15 21.84,185.42 20.95,186.31 15.36,186.31 14.57,187.1 7.39,187.1 v1(7.11,186.82) ; v1(30.73,260.73) 30.73,264.79 28.95,266.57 R8A28.1
  LAY5 w0.5: v1(72.51,216.41) 71.37,215.26 71.37,196.79 v1(71.95,196.21) ; v1(96.52,224.53) 95.91,225.14 93.06,225.14 91.24,223.33 86.95,223.33 83.87,226.4 83.87,229.97 80.87,232.97 72.71,232.97 v1(72,233.68)
  LAY5 w0.508: v1(65.22,138.81) 65.27,138.86 65.27,140.46 64.77,140.97 64.77,142.24 v1(65.27,142.75) 65.27,147.19 66.16,148.08 66.16,158.04 68.39,160.27 68.39,164.46 68.22,164.63 68.22,165.58 67.86,165.94 67.23,165.94 66.8,166.37 66.8,168.53 66.99,168.72 66.99,179.82 67.64,180.47 67.64,181.81 68.32,182.5 68.32,189.78 70.48,191.94 70.48,194.75 v1(71.95,196.21) ; v1(57.37,197.23) 57.37,197.2 56.13,195.96 48.31,195.96 47.04,194.69 43.53,194.69 43.18,194.33 38.56,194.33 37.21,192.98 33.52,192.98 32.89,192.35 29,192.35 27.94,193.42 v1(27.55,193.42)
  LAY6 w0.5: v1(72,233.68) 70.86,232.54 70.86,218.69 72.51,217.04 v1(72.51,216.41)
  LAY6 w0.508: v1(26.54,183.13) 26.54,184.15 27.3,184.91 27.3,190.75 27.55,191.01 v1(27.55,193.42) 27.55,202.18 27.12,202.61 27.12,203.66 27.71,204.24 27.71,212.19 26.62,213.28 26.62,221.93 26.02,222.53 26.02,226.98 23.67,229.32 23.67,234.36 24.43,235.11 24.43,237.92 25.11,238.6 25.11,239.97 25.65,240.51 25.65,242.31 26.35,243.01 27.11,243.01 27.81,243.71 27.81,245.49 27.24,246.06 27.24,247.71 29.4,249.87 29.4,253.05 30.09,253.74 30.09,260.09 v1(30.73,260.73)
  BOTTOM w0.2: v1(65.27,142.75) 68.58,142.75 69.79,143.96 72.5,143.96 73.25,144.71 78.55,144.71 79.12,144.14 79.12,143.13 79.37,142.87 R7R42.1
  BOTTOM w0.5: v1(9.27,26.29) 10.16,27.18 10.16,37.72 v1(9.27,38.61) 10.16,39.5 10.16,48.39 9.27,49.27 8.5,49.27 3.68,54.1 3.68,135.89 3.3,136.27 3.3,161.67 7.23,165.61 7.23,186.56 7.11,186.69 v1(7.11,186.82)
+V3.3A_KBC_DIO: length 2.1
  TOP w0.5: CR9E1.2 17.47,143.66 17.47,145.67 R9E25.2
+V3.3A_MECC_SPI: length 11.8
  TOP w0.38: CR6J1.1 103.75,12.19 107.56,12.19 107.97,11.78 v1(107.97,11.53) ; J6J2.14 v1(112.34,13.41)
  LAY6 w0.38: v1(107.97,11.53) 108.17,11.53 109.34,12.7 111.63,12.7 v1(112.34,13.41)
+V3.3A_SPI_EC: length 36.5
  TOP w0.38: EU9E1.8 25.65,139.95 25.78,139.83 R8E45.1 26.54,140.46 24.89,142.11 C8E10.1 ; R9E30.1 v1(13.97,138.68) ; R9E29.1 v1(13.97,139.95) ; C9E3.1 C9E2.1 14.6,136.14 14.6,137.29 R9E31.1 14.09,137.41 v1(13.97,137.29)
  TOP w0.5: C8E10.1 21.2,142.37 20.82,142.75 CR9E1.1 20.19,143.64 17.65,141.1 14.73,141.1 13.97,140.33 v1(13.97,139.95) ; v1(13.97,138.68) 13.71,138.68 12.7,137.67 12.7,136.52 8.5,132.33 J9E9.6
  LAY5 w0.38: v1(13.97,137.29) v1(13.97,138.68)
  LAY5 w0.5: v1(13.97,138.68) v1(13.97,139.95)
+V3.3M_LAN_ESD1_FOX: length 1.3
  TOP w0.38: R7A12.2 80.51,260.38 EU7A2.5
+V3.3M_LAN_ESD2_FOX: length 1.6
  TOP w0.38: R7A10.2 73.91,260.35 74.56,261 EU7A1.5
+V3P3_AUDIO: length 101.5
  TOP w0.38: R8A25.1 v1(24.38,268.48) ; R8B26.1 v1(26.03,232.66) ; R8A31.1 27.43,260.98 28.06,261.62 v1(28.95,261.62)
  TOP w0.5: v1(31.87,278.64) 31.54,278.97 R8A11.2 ; v1(30.98,252.73) 30.98,253.49 R8B9.1 ; v1(28.95,265.05) 28.06,265.94 25.52,265.94 Q8A1.1 v1(24.38,265.68) ; R9A4.2 v1(12.31,271.4) ; R9A21.2 v1(12.44,261.87)
  LAY5 w0.5: v1(31.11,278.64) 26.41,278.64 25.79,278.01 24.31,278.01 20.92,274.62 15.67,274.62 12.44,271.4 v1(12.31,271.4) 13,270.71 13,267.16 13.33,266.83 13.33,262.76 v1(12.44,261.87)
  BOTTOM w0.5: v1(26.03,232.66) 26.03,234.31 27.68,235.96 27.68,237.36 27.17,237.87 27.17,239.65 30.73,243.2 30.73,249.17 31.62,250.06 31.62,252.09 v1(30.98,252.73) ; v1(24.38,268.48) v1(24.38,265.68)
  BOTTOM w0.75: v1(30.98,252.73) 30.6,253.11 30.6,256.92 31.75,258.06 31.75,261.11 31.24,261.62 v1(28.95,261.62) v1(28.95,265.05) 29.33,265.43 29.33,270.64 28.7,271.27 28.7,276.22 30.35,277.88
+V3P3_AUDIO_R: length 1.6
  TOP w0.1: 30.09,281.05 R8A10.2
  TOP w0.5: R8A11.1 30.09,281.05
+V3P3_DUAL: length 1124
  TOP w0.305: 96.9,52.2 U7H1.5 ; v1(70.73,131.32) R7E57.1
  TOP w0.38: v1(32.51,229.74) 33.14,229.74 R8B33.1 32.89,230.5 v1(32.51,230.5) ; U8F5.5 25.85,127.07 25.78,127 C8F2.1 v1(24.38,127) 24.13,127 23.49,127.63 23.49,131.06 v1(25.65,133.22) C8E15.1 U8F1.5 ; U9C2.5 23.8,206.44 23.49,206.75 C9C7.1 v1(22.35,206.75) ; R6F12.1 v1(108.2,111.43) ; v1(169.16,235.71) 169.16,235.84 168.42,236.58 167.91,236.58 166.93,237.56 U5C1.5 166.49,237.04 165.48,236.02 R5C7.1 ; v1(151.25,78.99) 151.38,78.99 152.01,79.63 153.92,79.63 R5G24.1 ; R6A86.1 v1(104.26,281.97) R6A88.1 ; R7B67.1 87.05,234.75 87.05,235.71 85.34,235.71 C7B15.1 v1(85.09,234.57) ; v1(146.68,241.17) 146.68,241.3 R5B23.1 147.19,242.06 147.95,242.82 R5B20.1 ; v1(165.35,81.53) 165.8,81.98 U5G2.5 167.25,82.29 C5G15.1 ; v1(12.59,167.77) R9D35.1 R9D32.1 ; v1(36.83,116.2) 42.16,116.2 44.7,113.66 v1(45.59,113.66) ; 75.05,184.33 75.05,184.45 75.64,185.04 78.96,185.04 80.32,183.68 83.09,183.68 85.59,181.18 R7D16.1 ; v1(35.05,198.5) C8C26.1 U8C4.5 ; v1(32.38,78.87) C8G12.1 33.14,79.5 33.28,79.63 U8G1.5 ; v1(13.71,188.34) 14.85,188.34 15.36,187.83 v1(21.2,187.83) ; R7F41.1 v1(94.23,114.81) ; v1(29.21,133.22) C8E16.1 U8F2.5 ; R6J32.1 v1(105.53,3.3) ; R7B73.2 v1(89.66,231.65) ; v1(104.01,38.73) 104.14,38.73 104.74,39.34 106.44,39.34 109.05,36.73 121.01,36.73 122.31,35.43 R6F41.1 122.68,38.35 127.12,42.8 R6H20.1 ; R8G81.1 v1(31.49,64.95) ; R8F28.1 36.85,109.22 35.05,109.22 34.79,108.96 R8F32.1 v1(33.65,108.2) ; R8G78.1 v1(44.19,65.15) ; R7C1.2 v1(89.66,226.82) ; v1(37.97,79.5) 38.1,79.63 R8G45.1 ; R7E35.2 R7E40.1 72.72,138.94 72.34,138.56 v1(72.34,138.4) ; R5C9.2 163.57,219.68 v1(164.16,220.27) ; v1(20.95,218.82) 25.78,218.82 27.81,220.85 R8C11.1 27.81,222.25 28.95,223.39 R8C8.1 ; R9C18.1 v1(22.35,204.72) ; v1(42.97,199.77) 42.84,199.64 R8C67.1 ; R7F40.1 v1(90.93,114.68) ; R8C45.2 30.86,205.74 v1(30.22,205.1) ; R8H8.1 v1(25.52,52.7) ; R6F40.1 105.28,101.73 105.28,100.58 105.91,99.95 108.07,99.95 109.8,98.22 v1(110.11,98.22) ; R6F7.1 v1(103.12,114.68) ; v1(90.67,248.92) R7B21.1 ; R5G19.1 v1(160.02,80.64)
  TOP w0.5: R6D64.1 133.21,170.05 132.71,169.55 132.71,168.91 141.6,160.02 148.46,160.02 149.98,158.49 R5E3.1 151.76,158.49 151.84,158.42 155.95,158.42 156.69,159.15 158.85,159.15 159.2,158.8 159.2,156.64 159.76,156.08 159.76,154.89 v1(160.65,154)
  TOP w0.508: v1(95.93,53.57) 95.93,52.7 96.44,52.2 96.9,52.2 ; v1(65.7,199.82) 59.13,199.82 58.42,200.53 v1(57.37,200.53) ; v1(88.51,25.78) J7J1.9 ; v1(75.05,184.3) 75.05,184.33
  LAY5 w0.38: v1(86.86,248.92) v1(90.67,248.92) ; v1(13.71,188.34) 12.95,187.58 12.95,177.8 13.46,177.29 13.46,175.51 12.59,174.65 v1(12.59,167.77) ; v1(67.69,120.83) 67.99,120.83 69.33,122.16 69.33,125.33 69.8,125.8 69.8,130.38 v1(70.73,131.32) 72.34,132.92 v1(72.34,138.4) 72.53,138.59 72.53,144.71 72.78,144.97 72.78,151.64 71.24,153.17 71.24,156.34 72.23,157.32 72.23,159.92 71.93,160.22 71.93,165.92 73.02,167 73.63,167 75.41,168.78 75.41,171.22 74.67,171.96 74.67,183.92 v1(75.05,184.3) ; v1(151.25,78.99) 152.17,78.99 152.8,78.36 153.54,78.36 154.81,79.63 157.73,79.63 158.75,80.64 v1(160.02,80.64) 162.3,80.64 163.19,81.53 v1(165.35,81.53) ; 41.27,83.82 37.97,80.52 v1(37.97,79.5) 37.71,79.5 36.83,80.39 33.9,80.39 v1(32.38,78.87) ; v1(100.71,25.63) 97.56,25.63 96.64,26.54 89.28,26.54 v1(88.51,25.78) ; v1(166.24,226.95) 165.35,227.84 152.73,227.84 151.63,228.94 151.63,232.03 151.24,232.42 151.24,236.49 150.08,237.64 148.31,237.64 146.68,239.27 v1(146.68,241.17)
  LAY5 w0.508: v1(30.22,205.1) 30.22,204.92 31.06,204.09 33.78,204.09 34.54,203.33 34.54,201.8 35.05,201.29 v1(35.05,198.5) 35.94,198.5 36.7,199.26 42.46,199.26 v1(42.97,199.77) 44.8,201.6 50.92,201.6 51.48,201.04 56.89,201.04 57.37,200.56 v1(57.37,200.53)
  LAY5 w0.75: v1(119.63,74.17) 115.44,74.17 113.91,75.69 101.06,75.69 96.7,71.33 96.7,67.94 95.18,66.42 90.42,66.42 87.75,63.75 ; v1(151.25,78.99) v1(150.36,78.99) 149.97,78.6 140.32,78.6 139.94,78.23 138.67,78.23 135.5,75.06 133.09,75.06 131.06,73.02 128.39,73.02 126.36,75.06 v1(119.63,75.06)
  LAY6 w0.38: v1(90.93,114.68) 91.69,115.44 93.59,115.44 v1(94.23,114.81) 94.86,114.17 97.53,114.17 98.42,115.06 102.74,115.06 v1(103.12,114.68) 106.29,111.5 108.12,111.5 v1(108.2,111.43) ; v1(164.16,220.27) 164.16,224.86 v1(166.24,226.95) 167.64,228.35 167.64,230.19 166.86,230.96 166.86,232.1 168.52,233.76 168.52,235.2 169.03,235.71 v1(169.16,235.71) ; v1(36.83,116.2) 35.68,115.06 35.68,113.16 33.65,111.12 v1(33.65,108.2) ; v1(86.86,248.92) 86.35,249.43 86.35,266.56 87.88,268.1 88.39,268.1 88.95,267.54 93.01,267.54 93.07,267.48 v1(98.4,267.48) ; v1(100.71,25.63) 101.72,24.61 101.72,3.43 102.93,2.22 104.7,2.22 105.53,3.05 v1(105.53,3.3)
  LAY6 w0.5: v1(164.16,220.27) 164.23,220.34 168.52,220.34 171,217.87 172.02,217.87 172.66,217.23 172.66,214.7 171.06,213.1 170.43,213.1 169.84,212.52 169.84,207.18 168.4,205.74 168.4,204.47 166.48,202.55 166.48,198 167.69,196.78 167.69,186.15 166.61,185.06 166.61,181.9 161.57,176.86 161.57,175.25 161.39,175.08 161.39,172.23 161.92,171.7 163.12,171.7 165.66,169.16 166.75,169.16 167.25,168.65 167.25,163.19 162.81,158.75 162.81,157.72 160.65,155.56 v1(160.65,154)
  LAY6 w0.508: v1(75.05,184.3) 74.16,185.19 74.16,191.51 69.46,196.21 67.43,196.21 66.35,197.29 66.35,198.23 65.7,198.88 v1(65.7,199.82)
  LAY6 w0.75: v1(110.11,98.22) 109.47,97.58 v1(109.47,97.38) 109.47,95.63 112.35,92.75 112.35,87.35 116.96,82.75 116.96,79.03 119.63,76.36 v1(119.63,75.06) v1(119.63,74.17) ; v1(160.65,154) 159.35,154 158.41,153.06 158.41,152.33 148.77,142.69 148.77,134.96 149.63,134.1 149.63,133.6 150.36,132.87 150.36,132.21 148.64,130.48 148.64,106.35 144.27,101.98 144.27,99.94 138.22,93.89 138.22,87.37 139.34,86.26 140.56,86.26 147.82,78.99 v1(150.36,78.99) v1(151.25,78.99)
  LAY6 w1: 126.74,263.65 123.95,263.65 121.53,261.24 115.06,261.24 113.69,262.61 112.03,262.61 109.34,265.3 109.34,265.7 107.44,267.6 100.9,267.6 ; 135.63,269.37 135.63,270.38 138.68,273.43 157.73,273.43 157.9,273.6 161.71,273.6 162.07,273.96 163.47,273.96 163.59,274.09
  BOTTOM w0.38: v1(89.66,226.82) 89.02,227.46 89.02,231.01 v1(89.66,231.65) 88.01,231.65 v1(85.09,234.57) 86.86,234.57 88.77,236.47 88.77,237.87 87.5,239.14 87.5,246.38 86.86,247.01 v1(86.86,248.92) ; v1(29.21,133.22) v1(25.65,133.22) ; 98.04,268.6 98.04,274.83 101.34,278.13 101.34,281.43 101.72,281.81 104.11,281.81 v1(104.26,281.97) ; R7T6.1 v1(67.69,120.83) ; R7F41.1 v1(94.23,114.81) ; v1(24.38,127) 24.91,126.47 32.91,126.47 37.46,121.92 37.46,116.84 v1(36.83,116.2)
  BOTTOM w0.5: v1(109.47,97.38) 109.47,97.58 v1(110.11,98.22) 110.51,98.22 111.25,98.96 111.25,100.8 110.49,101.56 110.49,102.74 109.6,103.63 109.6,106.93 110.36,107.69 110.36,109.17 108.2,111.33 v1(108.2,111.43) ; v1(86.48,62.1) 91.69,62.1 95.12,58.67 95.12,55.24 95.93,54.43 v1(95.93,53.57)
  BOTTOM w0.508: 102.48,33.02 102.48,35.18 104.01,36.7 v1(104.01,38.73) 104.01,38.86 104.73,39.58 104.73,40.3 104.52,40.51 104.52,47.75 99.28,52.98 96.52,52.98 v1(95.93,53.57) ; 102.48,33.02 105.02,33.02 107.82,30.22 R6W2.1 101.98,27.56 99.88,29.65 98.48,29.65 96.01,32.13 90.04,32.13 88.51,30.61 C7W2.1 v1(88.51,25.78) ; 102.48,33.02 101.98,33.02 R6V1.1 ; R7R53.1 70.99,137.65 71.52,138.17 72.11,138.17 v1(72.34,138.4) ; v1(30.22,205.1) 29.21,204.09 26.16,204.09 24.63,202.56 v1(20.82,202.56)
  BOTTOM w1: 87.37,272.41 87.37,274.45 84.37,277.44 66.72,277.44 60.83,283.34 54.73,283.34 53.46,282.07 53.46,281.3 49.91,277.75 39.49,277.75 31.79,270.04
  vias: v1(30.6,268.35) v1(30.6,267.46) v1(31.49,268.35) v1(31.49,267.46) v1(46.81,68.71) v1(46.83,67.87) v1(47.24,82.17) v1(47.24,81.46) v1(47.24,80.75) v1(47.44,68.32) v1(48,82.17) v1(48,81.46) v1(48,80.75) v1(86.48,61.21) v1(99.17,267.48) v1(164.71,275.46) v1(164.74,274.7)
+V3P3_EC: length 670.7
  TOP w0.2: U8F6.5 30.02,107.44 ; U8F6.19 24.42,106.89 23.81,107.5
  TOP w0.203: U8F6.65 19.22,89.96 19.05,89.79 ; 26.02,89.91 U8F6.82 ; U8F6.103 33.86,94.69 34.16,94.39 ; 34.16,99.49 U8F6.115
  TOP w0.38: C9G2.1 16,89.15 16.51,89.66 18.92,89.66 19.05,89.79 ; v1(20.32,110.62) R9F15.1 19.2,109.83 R9F14.1 ; R8G17.1 36.95,90.68 37.08,90.8 ; R9G18.1 24,86.23 24.63,85.6 25.65,85.6 ; R9G15.1 19.05,86.23 18.54,85.72 17.65,85.72 ; v1(28.19,70.36) 28.57,69.98 R8G68.2 ; R8F13.1 25.14,121.54 26.03,122.43 27.43,122.43 27.68,122.17 R8F14.1 ; R8F27.1 v1(35.56,110.62) ; v1(27.05,42.04) 25.52,42.04 24.76,41.27 R8H54.1 ; 34.16,94.39 34.31,94.23 C8G3.1 ; R8F24.1 C8F8.1 28.06,111.38 ; C8F11.1 30.73,108.84 30.02,108.13 30.02,107.44 ; v1(70.61,82.9) 71.27,82.9 R7G14.1 ; 21.59,115.44 v1(21.59,111.63) 21.84,111.38 R9F12.1 22.6,110.62 22.21,110.22 22.21,109.23 22.47,108.96 C9F2.1 22.86,108.46 23.81,107.5 ; v1(30.22,269.87) 30.67,269.43 31.67,269.43 32.62,268.48 v1(33.4,268.48) 34.67,268.48 36.06,267.08 40.25,267.08 42.67,264.67 44.45,264.67 44.83,264.29 45.59,264.29 46.5,265.2 52.6,265.2 53.34,265.94 58.16,265.94 v1(59.56,264.54) 61.46,266.44 v1(61.46,267.46) ; v1(9.65,104.77) R9F27.1 R9F30.1 ; v1(35.56,97.66) 35.68,97.79 C8F20.1 34.62,99.49 34.16,99.49 ; R9G26.1 14.09,75.69 14.47,75.31 17.65,75.31 17.9,75.56 R9G27.1 ; 13.2,103.5 13.2,103.76 13.46,104.01 R9F29.1 ; 13.2,103.5 11.55,103.5 11.3,103.25 R9F31.1 ; 13.2,103.5 14.22,102.49 R9F32.1 ; 25.65,85.6 R8G29.1 ; 25.65,85.6 25.63,85.61 25.63,87.74 25.9,88.01 C8G6.1 26.41,88.52 26.02,88.91 26.02,89.91 ; R8G21.1 R8G22.1 R8G23.1 30.63,86.84 30.63,85.88 v1(30.22,85.47) ; R9G28.1 20.7,75.94 v1(20.95,75.69) ; 24.13,115.31 24.13,115.31 24.13,111 24.89,110.25 R8F23.1 ; Q9F1.1 13.58,98.42 v1(13.71,98.55) 13.97,98.8 R9F36.1 ; v1(23.36,76.45) R8G56.2 ; R8F19.1 v1(27.68,115.31) ; R9F21.1 v1(9.65,106.81)
  TOP w0.5: J7G1.12 68.36,72.91 68.32,72.95 C7G12.1 69.23,74.04 v1(69.36,73.91) ; C8G3.1 v1(35.68,93.47) 36.07,93.47 36.57,92.97 R8G10.1 ; R9F5.1 20.37,116.76 17.38,116.76 14.09,113.47 14.09,111.12 9.77,106.81 v1(9.65,106.81) ; v1(10.43,102.87) 10.69,102.61 R9F31.1 ; R6J1.1 111.88,24.13 110.74,22.99 v1(105.79,22.99) ; R8F14.1 v1(28.44,121.54) ; R8E19.1 32.38,153.41 31.36,154.43 29.59,154.43 27.55,156.46 19.43,156.46 16.38,159.51 14.85,159.51 v1(13.84,158.49) R9E2.1 ; R9G2.2 v1(12.95,96.01) 12.82,95.88 R9G3.1 R9G5.1 12.82,93.85 13.21,93.85 13.71,93.35 13.71,91.44 15.11,90.04 C9G1.1 C9G2.1 16.16,88.01 17.05,87.12 R9G14.1 17.27,86.1 17.65,85.72 17.65,83.44 18.16,82.93 18.16,76.2 R9G27.1 18.54,75.31 19.81,75.31 20.19,75.69 R9G28.1 ; 29.33,111.12 R8F25.1 29.59,109.85 30.48,108.96 C8F11.1 ; 25.65,85.6 25.65,85.21 26.15,84.71 29.71,84.71 30.22,85.22 v1(30.22,85.47)
  TOP w0.508: R9E7.1 R9E4.1 R9E2.1 ; R9E7.1 R9E9.1 R9E12.1 R9E15.1 R9E17.1 R9E20.1 ; R9E7.1 R9E6.1 ; R9E20.1 R9E19.1 ; R9E20.1 R9E22.1 ; R8E19.1 R8E21.1 R8E25.1 R8E33.1 32.38,147.83 31.75,147.19 R8E36.1
  TOP w1: R9E25.1 22.98,145.67 24.63,144.02 27.68,144.02
  LAY5 w0.5: v1(63.62,28.07) 64.82,28.07 65.36,27.52 71.91,27.52 72.77,26.66 77.25,26.66 77.82,27.23 85.55,27.23 88.91,23.87 105.15,23.87 105.79,23.24 v1(105.79,22.99)
  LAY5 w0.508: v1(35.68,93.47) 35.56,93.6 v1(35.56,97.66)
  LAY5 w1: 36.44,112.52 38.35,114.43 38.35,121.32 34.16,125.51 34.16,128.14 31.24,131.06 31.24,135.25 28.95,137.54 28.95,142.49 29.46,143 ; 36.93,110.49 39.49,107.92 39.49,106.3 38.35,105.15 38.35,99.95 38.86,99.44 38.86,92.58 37.84,91.57 v1(37.84,90.68) v1(37.84,89.66)
  LAY6 w0.38: v1(27.05,42.04) 27.29,42.28 27.29,52.38 29.97,55.05 29.97,56.14 28.95,57.15 28.95,65.69 27.62,67.01 27.62,69.79 v1(28.19,70.36)
  LAY6 w0.5: v1(69.85,96.26) 69.99,96.12 69.99,93.27 69.41,92.7 69.41,89.71 70.12,89 v1(70.12,86.31) ; v1(63.62,28.07) 63.62,40.63 65.27,42.28 65.27,51.05 66.14,51.92 66.14,57.44 65.53,58.05 65.53,60.32 65.27,60.58 65.27,64.9 66.1,65.73 66.1,66.52 69.36,69.77 v1(69.36,73.91) 69.39,73.94 69.39,82.34 69.72,82.68 70.25,82.68 70.48,82.9 ; v1(13.84,158.49) 13.84,167.51 13.71,167.64 13.71,177.04 12.78,177.97 12.78,188.42 14.35,190 14.35,192.26 17.9,195.81 17.9,202.44 20.16,204.7 20.16,219.68 20.7,220.22 20.7,232.51 18.32,234.89 18.32,241.72 20.95,244.35 20.95,245.62 21.46,246.12 23.18,246.12 23.74,246.68 23.74,263.65 26.41,266.32 26.41,267.97 26.92,268.48 28.82,268.48 v1(30.22,269.87)
  LAY6 w0.508: v1(70.12,86.31) 69.34,85.52 69.34,84.05 70.48,82.9 v1(70.61,82.9)
  BOTTOM w0.38: R7L1.1 61.59,267.33 v1(61.46,267.46) ; v1(20.32,110.62) 21.33,111.63 v1(21.59,111.63) ; R8L1.1 v1(33.4,268.48) ; U8L2.8 v1(59.56,264.54) C8L4.1 ; v1(20.95,75.69) 22.6,75.69 v1(23.36,76.45) 24.63,75.18 24.63,73.91 v1(28.19,70.36) ; v1(70.12,86.31) 72.08,86.31 72.64,86.87 R7U31.1 72.86,87.47 U7U1.12
  BOTTOM w0.5: v1(27.68,115.31) 29.21,116.84 29.21,120.78 v1(28.44,121.54) ; v1(30.22,85.47) 31.11,85.47 31.57,85.01 32.68,85.01 34.09,86.42 34.09,87.56 35.3,88.77 36.83,88.77 37.71,89.66 v1(37.84,89.66) 38.22,89.28 42.16,89.28 48.31,95.43 66.29,95.43 66.47,95.25 68.2,95.25 69.21,96.26 v1(69.85,96.26) ; v1(12.95,96.01) 12.95,97.79 v1(13.71,98.55) 12.7,99.57 12.7,101.34 11.17,102.87 v1(10.43,102.87) 10.43,103.99 v1(9.65,104.77) v1(9.65,106.81)
  BOTTOM w0.508: J9F5.2 5.33,102.87 v1(10.43,102.87)
  vias: v1(29.21,144.02) v1(30.73,144.02) v1(35.56,111.63)
+V3P3_EC_AIC: length 1.5
  TOP w0.1: 115.13,22.68 FB6J1.1
  TOP w0.3: R6J1.2 115.13,22.68
+V3P3_EC_MIX: length 1.7
  TOP w0.3: R8G17.2 35.5,88.19 R8G26.2
+V3P3_LAN: length 57.6
  TOP w0.2: v1(186.69,262.89) 186.74,262.84 EU4B1.19 ; EU4B1.29 183.35,259.74 183.26,259.84 v1(183.13,259.84) ; EU4B1.15 188.34,262.79 v1(188.64,263.09) ; EU4B1.4 190.42,258.14 190.42,258.34 190.22,258.54 EU4B1.5
  TOP w0.38: R4B2.1 R4B4.1 v1(181.48,256.54) ; R4B8.1 194.69,256.16 196.21,257.68 197.99,257.68 198.88,258.57 198.88,262.63 198.62,262.89 v1(198.62,263.45) ; R4B8.1 193.67,256.16 193.04,256.79 191.51,256.79 191,257.3 191,257.55 190.42,258.14 ; R4B8.1 194.56,255.52 194.56,254.25 193.47,253.16 192.4,253.16 192.02,253.54 R4B18.1 R4B17.1 R4B16.1 ; C4A25.1 186.69,262.95 186.69,262.94 v1(186.69,262.89) ; R4B12.1 181.76,254.63 182.47,255.35 v1(182.67,255.35) ; 177.92,254.13 177.85,254.2 R4B10.2 179.07,255.4 C4B5.1 ; C4A34.1 182.49,260.73 183.13,260.09 v1(183.13,259.84)
  LAY5 w0.38: v1(178.56,254.1) 179.38,254.1 181.48,256.2 v1(181.48,256.54)
  LAY6 w0.38: 183,260.86 183,259.97 v1(183.13,259.84) ; J4A2.31 187.61,267.42 190.11,264.92 197.15,264.92 v1(198.62,263.45)
