# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DATA_A<24>: length 54.9
  TOP w0.165: v3(237.77,161.83) J3D1.AY36
  LAY2 w0.089: 250.89,126.74 250.79,126.85 250.79,127.22 251.12,127.55 251.12,128.12 250.64,128.59 250.64,129.51 250.68,129.55 250.68,130.38 250.82,130.53 250.82,131.1 251.11,131.39 251.11,131.92 246.07,136.97 246.07,141.21 245.98,141.3 245.52,141.3 245.44,141.21 245.44,139.47 245.35,139.39 244.91,139.39 244.8,139.5 244.8,150.31 240.3,154.81 238.16,160.48 238.16,161.27 237.77,161.66 v3(237.77,161.83) ; 250.89,126.74 250.68,126.53 250.68,126.16 251.09,124.24 251.09,123.69 J1F1.38 ; 250.89,126.74 251.07,126.93 251.32,126.93 251.41,127.02 251.41,127.22 251.32,127.31 251.32,128.76 251.25,128.83 251.05,128.83 250.95,128.93 250.95,129.13 251.04,129.22 251.51,129.22 251.6,129.32 251.6,129.53 251.32,130.06 J1E5.38
M_DATA_A<25>: length 54.7
  TOP w0.165: v3(236.86,161.83) J3D1.AY35
  LAY2 w0.089: 249.9,124.34 249.8,124.44 249.8,125.53 250.26,125.99 250.26,126.52 249.98,126.81 249.98,127.44 249.83,127.59 249.83,128.12 250.05,128.34 250.05,129.58 250.26,129.79 250.26,130.32 250.02,130.56 250.02,131.19 249.83,131.39 249.83,132.22 245.44,136.62 245.44,138.47 245.34,138.57 244.89,138.57 244.8,138.48 244.8,137.8 244.67,137.68 244.3,137.68 244.17,137.81 244.17,150.05 239.76,154.46 237.95,159.25 237.53,160.36 237.53,161.16 v3(236.86,161.83) ; 249.9,124.34 250.11,124.55 250.47,124.55 250.56,124.64 250.56,124.77 250.47,124.86 250.32,124.86 250.2,124.98 250.2,125.11 250.48,125.39 250.48,127.85 J1E5.183 ; 249.9,124.34 249.81,124.25 249.81,123.77 250.24,122.43 J1F1.183
M_DATA_A<26>: length 54.8
  TOP w0.165: v3(234.95,161.83) J3D1.AY33
  LAY2 w0.089: J1F1.45 245.16,124.5 245.16,126.61 244.73,127.69 244.73,128.23 ; 244.73,128.23 244.79,128.23 245.08,128.52 245.32,128.52 245.39,128.59 245.39,128.71 245.3,128.79 245.11,128.79 245.02,128.88 245.02,129.01 245.11,129.11 245.4,129.11 245.49,129.2 245.49,129.31 245.37,129.43 J1E5.45 ; 244.73,128.23 244.61,128.41 244.61,129.24 245.16,129.79 245.16,130.32 244.84,130.64 244.84,131.27 244.73,131.39 244.73,131.92 245.12,132.31 245.24,132.31 245.37,132.44 245.37,132.58 241.34,136.6 241.34,142.96 241.25,143.05 240.8,143.05 240.71,142.96 240.71,139.94 240.62,139.85 240.19,139.85 240.07,139.97 240.07,150.08 237.37,152.78 234.68,159.9 234.68,160.87 234.95,161.13 234.95,161.82 v3(234.95,161.83)
M_DATA_A<27>: length 55.8
  TOP w0.165: v3(234.5,162.89) J3D1.AW33
  LAY2 w0.089: v3(234.5,162.89) 234.51,162.88 234.51,161.47 234.03,161 234.03,159.82 236.83,152.43 239.44,149.81 239.44,138.06 239.54,137.96 239.97,137.96 240.07,138.06 240.07,138.68 240.16,138.77 240.62,138.77 240.71,138.68 240.71,136.34 244.31,132.74 244.31,131.39 243.83,130.27 243.83,129.91 244.31,128.12 244.31,127.48 243.84,126.54 243.84,125.97 244.29,124.42 244.29,123.62 243.74,123.06 243.74,122.68 243.84,122.57 243.87,122.57 ; J1E5.190 244.52,125.66 244.71,125.47 244.71,123.41 243.87,122.57 ; 243.87,122.57 243.87,122.55 243.86,122.53 243.86,122.1 244.5,119.42 J1F1.190
M_DATA_A<28>: length 54.9
  TOP w0.165: v3(238.15,163.8) J3D1.AV36
  LAY2 w0.089: v3(238.15,163.8) 238.15,163.51 238.56,163.1 238.56,162.53 239.43,161.66 239.43,160.86 239.44,160.83 241.46,155.47 246.08,150.86 246.08,143.01 246.19,142.9 246.6,142.9 246.71,143.01 246.71,143.49 246.8,143.58 247.26,143.58 247.35,143.49 247.35,137.48 252.81,132.02 252.81,131.23 252.61,131.03 252.61,130.56 252.38,130.32 252.38,129.79 252.42,129.75 252.42,128.51 252.81,128.12 252.81,127.59 252.49,127.27 252.49,126.85 252.59,126.74 ; 252.59,126.74 252.78,126.93 253.24,126.93 253.34,127.03 253.34,127.4 253.23,127.51 253.23,128.44 253.02,128.65 253.02,128.91 252.96,128.98 252.82,128.98 252.73,129.07 252.73,129.21 252.83,129.31 253.09,129.31 253.19,129.41 253.19,129.54 J1E5.36 ; 252.59,126.74 252.38,126.52 252.38,126.16 252.79,124.24 252.79,123.69 J1F1.36
M_DATA_A<29>: length 54.7
  TOP w0.165: v3(238.15,162.89) J3D1.AW36
  LAY2 w0.089: 251.6,124.34 251.81,124.55 252.17,124.55 252.26,124.64 252.26,124.77 252.17,124.86 252.02,124.86 251.9,124.98 251.9,125.11 252.18,125.39 252.18,127.85 J1E5.181 ; 251.6,124.34 251.5,124.44 251.5,125.51 251.97,125.98 251.97,126.52 251.74,126.74 251.74,127.37 251.53,127.58 251.53,128.12 251.94,128.53 251.94,129.66 251.96,129.69 251.96,130.32 251.68,130.6 251.68,131.24 251.53,131.39 251.53,132.4 246.7,137.23 246.7,142.12 246.56,142.26 246.14,142.26 245.89,142.01 245.54,142.01 245.44,142.12 245.44,150.58 240.94,155.07 240.92,155.12 240.92,155.12 240.56,156.07 238.8,160.72 238.8,161.37 238.15,162.01 v3(238.15,162.89) ; 251.6,124.34 251.51,124.25 251.51,123.77 251.94,122.43 J1F1.181
M_DATA_A<30>: length 54.8
  TOP w0.165: v3(235.87,161.83) J3D1.AY34
  LAY2 w0.089: J1E5.43 247.28,131.06 247.28,129.4 247.15,129.27 247,129.27 246.92,129.18 246.92,129.04 247,128.95 247.21,128.95 247.29,128.87 247.29,128.76 247.21,128.67 246.93,128.67 246.48,128.22 ; J1F1.43 247.05,125.95 246.43,127.71 246.43,128.17 246.48,128.22 ; 246.48,128.22 246.4,128.3 246.4,129.33 246.86,129.79 246.86,130.32 246.58,130.6 246.58,131.24 246.43,131.39 246.43,131.94 246.93,132.44 246.93,132.81 242.61,137.13 242.61,148.08 242.52,148.17 242.07,148.17 241.98,148.08 241.98,145 241.88,144.91 241.46,144.91 241.34,145.03 241.34,150.61 238.46,153.49 235.97,160.07 235.97,160.58 235.87,160.68 v3(235.87,161.83)
M_DATA_A<31>: length 56.8
  TOP w0.165: v3(235.41,163.8) J3D1.AV33
  LAY2 w0.089: J1F1.188 246.2,119.4 245.56,122.11 245.56,122.56 ; J1E5.188 246.22,125.67 246.41,125.48 246.41,123.41 245.56,122.56 ; 245.56,122.56 245.38,122.56 245.25,122.69 245.25,122.83 245.99,123.57 245.99,124.15 245.82,124.32 245.82,124.66 246.02,124.86 246.02,125.1 245.73,125.39 245.73,125.84 245.58,125.99 245.58,126.52 245.9,126.84 245.9,127.48 246.01,127.59 246.01,128.17 245.89,128.3 245.89,129.48 245.58,129.79 245.58,130.32 245.91,130.66 245.91,131.29 246.01,131.39 246.01,132.17 246.17,132.33 246.17,132.68 241.98,136.87 241.98,143.76 241.85,143.89 241.39,143.89 241.24,143.74 240.81,143.74 240.71,143.84 240.71,150.34 237.91,153.14 235.34,159.96 235.34,160.47 235.41,160.54 235.41,162.43 235.86,162.88 235.86,163.36 v3(235.41,163.8)
M_DATA_A<32>: length 55.5
  TOP w0.165: v3(211.27,164.72) J3D1.AW10
  LAY2 w0.088: 212.03,162.59 212.03,163.23 212.38,163.57 212.38,165.07 212.17,165.28 211.83,165.28 v3(211.27,164.72)
  LAY2 w0.089: 212.03,162.59 212.03,159.95 211.05,158.96 211.05,158.75 210.33,158.03 210.33,157.4 198.28,145.35 198.28,139.55 198.31,139.53 198.31,134.69 195.92,132.3 195.8,132.3 195.43,131.92 195.43,131.39 195.55,131.27 195.55,130.64 195.86,130.32 195.86,129.79 195.31,129.24 195.31,128.41 195.43,128.23 195.43,128.17 ; J1E5.97 196.07,129.43 196.17,129.32 196.17,129.19 196.08,129.11 195.81,129.11 195.72,129.01 195.72,128.88 195.81,128.79 196,128.79 196.09,128.71 196.09,128.59 196.02,128.52 195.78,128.52 195.43,128.17 ; 195.43,128.17 195.43,127.69 195.86,126.51 195.86,124.5 J1F1.97
M_DATA_A<33>: length 59
  TOP w0.165: v3(211.27,163.8) J3D1.AW9
  LAY2 w0.088: 211.4,162.86 211.54,163.01 211.54,163.52 v3(211.27,163.8)
  LAY2 w0.089: 194.56,122.56 194.44,122.68 194.44,123.06 194.99,123.62 194.99,124.15 194.71,124.44 194.71,125.86 194.48,126.09 194.48,126.42 194.82,126.76 194.82,127.4 195.01,127.59 195.01,128.12 194.46,128.67 194.46,128.87 194.56,128.96 194.85,128.96 194.93,129.04 194.93,129.18 194.79,129.32 194.57,129.32 194.46,129.43 194.46,130.62 195.01,131.17 195.01,132.31 197.63,134.93 197.63,145.59 209.7,157.66 209.7,158.3 211.4,160 211.4,162.86 ; 194.56,122.56 195.41,123.41 195.41,124.46 195.22,124.65 J1E5.242 ; 194.56,122.56 194.56,122.1 194.99,120.17 J1F1.242
M_DATA_A<34>: length 56.5
  TOP w0.165: v3(208.98,162.74) J3D1.AY7
  LAY2 w0.088: 208.65,161.37 208.65,161.94 208.98,162.28 v3(208.98,162.74)
  LAY2 w0.089: J1E5.104 190.49,129.35 190.49,129.18 190.44,129.13 190.23,129.13 190.14,129.04 190.14,128.92 190.23,128.83 190.86,128.83 190.95,128.74 190.95,128.62 190.86,128.53 190.6,128.53 190.49,128.42 190.49,128.28 190.33,128.12 190.33,127.59 190.49,127.43 190.49,126.86 ; J1F1.104 190.25,123.1 190.31,123.5 190.31,123.98 190.76,125.98 190.76,126.53 190.49,126.86 ; 190.49,126.86 190.41,126.86 190.2,126.94 190.13,127.01 190.13,128.53 189.61,129.05 189.61,129.66 189.48,129.79 189.48,130.32 190.33,131.17 190.33,131.95 190.97,132.59 190.97,133.79 191.06,133.88 191.51,133.88 191.6,133.79 191.6,133.68 191.69,133.59 192.15,133.59 192.24,133.68 192.24,134.27 191.96,134.55 191.96,134.73 192.74,135.51 193.37,135.51 193.5,135.65 193.5,136.28 194.4,137.17 194.68,137.17 194.77,137.26 194.77,146.72 206.88,158.82 206.88,159.46 208.65,161.23 208.65,161.37
M_DATA_A<35>: length 59.9
  TOP w0.165: v3(208.5,165.63) J3D1.AV7
  LAY2 w0.088: v3(208.5,165.63) 208.1,165.22 208.1,164.55 208.65,164 208.65,162.98 208.5,162.83 208.5,162.6 208.08,162.18 208.08,161.56
  LAY2 w0.089: J1E5.249 189.27,126.98 189.06,126.77 189.06,124.95 189.38,124.63 189.48,124.63 189.93,124.17 ; 189.93,124.17 189.98,124.22 189.98,124.73 189.84,124.88 189.84,125.63 189.48,125.99 189.48,126.52 189.67,126.71 189.67,127.35 189.91,127.59 189.91,128.12 189.53,128.5 189.36,128.5 189.06,128.8 189.06,130.54 189.91,131.39 189.91,132.62 190.34,133.04 190.34,134.05 194.14,137.86 194.14,146.98 206.25,159.09 206.25,159.73 208.08,161.56 ; 189.93,124.17 189.91,124.15 189.91,123.64 189.47,122.54 J1F1.249
M_DATA_A<36>: length 55.5
  TOP w0.165: v3(214.31,162.89) J3D1.AW11
  LAY2 w0.088: 213.3,160.43 213.3,162.55 213.64,162.89 v3(214.31,162.89)
  LAY2 w0.089: J1E5.95 197.77,129.43 197.87,129.33 197.87,129.19 197.78,129.11 197.51,129.11 197.42,129.01 197.42,128.88 197.51,128.79 197.7,128.79 197.79,128.71 197.79,128.6 197.7,128.52 197.47,128.52 197.18,128.23 197.13,128.23 ; 197.13,128.23 197.13,127.75 197.56,126.52 197.56,124.52 J1F1.95 ; 197.13,128.23 197.02,128.39 197.02,129.24 197.57,129.79 197.57,130.38 197.13,130.82 197.13,131.96 197.47,132.31 197.77,132.31 199.58,134.11 199.58,135.52 199.68,135.62 199.93,135.62 200.03,135.72 200.03,136.04 199.9,136.18 199.66,136.18 199.58,136.27 199.58,137.96 199.66,138.05 199.99,138.05 200.1,138.17 200.1,140.08 199.98,140.2 199.68,140.2 199.58,140.3 199.58,141 199.69,141.11 200,141.11 200.09,141.2 200.09,142.24 199.97,142.35 199.67,142.35 199.58,142.45 199.58,143.24 199.69,143.36 200,143.36 200.09,143.45 200.09,143.81 199.98,143.91 199.68,143.91 199.58,144.01 199.58,144.85 211.6,156.87 211.6,157.51 212.09,158 212.09,158.61 213.3,159.83 213.3,160.43
M_DATA_A<37>: length 60.2
  TOP w0.165: v3(214.31,163.8) J3D1.AV11
  LAY2 w0.088: 212.67,162.48 212.67,162.95 213.52,163.8 v3(214.31,163.8)
  LAY2 w0.089: J1F1.240 196.69,120.17 196.26,122.1 196.26,122.56 ; 196.26,122.56 197.11,123.41 197.11,124.5 196.92,124.69 J1E5.240 ; 196.26,122.56 196.1,122.56 195.94,122.72 195.94,122.84 196.69,123.59 196.69,124.15 196.43,124.41 196.43,125.84 196.13,126.14 196.13,126.74 196.34,126.95 196.6,126.95 196.75,127.1 196.75,128.13 196.59,128.3 196.59,129.48 196.28,129.79 196.28,130.32 196.83,130.88 196.83,132.27 198.94,134.38 198.94,134.43 198.94,138.48 199.03,138.57 199.28,138.57 199.4,138.69 199.41,138.69 199.41,139.52 199.28,139.64 199.09,139.64 198.91,139.82 198.91,145.08 210.96,157.13 210.96,157.77 211.61,158.41 211.61,158.83 212.67,159.89 212.67,162.48
M_DATA_A<38>: length 55.9
  TOP w0.165: v3(209.89,162.74) J3D1.AY8
  LAY2 w0.088: v3(209.89,162.74) 209.84,162.69
  LAY2 w0.089: 209.84,162.69 209.84,160.62 208.15,158.94 208.15,158.3 196.04,146.19 196.04,135.54 195.95,135.45 195.5,135.45 195.41,135.54 195.41,135.74 195.3,135.84 194.88,135.84 194.77,135.74 194.77,134.27 193.21,132.71 193.21,132.71 192.81,132.31 192.39,132.31 192.03,131.95 192.03,130.96 191.77,130.7 191.55,130.7 191.18,130.32 191.18,129.79 191.51,129.46 191.51,129.31 191.83,129 191.83,127.06 191.98,126.9 192.15,126.83 192.47,126.83 ; J1E5.102 191.82,129.51 191.91,129.42 192.17,129.42 192.24,129.35 192.24,129.2 192.15,129.11 192.15,128.91 192.22,128.83 192.62,128.83 192.69,128.76 192.69,128.59 192.6,128.5 192.4,128.5 192.03,128.12 192.03,127.59 192.47,127.15 192.47,126.83 192.47,126.83 ; 192.47,126.83 192.47,126.06 192.01,124.02 192.01,123.58 J1F1.102
M_DATA_A<39>: length 59.5
  TOP w0.165: v3(209.44,163.8) J3D1.AW7
  LAY2 w0.088: v3(209.44,163.8) 209.44,162.09 209.27,161.92 209.27,161.27
  LAY2 w0.089: 191.63,124.17 191.68,124.22 191.68,125.49 191.18,125.99 191.18,126.52 191.41,126.76 191.41,127.39 191.61,127.59 191.61,128.12 191.3,128.43 191.3,128.94 190.76,129.48 190.76,130.54 191.61,131.39 191.61,132.59 191.97,132.95 192.55,132.95 193.17,133.57 193.17,133.9 192.87,134.2 192.87,134.73 193,134.87 193.41,134.87 193.5,134.78 193.5,134.6 193.65,134.45 194.05,134.45 194.14,134.54 194.14,136.01 194.63,136.5 195.32,136.5 195.41,136.59 195.41,146.45 207.52,158.56 207.52,159.2 209.27,160.95 209.27,161.27 ; 191.63,124.17 191.61,124.15 191.61,123.64 191.17,122.54 J1F1.247 ; 191.63,124.17 191.22,124.59 191.04,124.59 190.93,124.7 190.93,124.99 191.13,125.19 191.13,125.44 190.96,125.93 190.96,127.85 J1E5.247
M_DATA_A<40>: length 57.3
  TOP w0.165: v3(207.7,163.8) J3D1.AW5
  LAY2 w0.088: 205.38,161.22 206.27,162.11 206.27,162.6 206.88,163.53 207.16,163.8 v3(207.7,163.8)
  LAY2 w0.089: 186.29,126.74 186.47,126.93 186.72,126.93 186.81,127.02 186.81,127.22 186.72,127.31 186.72,128.76 186.65,128.83 186.45,128.83 186.35,128.93 186.35,129.13 186.44,129.22 186.91,129.22 187,129.32 187,129.53 186.72,130.06 J1E5.108 ; 186.29,126.74 186.08,126.53 186.08,126.16 186.49,124.24 186.49,123.69 J1F1.108 ; 186.29,126.74 186.13,126.91 186.13,127.16 186.52,127.55 186.52,128.12 186.04,128.59 186.04,129.51 186.08,129.55 186.08,130.38 186.22,130.53 186.22,131.1 186.51,131.39 186.51,132.07 186.88,132.44 186.88,132.78 187.04,132.94 187.42,132.94 187.53,133.04 187.53,133.3 187.44,133.39 187.33,133.39 187.25,133.48 187.25,133.85 191.49,138.1 191.49,147.66 205.05,161.22 205.38,161.22
M_DATA_A<41>: length 59.1
  TOP w0.165: v3(205.83,162.89) J3D1.AY4
  LAY2 w0.088: v3(205.83,162.89) 205.76,162.81 205.76,162.29 205.25,161.78
  LAY2 w0.089: 185.3,124.34 185.51,124.55 185.87,124.55 185.96,124.64 185.96,124.77 185.87,124.86 185.72,124.86 185.6,124.98 185.6,125.11 185.88,125.39 185.88,127.85 J1E5.253 ; 185.3,124.34 185.2,124.44 185.2,125.53 185.66,125.99 185.66,126.52 185.38,126.81 185.38,127.44 185.23,127.59 185.23,128.12 185.45,128.34 185.45,129.58 185.66,129.79 185.66,130.32 185.42,130.56 185.42,131.19 185.23,131.39 185.23,132.72 185.33,132.83 185.52,132.83 185.61,132.74 185.61,132.47 185.78,132.3 186.07,132.3 186.24,132.47 186.24,132.83 185.98,133.09 185.98,133.48 190.86,138.36 190.86,147.92 204.72,161.78 205.25,161.78 ; 185.3,124.34 185.21,124.25 185.21,123.77 185.64,122.43 J1F1.253
M_DATA_A<42>: length 56.9
  TOP w0.165: v3(203.95,164.72) J3D1.AV2
  LAY2 w0.088: 202.62,164.05 202.81,164.24 203.48,164.24 v3(203.95,164.72)
  LAY2 w0.089: J1E5.115 180.77,129.43 180.89,129.31 180.89,129.2 180.8,129.11 180.51,129.11 180.42,129.01 180.42,128.88 180.51,128.79 180.7,128.79 180.79,128.71 180.79,128.59 180.72,128.52 180.48,128.52 180.19,128.23 ; 180.19,128.23 180.04,128.38 180.04,129.27 180.56,129.79 180.56,130.32 180.25,130.64 180.25,131.27 180.13,131.39 180.13,131.99 185.25,137.12 185.49,137.12 188.04,139.66 188.04,149.09 202.62,163.68 202.62,164.05 ; 180.19,128.23 180.12,128.16 180.12,127.72 180.56,126.51 180.56,124.5 J1F1.115
M_DATA_A<43>: length 62.1
  TOP w0.165: v3(202.95,164.84) J3D1.AV1
  LAY2 w0.088: 202.89,164.84 v3(202.95,164.84)
  LAY2 w0.089: 179.26,122.56 179.26,122.1 179.69,120.17 J1F1.260 ; 179.26,122.56 179.09,122.73 179.09,123.02 179.69,123.62 179.69,124.15 179.48,124.37 179.48,125.79 179.28,125.99 179.28,126.52 179.42,126.66 179.42,127.3 179.71,127.59 179.71,128.12 179.51,128.32 179.51,129.55 179.28,129.79 179.28,130.32 179.6,130.64 179.6,131.28 179.71,131.39 179.71,132.56 185.01,137.86 185.34,137.86 187.4,139.93 187.4,149.36 202.89,164.84 ; 179.26,122.56 180.11,123.41 180.11,124.45 179.92,124.64 J1E5.260
M_DATA_A<44>: length 58.9
  TOP w0.165: v3(207.7,164.72) J3D1.AV5
  LAY2 w0.088: v3(207.7,164.72) 207.7,164.37 208.1,163.97 208.1,163.64 207.4,162.94 207.4,161.77
  LAY2 w0.089: J1E5.106 188.59,129.54 188.59,129.41 188.49,129.31 188.23,129.31 188.13,129.21 188.13,129.07 188.22,128.98 188.36,128.98 188.42,128.91 188.42,128.65 188.63,128.44 188.63,127.51 188.74,127.4 188.74,127.03 188.64,126.93 188.18,126.93 187.99,126.74 ; 187.99,126.74 187.78,126.52 187.78,126.16 188.19,124.24 188.19,123.69 J1F1.106 ; 187.99,126.74 187.89,126.85 187.89,127.27 188.21,127.59 188.21,128.12 187.82,128.51 187.82,129.75 187.78,129.79 187.78,130.32 188.01,130.56 188.01,131.03 188.21,131.23 188.21,131.76 189.08,132.63 189.08,133.89 193.36,138.17 193.36,139.11 193.26,139.21 193.03,139.21 192.92,139.32 192.92,139.76 193.01,139.85 193.27,139.85 193.36,139.94 193.36,140.42 193.26,140.52 192.96,140.52 192.85,140.62 192.85,141.07 192.94,141.16 193.27,141.16 193.36,141.24 193.36,141.72 193.26,141.82 193.06,141.82 192.95,141.92 192.95,142.37 193.04,142.46 193.27,142.46 193.36,142.54 193.36,147.74 207.4,161.77
M_DATA_A<45>: length 58.9
  TOP w0.165: v3(206.98,162.73) J3D1.AY5
  LAY2 w0.088: v3(206.98,162.73) 206.77,162.39 206.77,161.94
  LAY2 w0.089: J1E5.251 187.58,127.85 187.58,125.39 187.3,125.11 187.3,124.98 187.42,124.86 187.57,124.86 187.66,124.77 187.66,124.64 187.57,124.55 187.21,124.55 187,124.34 ; J1F1.251 187.34,122.43 186.91,123.77 186.91,124.25 187,124.34 ; 187,124.34 186.9,124.44 186.9,125.51 187.37,125.98 187.37,126.52 187.14,126.74 187.14,127.37 186.93,127.58 186.93,128.12 187.34,128.53 187.34,129.66 187.36,129.69 187.36,130.32 187.08,130.6 187.08,131.24 186.93,131.39 186.93,131.83 186.93,131.92 187.3,132.3 187.51,132.3 187.52,132.3 187.68,132.3 188.16,132.78 188.16,133.87 192.53,138.24 192.53,138.74 192.22,139.06 192.22,143.12 192.31,143.21 192.62,143.21 192.72,143.32 192.72,143.76 192.62,143.85 192.32,143.85 192.22,143.95 192.22,144.42 192.31,144.51 192.66,144.51 192.73,144.59 192.73,145.04 192.62,145.15 192.32,145.15 192.22,145.25 192.22,147.49 205.39,160.66 205.49,160.66 206.77,161.94
M_DATA_A<46>: length 56.5
  TOP w0.165: v3(204.86,164.72) J3D1.AW3
  LAY2 w0.088: v3(204.86,164.72) 204.86,163.96 203.79,162.89
  LAY2 w0.089: 181.88,128.22 181.88,128.12 181.83,128.07 181.83,127.73 182.26,126.6 182.26,124.52 J1F1.113 ; 181.88,128.22 181.79,128.22 181.67,128.34 181.67,129.2 182.26,129.79 182.26,130.32 181.98,130.6 181.98,131.24 181.83,131.39 181.83,131.92 182.2,132.3 182.24,132.3 182.7,132.75 183.05,132.75 189.3,139.01 189.3,148.57 203.62,162.89 203.79,162.89 ; 181.88,128.22 181.92,128.22 182.33,128.63 182.57,128.63 182.66,128.72 182.66,128.87 182.58,128.95 182.39,128.95 182.3,129.04 182.3,129.18 182.39,129.27 182.55,129.27 182.67,129.39 182.67,131.07 J1E5.113
M_DATA_A<47>: length 61.6
  TOP w0.165: v3(203.95,163.8) J3D1.AW2
  LAY2 w0.088: v3(203.95,163.8) 203.54,163.4
  LAY2 w0.089: J1F1.258 181.39,120.17 180.96,122.1 180.96,122.56 ; 180.96,122.56 180.85,122.56 180.69,122.71 180.69,122.92 181.39,123.62 181.39,124.15 181.13,124.41 181.13,125.84 180.98,125.99 180.98,126.52 181.17,126.72 181.17,127.35 181.41,127.59 181.41,128.11 181.29,128.24 181.29,129.48 180.98,129.79 180.98,130.32 181.31,130.66 181.31,131.29 181.41,131.39 181.41,132.36 183.85,134.8 184.13,134.8 184.22,134.89 184.22,135.17 184.31,135.27 184.67,135.27 184.79,135.38 184.79,135.74 184.89,135.84 185.24,135.84 185.36,135.96 185.36,136.22 185.49,136.34 185.75,136.34 188.67,139.27 188.67,148.83 203.24,163.4 203.54,163.4 ; 180.96,122.56 181.59,123.19 181.81,123.41 181.81,124.47 181.62,124.66 J1E5.258
M_DATA_A<48>: length 69.5
  TOP w0.165: v3(202.78,166.55) J3D1.AT1
  LAY2 w0.088: 202.29,166.55 v3(202.78,166.55)
  LAY2 w0.089: 176.73,128.17 176.73,128.23 176.61,128.41 176.61,129.24 177.16,129.79 177.16,130.32 176.84,130.64 176.84,131.27 176.73,131.39 176.73,132.24 177.37,132.88 177.37,133.04 181.22,136.89 181.22,140.03 181.03,140.22 180.67,140.22 180.59,140.13 180.59,137.09 180.24,136.75 180.12,136.75 179.8,137.06 179.8,137.2 179.95,137.35 179.95,145.16 182.48,147.69 183.96,147.69 184.11,147.83 184.11,149.31 199.97,165.18 200.92,165.18 202.29,166.55 ; 176.73,128.17 177.08,128.52 177.32,128.52 177.39,128.59 177.39,128.71 177.3,128.79 177.11,128.79 177.02,128.88 177.02,129.01 177.11,129.11 177.38,129.11 177.47,129.19 177.47,129.32 177.37,129.43 J1E5.119 ; 176.73,128.17 176.73,127.69 177.16,126.51 177.16,124.5 J1F1.119
M_DATA_A<49>: length 71.4
  TOP w0.165: v3(202.78,167.41) J3D1.AR1
  LAY2 w0.089: v3(202.78,167.41) 202.61,167.24 202.26,167.24 200.83,165.81 199.71,165.81 179.32,145.42 179.32,137.68 177.23,135.6 177.23,135.44 177.53,135.13 177.66,135.13 178.97,136.44 179.1,136.44 179.43,136.12 179.43,136 176.74,133.31 176.74,133.3 176.12,132.69 176.12,132.23 176.31,132.04 176.31,131.39 175.83,130.27 175.83,129.91 176.31,128.12 176.31,127.59 176.12,127.4 176.12,126.76 175.88,126.52 175.88,125.99 176.01,125.86 176.01,124.44 176.29,124.15 176.29,123.62 175.74,123.06 175.74,122.68 175.86,122.56 ; J1E5.264 176.52,124.65 176.71,124.46 176.71,123.41 175.86,122.56 ; 175.86,122.56 175.86,122.1 176.29,120.17 J1F1.264
M_DATA_A<50>: length 71.4
  TOP w0.165: v3(202.89,169.75) J3D1.AN1
  LAY2 w0.088: 201.89,169.75 v3(202.89,169.75)
  LAY2 w0.089: 171.79,126.86 171.79,127.43 171.63,127.59 171.63,128.12 171.79,128.28 171.79,128.42 171.9,128.53 172.16,128.53 172.25,128.62 172.25,128.74 172.16,128.83 171.53,128.83 171.44,128.92 171.44,129.04 171.53,129.13 171.74,129.13 171.79,129.18 171.79,129.35 J1E5.126 ; 171.79,126.86 172.06,126.53 172.06,125.98 171.61,123.98 171.61,123.5 171.55,123.1 J1F1.126 ; 171.79,126.86 171.71,126.86 171.5,126.94 171.43,127.01 171.43,128.53 170.91,129.05 170.91,129.66 170.78,129.79 170.78,130.32 171.63,131.17 171.63,131.95 172.56,132.88 172.56,135.49 172.76,135.69 175.22,138.15 175.22,143.8 175.22,143.8 175.22,145.23 175.33,145.33 175.76,145.33 175.85,145.24 175.85,144.33 175.97,144.22 176.4,144.22 176.49,144.31 176.49,146.59 198.99,169.1 201.24,169.1 201.89,169.75
M_DATA_A<51>: length 75
  TOP w0.165: v3(205.78,169.29) J3D1.AN3
  LAY2 w0.088: 201.71,170.16 204.34,170.16 204.69,169.82 205.52,169.82 205.78,169.56 v3(205.78,169.29)
  LAY2 w0.089: J1F1.271 170.77,122.54 171.21,123.64 171.21,124.15 171.23,124.17 ; J1E5.271 170.57,126.98 170.36,126.77 170.36,124.95 170.68,124.63 170.78,124.63 171.23,124.17 ; 171.23,124.17 171.28,124.22 171.28,124.73 171.14,124.88 171.14,125.63 170.78,125.99 170.78,126.52 170.97,126.71 170.97,127.35 171.21,127.59 171.21,128.12 170.84,128.5 170.66,128.5 170.36,128.8 170.36,130.54 171.21,131.39 171.21,132.49 171.93,133.2 171.93,135.75 172.13,135.95 172.32,136.14 172.32,136.15 174.58,138.41 174.58,145.59 198.73,169.73 201.28,169.73 201.71,170.16
M_DATA_A<52>: length 69.6
  TOP w0.165: v3(204.86,166.55) J3D1.AT3
  LAY2 w0.088: 202.41,165.24 202.96,165.24 203.75,166.03 204.35,166.03 v3(204.86,166.55)
  LAY2 w0.089: J1F1.117 178.86,124.52 178.86,126.52 178.43,127.75 178.43,128.17 ; 178.43,128.17 178.77,128.52 179,128.52 179.09,128.6 179.09,128.71 179,128.79 178.81,128.79 178.72,128.88 178.72,129.01 178.81,129.11 179.08,129.11 179.17,129.19 179.17,129.33 179.07,129.43 J1E5.117 ; 178.43,128.17 178.43,128.23 178.27,128.43 178.27,129.2 178.87,129.79 178.87,130.38 178.7,130.54 178.55,130.7 178.55,131.27 178.43,131.39 178.43,131.97 178.86,132.41 178.86,132.75 183.76,137.64 183.76,139.28 183.67,139.37 181.22,141.82 181.22,144.55 183.09,146.42 185.26,146.42 185.38,146.53 185.38,148.49 185.5,148.61 185.92,148.61 186.01,148.52 186.01,146.03 186.14,145.91 186.52,145.91 186.64,146.03 186.64,150.05 200.5,163.91 201.08,163.91 202.41,165.24
M_DATA_A<53>: length 71.4
  TOP w0.165: v3(203.95,166.55) J3D1.AT2
  LAY2 w0.088: v3(203.95,166.55) 203.88,166.47 203.42,166.47 203.01,166.06 202.62,166.06 202.43,165.87 202.32,165.87
  LAY2 w0.089: J1F1.262 177.99,120.17 177.56,122.1 177.56,122.56 ; 177.56,122.56 177.38,122.56 177.25,122.69 177.25,122.83 177.99,123.57 177.99,124.15 177.73,124.41 177.73,125.84 177.58,125.99 177.58,126.52 177.9,126.84 177.9,127.48 178.01,127.59 178.01,128.17 177.89,128.3 177.89,129.48 177.58,129.79 177.58,130.32 177.91,130.66 177.91,131.29 178.01,131.39 178.01,132.45 178.21,132.65 178.21,132.99 181.85,136.63 181.85,138.33 181.94,138.42 182.36,138.42 182.49,138.29 182.49,137.86 182.58,137.77 183,137.77 183.12,137.9 183.12,139.02 182.7,139.44 182.06,139.44 181.85,139.65 181.85,140.29 180.59,141.55 180.59,144.9 182.75,147.05 184.52,147.05 184.74,147.27 184.74,148.89 185.14,149.29 185.43,149.29 186.01,149.87 186.01,150.32 200.23,164.54 200.99,164.54 202.32,165.87 ; 177.56,122.56 178.41,123.41 178.41,124.5 178.22,124.69 J1E5.262
M_DATA_A<54>: length 69.9
  TOP w0.165: v3(202.89,168.76) J3D1.AP1
  LAY2 w0.088: 202.17,168.76 v3(202.89,168.76)
  LAY2 w0.089: J1F1.124 173.31,123.58 173.31,124.02 173.77,126.06 173.77,126.83 ; 202.17,168.76 201.18,167.78 199.47,167.78 177.75,146.06 177.75,138.32 177.67,138.23 177.21,138.23 177.12,138.32 177.12,139.51 177.03,139.6 176.64,139.6 176.49,139.45 176.49,137.62 173.83,134.96 173.83,132.44 173.33,131.94 173.33,130.96 173.07,130.7 172.85,130.7 172.48,130.32 172.48,129.79 172.81,129.46 172.81,129.31 173.13,129 173.13,127.06 173.28,126.9 173.45,126.83 173.77,126.83 ; 173.77,126.83 173.77,126.83 173.77,127.15 173.33,127.59 173.33,128.12 173.7,128.5 173.9,128.5 173.99,128.59 173.99,128.76 173.92,128.83 173.52,128.83 173.45,128.91 173.45,129.11 173.54,129.2 173.54,129.35 173.47,129.42 173.21,129.42 173.12,129.51 J1E5.124
M_DATA_A<55>: length 75.3
  TOP w0.165: v3(203.95,169.29) J3D1.AN2
  LAY2 w0.088: 202.05,169.29 v3(203.95,169.29)
  LAY2 w0.089: 172.93,124.17 172.98,124.22 172.98,125.49 172.48,125.99 172.48,126.52 172.71,126.76 172.71,127.39 172.91,127.59 172.91,128.12 172.6,128.43 172.6,128.94 172.06,129.48 172.06,130.54 172.91,131.39 172.91,132.28 173.19,132.56 173.19,135.23 175.85,137.88 175.85,142.86 175.94,142.95 176.34,142.95 176.49,142.8 176.49,140.82 176.58,140.73 177.03,140.73 177.12,140.82 177.12,146.33 199.2,168.41 201.17,168.41 202.05,169.29 ; 172.93,124.17 172.52,124.59 172.34,124.59 172.23,124.7 172.23,124.99 172.43,125.19 172.43,125.44 172.26,125.93 172.26,127.85 J1E5.269 ; 172.93,124.17 172.91,124.15 172.91,123.64 172.47,122.54 J1F1.269
M_DATA_A<56>: length 80.9
  TOP w0.165: J3D1.AL2 203.95,172.03 v3(203.95,172.07)
  LAY2 w0.089: 167.59,126.74 167.49,126.85 167.49,127.22 167.82,127.55 167.82,128.12 167.34,128.59 167.34,129.51 167.38,129.55 167.38,130.38 167.52,130.53 167.52,131.1 167.81,131.39 167.81,132.07 168.74,133 168.74,133.11 168.75,133.11 168.75,136.55 168.87,136.67 169.29,136.67 169.38,136.58 169.38,134.12 169.53,133.97 169.86,133.97 170.02,134.13 170.02,141.78 170.19,141.96 170.55,141.96 170.64,141.87 170.64,141.74 170.72,141.65 171.2,141.65 171.28,141.74 171.28,143.97 173.13,147.24 197.52,171.63 201,171.63 201.18,171.82 202.48,171.82 202.67,172.02 203.89,172.02 v3(203.95,172.07) ; 167.59,126.74 167.38,126.53 167.38,126.16 167.79,124.24 167.79,123.69 J1F1.130 ; 167.59,126.74 167.77,126.93 168.02,126.93 168.11,127.02 168.11,127.22 168.02,127.31 168.02,128.76 167.95,128.83 167.75,128.83 167.65,128.93 167.65,129.13 167.74,129.22 168.21,129.22 168.3,129.32 168.3,129.53 168.02,130.06 J1E5.130
M_DATA_A<57>: length 80.7
  TOP w0.165: v3(202.89,172.45) 202.89,172.45 J3D1.AK1
  LAY2 w0.088: v3(202.89,172.45) 202.88,172.45 202.84,172.44 202.03,172.44
  LAY2 w0.089: J1F1.275 166.94,122.43 166.51,123.77 166.51,124.25 166.6,124.34 ; 202.03,172.44 201.04,172.44 200.86,172.27 197.26,172.27 172.48,147.49 169.38,141.99 169.38,137.85 169.26,137.73 168.91,137.73 168.75,137.89 168.75,139.69 168.66,139.78 168.19,139.78 168.1,139.69 168.1,133.27 167.18,132.34 166.89,132.34 166.53,131.98 166.53,131.39 166.72,131.19 166.72,130.56 166.96,130.32 166.96,129.79 166.75,129.58 166.75,128.34 166.53,128.12 166.53,127.59 166.68,127.44 166.68,126.81 166.96,126.52 166.96,125.99 166.5,125.53 166.5,124.44 166.6,124.34 ; 166.6,124.34 166.81,124.55 167.17,124.55 167.26,124.64 167.26,124.77 167.17,124.86 167.02,124.86 166.9,124.98 166.9,125.11 167.18,125.39 167.18,127.85 J1E5.275
M_DATA_A<58>: length 80.7
  TOP w0.165: v3(202.89,174.32) J3D1.AH1
  LAY2 w0.088: v3(202.89,174.32) 202.01,174.32
  LAY2 w0.089: 161.43,128.23 161.31,128.41 161.31,129.24 161.86,129.79 161.86,130.32 161.55,130.64 161.55,131.27 161.43,131.39 161.43,132.13 161.73,132.43 162.32,132.43 162.44,132.55 162.44,132.95 162.32,133.06 161.74,133.06 161.66,133.15 161.66,133.62 161.73,133.7 162.94,133.7 163.05,133.8 163.05,134.25 162.96,134.33 162,134.33 161.86,134.48 161.86,134.64 169.92,148.94 196.08,175.09 201.24,175.09 202.01,174.32 ; 161.43,128.23 161.49,128.23 161.78,128.52 162.02,128.52 162.09,128.59 162.09,128.71 162,128.79 161.81,128.79 161.72,128.88 161.72,129.01 161.81,129.11 162.1,129.11 162.19,129.2 162.19,129.31 162.07,129.43 J1E5.137 ; 161.43,128.23 161.43,127.69 161.86,126.61 161.86,124.5 J1F1.137
M_DATA_A<59>: length 86.5
  TOP w0.165: v3(204.86,174.78) J3D1.AH3
  LAY2 w0.088: v3(204.86,174.78) 204.47,175.17 203.79,175.17 203.42,174.81 202.19,174.81
  LAY2 w0.089: 160.57,122.57 160.54,122.57 160.44,122.68 160.44,123.06 160.99,123.62 160.99,124.48 160.54,126.04 160.54,126.43 161.01,127.49 161.01,128.12 160.57,129.78 160.57,130.35 161.01,131.39 161.01,132.14 160.88,132.27 160.69,132.27 160.6,132.35 160.6,132.84 160.7,132.94 160.93,132.94 161.02,133.04 161.02,133.56 160.91,133.67 160.84,133.67 160.73,133.78 160.73,134.16 160.84,134.27 160.99,134.27 161.1,134.38 161.26,134.88 169.41,149.32 195.81,175.73 201.28,175.73 202.19,174.81 ; 160.57,122.57 161.41,123.41 161.41,125.47 161.22,125.66 J1E5.282 ; 160.57,122.57 160.57,122.55 160.56,122.53 160.56,122.1 161.2,119.42 J1F1.282
M_DATA_A<60>: length 80.9
  TOP w0.165: J3D1.AL3 204.91,171.17 v3(204.86,171.17)
  LAY2 w0.088: 202.03,170.8 202.56,170.8 202.73,170.97 203.05,170.97 203.3,170.72 204.11,170.72 204.55,171.17 v3(204.86,171.17)
  LAY2 w0.089: 169.29,126.74 169.08,126.52 169.08,126.16 169.49,124.24 169.49,123.69 J1F1.128 ; 169.29,126.74 169.48,126.93 169.94,126.93 170.04,127.03 170.04,127.4 169.93,127.51 169.93,128.44 169.72,128.65 169.72,128.91 169.66,128.98 169.52,128.98 169.43,129.07 169.43,129.21 169.53,129.31 169.79,129.31 169.89,129.41 169.89,129.54 J1E5.128 ; 169.29,126.74 169.19,126.85 169.19,127.27 169.51,127.59 169.51,128.12 169.12,128.51 169.12,129.75 169.08,129.79 169.08,130.32 169.31,130.56 169.31,131.03 169.51,131.23 169.51,131.83 171.28,133.6 171.28,136.09 172.55,137.36 172.55,142.35 172.68,142.47 173.04,142.47 173.19,142.33 173.19,138.9 173.27,138.81 173.73,138.81 173.82,138.9 173.82,145.83 173.82,145.83 174.22,146.54 198.05,170.37 201.04,170.37 201.47,170.8 202.03,170.8
M_DATA_A<61>: length 80.7
  TOP w0.165: v3(202.89,171.58) J3D1.AL1
  LAY2 w0.089: J1E5.273 168.88,127.85 168.88,125.39 168.6,125.11 168.6,124.98 168.72,124.86 168.87,124.86 168.96,124.77 168.96,124.64 168.87,124.55 168.51,124.55 168.3,124.34 ; J1F1.273 168.64,122.43 168.21,123.77 168.21,124.25 168.3,124.34 ; v3(202.89,171.58) 202.73,171.58 202.45,171.29 201.3,171.29 201.01,171 197.78,171 173.67,146.89 171.92,143.78 171.92,138.19 171.76,138.04 171.42,138.04 171.28,138.17 171.28,140.85 171.16,140.98 170.76,140.98 170.65,140.87 170.65,133.87 169.26,132.47 169.11,132.47 168.93,132.3 168.6,132.3 168.23,131.92 168.23,131.83 168.23,131.39 168.38,131.24 168.38,130.6 168.66,130.32 168.66,129.69 168.64,129.66 168.64,128.53 168.23,128.12 168.23,127.58 168.44,127.37 168.44,126.74 168.67,126.52 168.67,125.98 168.2,125.51 168.2,124.44 168.3,124.34
M_DATA_A<62>: length 80.9
  TOP w0.165: v3(202.89,173.44) J3D1.AJ1
  LAY2 w0.088: 201.3,173.82 201.69,173.44 v3(202.89,173.44)
  LAY2 w0.089: 163.18,128.22 163.1,128.3 163.1,129.33 163.56,129.79 163.56,130.32 163.28,130.6 163.28,131.24 163.13,131.39 163.13,131.92 163.63,132.42 163.8,132.42 164.48,133.1 164.48,136.44 164.57,136.53 165.02,136.53 165.11,136.44 165.11,134.1 165.2,134.01 165.66,134.01 165.75,134.1 165.75,137.11 166.55,137.91 166.55,140.37 170.94,148.16 196.61,173.82 201.3,173.82 ; 163.18,128.22 163.13,128.17 163.13,127.71 163.75,125.95 J1F1.135 ; 163.18,128.22 163.63,128.67 163.91,128.67 163.99,128.76 163.99,128.87 163.91,128.95 163.7,128.95 163.62,129.04 163.62,129.18 163.7,129.27 163.85,129.27 163.98,129.4 163.98,131.06 J1E5.135
M_DATA_A<63>: length 86.4
  TOP w0.165: v3(203.95,173.86) J3D1.AH2
  LAY2 w0.088: v3(203.95,173.86) 201.86,173.86
  LAY2 w0.089: J1E5.280 162.92,125.67 163.11,125.48 163.11,123.41 162.26,122.56 ; 162.26,122.56 162.08,122.56 161.95,122.69 161.95,122.83 162.69,123.57 162.69,124.15 162.52,124.32 162.52,124.66 162.72,124.86 162.72,125.1 162.43,125.39 162.43,125.84 162.28,125.99 162.28,126.52 162.6,126.84 162.6,127.48 162.71,127.59 162.71,128.17 162.59,128.3 162.59,129.48 162.28,129.79 162.28,130.32 162.61,130.66 162.61,131.29 162.71,131.39 162.71,132.07 163.2,132.55 163.2,132.71 163.85,133.36 163.85,134.88 163.76,134.97 163.17,134.97 163.08,135.06 163.08,135.5 163.17,135.6 163.77,135.6 163.85,135.68 163.85,136.7 164.45,137.3 164.45,137.54 164.54,137.63 165.34,137.63 165.62,137.91 165.62,138.2 165.49,138.34 165.13,138.34 165.01,138.46 165.01,138.9 165.14,139.03 165.71,139.03 165.88,139.2 165.88,139.46 165.58,139.76 165.58,139.94 170.43,148.55 196.34,174.46 201.26,174.46 201.86,173.86 ; 162.26,122.56 162.26,122.11 162.9,119.4 J1F1.280
M_DATA_A_CB<0>: length 86.5
  TOP w0.089: J1F1.49 241.97,123.88 241.77,125.94 241.77,126.42 241.35,127.6 241.33,127.67 241.33,128.07 v1(241.55,128.66) 241.55,128.69 241.43,128.96 241.43,129.36 241.78,129.7 241.78,130.43 240.95,131.26 240.95,131.86 241.13,132.04 241.47,132.04 J1E5.49
  TOP w0.165: v3(231.73,170.2) 231.75,170.2 J3D1.AL30
  LAY8 w0.1: 227.88,162.55 227.88,162.83 228.1,163.05 228.1,165.97 227.69,166.38 227.69,166.71 227.93,166.95 228.16,166.95 228.61,167.4 228.61,167.63 228.84,167.87 229.07,167.87 229.45,168.24 229.45,168.68 229.58,168.81 230.13,168.81 230.36,169.03 230.36,169.41 230.69,169.75 231.27,169.75 v3(231.73,170.2)
  LAY8 w0.19: v1(241.55,128.66) 240.84,129.37 240.83,129.37 240.43,129.77 240.43,129.78 240.33,129.88 240.33,130.24 239.4,131.18 239.4,131.94 238.98,132.35 238.96,132.35 238.81,132.5 238.81,134.99 237.99,135.82 237.99,136.23 236.3,137.91 236.3,140.14 236.03,140.41 236.03,140.84 236.3,141.11 236.3,142.24 236.58,142.52 236.58,145.15 236.34,145.39 235.75,145.39 235.56,145.2 235.56,143.29 235.37,143.1 234.76,143.1 234.57,143.28 234.57,147.06 234.26,147.37 233.79,147.37 233.54,147.12 233.54,144.02 233.28,143.76 232.76,143.76 232.48,144.04 232.48,147.72 232.29,147.91 231.71,147.91 231.53,147.74 231.53,145.9 231.34,145.71 230.84,145.71 230.58,145.97 230.58,150.63 230.39,150.82 229.81,150.82 229.62,150.63 229.62,147.7 229.43,147.51 228.86,147.51 228.66,147.71 228.66,155.57 228.43,155.79 228.43,160.66 227.88,161.21 227.88,162.55
M_DATA_A_CB<1>: length 83.6
  TOP w0.089: J1E5.194 241.12,126.78 241,126.9 240.81,126.9 240.48,126.57 240.48,125.97 241.01,125.43 241.01,123.68 240.9,123.57 v1(240.9,123.17) 240.46,122.51 240.46,122 241.1,120.27 241.1,119.71 240.99,119.6 240.99,119.47 241.1,119.37 J1F1.194
  TOP w0.165: v3(231.73,171.08) 232.21,171.57 J3D1.AK30
  LAY8 w0.1: 226.93,162.59 226.93,162.79 227.61,163.47 227.61,165.31 227.4,165.53 227.4,167.37 227.96,167.92 228.22,167.92 228.58,168.28 228.58,168.55 228.83,168.81 229.08,168.81 229.28,169 229.28,169.48 229.52,169.73 230.1,169.73 230.43,170.06 230.43,170.46 230.61,170.64 231.28,170.64 v3(231.73,171.08)
  LAY8 w0.19: v1(240.9,123.17) 240.29,122.54 240.29,121.75 239.39,120.85 239.39,119.67 238.57,118.85 238.57,117.76 238.25,117.43 237.11,117.43 236.83,117.71 236.83,118.86 237.7,119.73 237.7,121 238.49,121.79 238.49,122.59 239.37,123.48 239.37,124.6 240.34,125.57 240.34,126.62 240.96,127.24 240.96,128.14 239.81,129.3 239.16,129.3 238.7,129.75 238.7,130.35 237.74,131.31 237.74,132.02 237.13,132.64 237.13,135.33 233.64,138.81 233.64,141.35 227.75,147.24 227.75,147.27 227.71,147.32 227.71,155.18 227.48,155.4 227.48,160.27 226.93,160.82 226.93,162.59
M_DATA_A_CB<2>: length 81.6
  TOP w0.089: J1F1.56 236,122.84 236.21,123.05 236.21,125.53 236.67,125.99 v1(236.67,126.94) 236.4,127.21 236.4,127.42 236.23,127.59 236.23,128.12 236.23,128.25 236.91,128.93 236.91,130.32 236.77,130.46 236.43,130.46 236.03,130.06 J1E5.56
  TOP w0.165: J3D1.AL32 v3(234.56,170.2)
  LAY8 w0.1: 223.96,167.81 223.96,168.55 224,168.59 224,169.45 224.26,169.72 224.63,169.72 224.95,170.04 224.95,170.37 225.18,170.61 225.48,170.61 225.8,170.93 225.8,171.28 226.69,172.17 226.69,172.27 227.86,173.44 231.41,173.44 231.83,173.02 232.99,173.02 233.64,172.37 233.64,171.12 v3(234.56,170.2)
  LAY8 w0.19: 223.96,167.81 223.96,166.1 223.59,165.73 223.59,162.08 223.75,161.92 223.75,160.76 223.48,160.48 223.07,160.48 222.78,160.19 222.78,159.73 223.4,159.11 223.4,157.69 223.59,157.5 223.94,157.5 224.13,157.31 224.13,156.76 223.92,156.55 223.38,156.55 222.97,156.14 222.97,148.03 223.1,147.9 223.1,147.39 222.78,147.07 222.78,146.32 223.24,145.86 223.55,145.86 223.88,145.53 223.88,144.62 223.69,144.43 222.99,144.43 222.8,144.24 222.8,143.46 223.02,143.24 223.69,143.24 223.88,143.05 223.88,142.52 223.69,142.33 223.19,142.33 223,142.14 223,141.53 223.17,141.36 223.77,141.36 223.88,141.25 223.88,140.84 223.68,140.64 223.68,140.37 224.25,139.8 224.52,139.8 224.72,140 224.99,140 232.67,132.31 232.67,131.28 233.43,130.53 233.43,129.25 234.3,128.38 234.3,127.49 234.75,127.05 235.56,127.05 235.84,127.33 236.27,127.33 v1(236.67,126.94)
M_DATA_A_CB<3>: length 81.4
  TOP w0.089: J1E5.201 235.43,128.24 235.56,128.38 235.74,128.38 235.82,128.3 235.82,127.57 235.18,126.94 235.18,125.02 v1(235.52,124.69) 235.53,124.69 235.81,124.4 235.81,123.6 235.15,122.94 J1F1.201
  TOP w0.165: J3D1.AJ32 v3(234.56,172.03)
  LAY8 w0.1: 221.26,167.79 221.26,168.63 221.52,168.89 221.63,168.89 221.63,168.89 221.86,168.89 222.1,169.12 222.1,169.35 222.55,169.8 222.78,169.8 223.01,170.04 223.01,170.27 223.36,170.61 223.65,170.61 224.01,170.97 224.01,171.3 224.26,171.55 224.57,171.55 224.92,171.89 224.92,172.23 227.26,174.57 232.85,174.57 233.14,174.29 233.17,174.29 233.18,174.28 233.74,174.28 234.9,173.11 234.9,172.37 v3(234.56,172.03)
  LAY8 w0.19: 221.26,167.79 221.26,165.15 220.93,164.83 220.93,161.6 220.74,161.41 220.74,140.29 229.22,131.81 229.22,131.26 230.1,130.38 230.1,129.8 230.97,128.01 230.97,127.49 231.77,126.41 231.77,125.06 232.35,124.48 232.76,124.48 232.96,124.69 v1(235.52,124.69)
M_DATA_A_CB<4>: length 83.6
  TOP w0.089: J1F1.47 243.67,123.88 243.47,125.81 243.47,126.38 243.03,127.72 243.03,128.07 v1(243.25,128.65) 243.25,128.69 243.13,128.98 243.13,129.36 243.48,129.7 243.48,130.43 242.65,131.26 242.65,131.86 242.83,132.04 243.17,132.04 J1E5.47
  TOP w0.165: J3D1.AM31 v3(232.6,169.29)
  LAY8 w0.1: 229.61,163.08 229.61,163.36 229.46,163.51 229.46,166.66 229.86,167.06 230.09,167.06 230.33,167.29 230.33,167.52 230.78,167.97 231.01,167.97 231.24,168.21 231.24,168.44 231.59,168.78 232.09,168.78 v3(232.6,169.29)
  LAY8 w0.19: 229.61,163.08 229.61,162.17 230.33,161.45 230.33,158.12 230.76,157.69 231.28,157.69 231.54,157.43 231.54,155.59 235.84,151.28 235.84,151.07 236.09,150.83 236.29,150.83 237.52,149.6 237.52,149.33 237.11,148.93 236.85,148.93 231.2,154.57 230.81,154.57 230.56,154.32 230.56,153.86 235.98,148.44 235.99,148.44 237.02,147.4 239.25,147.4 239.6,147.06 239.6,143.57 239.79,143.38 240.41,143.38 240.59,143.19 240.59,142.48 240.41,142.29 239.12,142.29 238.92,142.09 238.92,141.38 239.12,141.18 240.41,141.18 240.59,140.99 240.59,140.42 240.38,140.2 239.61,140.2 239.42,140.01 239.42,139.52 239.61,139.33 240.45,139.33 240.59,139.19 240.59,136 241.52,135.07 241.52,134.04 243.07,132.49 243.07,132.02 242.87,131.81 242.87,131.28 243.61,130.54 243.61,129.01 v1(243.25,128.65)
M_DATA_A_CB<5>: length 87.1
  TOP w0.089: J1F1.192 242.57,120.32 242.16,122.18 242.16,122.51 v1(242.7,123.25) 242.82,123.37 242.83,123.37 242.83,125.31 242.18,125.96 242.18,126.57 242.5,126.9 242.7,126.9 242.82,126.78 J1E5.192
  TOP w0.165: v3(231.73,169.29) 232.18,169.75 J3D1.AM30
  LAY8 w0.1: v3(231.73,169.29) 231.51,169.29 231,168.78 230.67,168.78 230.43,168.54 230.43,168.31 229.99,167.87 229.76,167.87 229.52,167.63 229.52,167.4 229.18,167.06 228.95,167.06 228.61,166.71 228.61,163.51 228.84,163.28 228.84,162.59
  LAY8 w0.19: 228.84,162.59 228.84,161.6 229.38,161.05 229.38,156.86 229.61,156.63 229.61,153.65 229.61,153.47 237.97,145.11 237.97,138.19 239.16,137.01 239.16,136.07 240.17,135.05 240.17,132.93 241.18,131.92 241.18,131.22 242,130.41 242,129.71 242.74,128.97 242.74,127.47 243.57,126.64 243.57,125.42 244.49,124.5 244.49,123.62 243.66,122.79 243.66,121.61 242.81,120.76 242.81,119.74 243.55,119 243.55,114.73 243.18,114.36 241.6,114.36 241.41,114.55 241.41,115.63 241.98,116.2 241.98,118.76 241.11,119.63 241.11,120.72 242.01,121.61 242.01,122.66 242.6,123.25 v1(242.7,123.25)
M_DATA_A_CB<6>: length 81.2
  TOP w0.089: J1F1.54 237.7,122.86 237.91,123.07 237.91,124.15 238.37,124.61 v1(238.37,126.94) 238.11,127.19 238.11,127.41 237.93,127.59 237.93,128.28 238.61,128.96 238.61,130.32 238.47,130.46 238.13,130.46 237.73,130.06 J1E5.54
  TOP w0.165: J3D1.AM32 v3(233.58,169.29)
  LAY8 w0.1: 225.47,167.8 225.86,168.19 225.86,169.54 226.04,169.72 226.47,169.72 226.71,169.97 226.71,170.45 226.91,170.65 227.39,170.65 227.65,170.91 227.65,172.18 227.65,172.19 227.65,172.2 227.89,172.44 227.9,172.44 227.99,172.53 232.74,172.53 233.16,172.12 233.16,169.72 v3(233.58,169.29)
  LAY8 w0.19: v1(238.37,126.94) 237.56,127.74 237.56,128.14 237.16,128.55 235.93,128.55 235.17,129.31 235.17,130.43 234.32,131.28 234.32,131.95 233.93,132.34 233.93,132.97 224.82,142.07 224.82,146.54 224.22,147.14 224.22,149.47 224.41,149.66 225.18,149.66 225.49,149.97 225.49,150.47 225.3,150.66 224.38,150.66 224.19,150.85 224.19,151.42 224.38,151.61 225.3,151.61 225.49,151.8 225.49,152.37 225.3,152.56 224.33,152.56 224.14,152.75 224.14,153.32 224.33,153.51 225.33,153.51 225.49,153.67 225.49,154.26 225.3,154.46 224.33,154.46 224.14,154.65 224.14,155.22 224.33,155.41 225.08,155.41 225.27,155.6 225.27,157.72 225.04,157.96 224.9,157.96 224.71,158.15 224.71,158.44 224.9,158.63 225.06,158.63 225.27,158.84 225.27,159.35 224.71,159.9 224.71,164.81 225.47,165.57 225.47,167.8
M_DATA_A_CB<7>: length 83.4
  TOP w0.089: J1E5.199 237.03,128.32 237.11,128.4 237.25,128.4 237.52,128.13 237.52,127.59 237.39,127.46 237.39,126.83 237.08,126.52 237.08,125.99 237.44,125.63 237.44,125.4 237.23,125.19 v1(237.23,124.69) 237.52,124.4 237.52,123.61 236.85,122.95 J1F1.199
  TOP w0.165: J3D1.AK32 v3(234.56,171.12)
  LAY8 w0.1: 222.21,167.73 222.21,168.2 222.2,168.21 222.2,168.54 222.44,168.78 222.86,168.78 223.12,169.04 223.12,169.46 223.46,169.8 223.69,169.8 224.03,170.14 224.03,170.37 224.35,170.69 224.62,170.69 224.87,170.94 224.87,171.24 225.17,171.55 225.34,171.55 225.8,172.01 225.8,172.23 227.52,173.95 232.54,173.95 232.84,173.65 233.17,173.65 234.14,172.69 234.14,171.54 v3(234.56,171.12)
  LAY8 w0.19: v1(237.23,124.69) 236.95,124.69 236.07,125.57 235.73,125.57 235.47,125.83 234.87,125.83 234.61,125.57 234.03,125.57 233.43,126.16 233.43,126.68 232.55,127.57 232.55,128.51 231.75,129.31 231.75,130.47 230.84,131.38 230.84,131.99 229.93,132.9 229.93,133.11 229.66,133.39 229.18,133.39 228.77,133.79 228.77,134.06 229.04,134.33 229.04,134.6 228.64,135 228.37,135 228.1,134.73 227.83,134.73 227.43,135.13 227.43,135.4 227.7,135.67 227.7,135.94 227.3,136.34 227.03,136.34 226.67,135.98 226.4,135.98 226,136.39 226,136.65 226.32,136.98 226.32,137.31 225.96,137.67 225.69,137.67 225.45,137.43 225.27,137.43 221.83,140.88 221.83,160.58 222.13,160.89 222.13,164.68 222.13,164.68 222.13,167.66 222.21,167.73
M_DATA_B<0>: length 109.2
  TOP w0.088: J1F3.5 279.35,107.58 279.27,107.66 279.27,107.86 279.38,107.96 279.38,108.15 279.29,108.25 279.29,108.42 279.41,108.54 279.41,108.77 279.25,108.92 v1(278.82,108.92) 278.54,109.21 278.54,110.03 279.37,110.86 J1F2.5
  TOP w0.165: v3(238.15,176.69) J3D1.AD36
  LAY9 w0.088: 243.87,177.33 242.25,177.33 242.12,177.46 241.43,177.46 241.06,177.83 240.73,177.83 240.63,177.72 240.25,177.72 240.15,177.83 239.82,177.83 239.46,177.47 238.8,177.47 238.15,176.82 v3(238.15,176.69)
  LAY9 w0.089: 243.87,177.33 244.28,176.92 249.56,176.92 259.38,167.1 259.38,162.47 274.48,147.37 274.48,133.3 274.59,133.19 275.02,133.19 275.11,133.28 275.11,134.48 275.2,134.57 275.66,134.57 275.74,134.48 275.74,132.34 275.33,131.92 275.33,131.39 276.18,130.54 276.18,129.79 277.03,128.94 277.03,127.37 276.18,126.52 276.18,125.99 277.01,125.16 277.01,123.4 276.16,122.55 276.16,122.02 276.98,121.2 276.98,121.18 277.01,121.15 277.01,119.6 276.16,118.75 276.16,118.09 276.27,117.99 276.27,115.39 277.4,114.26 277.4,114.1 277.03,113.73 277.03,113.19 277.88,112.34 277.88,111.59 278.73,110.74 278.73,109.02 v1(278.82,108.92)
M_DATA_B<1>: length 110.3
  TOP w0.088: J1F3.150 278.3,100.97 277.85,102.76 277.85,103.23 v1(278.4,103.93) 278.4,104.71 278.49,104.8 278.61,104.8 278.7,104.89 278.7,105.02 278.63,105.1 278.35,105.1 278.27,105.17 278.27,105.3 278.36,105.39 278.58,105.39 278.67,105.48 278.67,105.64 278.52,105.78 J1F2.150
  TOP w0.165: v3(238.15,175.74) J3D1.AE36
  LAY9 w0.088: 243.63,176.63 241.45,176.63 241.06,177.02 240.73,177.02 240.65,176.94 240.23,176.94 240.15,177.02 239.82,177.02 239.74,176.94 239.35,176.94 239.23,177.05 238.9,177.05 238.63,176.78 238.63,176.52 238.15,176.04 v3(238.15,175.74)
  LAY9 w0.089: v1(278.4,103.93) 278.4,103.93 278.4,105.3 278.31,105.38 278.09,105.38 278,105.47 278,105.71 278.09,105.8 278.31,105.8 278.4,105.89 278.4,107.15 277.83,107.72 277.83,108.92 278.31,109.39 278.31,109.93 277.46,110.77 277.46,112.16 276.61,113.01 276.61,113.73 276.61,113.73 276.61,113.77 275.61,114.77 275.61,118.02 275.75,118.16 275.75,118.97 276.59,119.82 276.59,120.28 275.75,121.74 275.75,122.77 276.59,123.62 276.59,124.12 275.76,125.88 275.76,126.74 276.61,127.59 276.61,128.09 275.77,129.58 275.76,129.59 275.76,130.32 274.91,131.17 274.91,131.92 273.84,132.99 273.84,147.11 258.75,162.2 258.75,166.84 249.33,176.25 244,176.25 243.63,176.63
M_DATA_B<2>: length 110.9
  TOP w0.088: J1F2.12 273.2,109.41 272.78,108.32 272.78,107.8 v1(273.33,107.13) 273.23,106.79 273.23,106.12 273.39,105.96 273.39,105.82 273.3,105.73 273,105.73 272.91,105.64 272.91,105.47 273,105.38 273.16,105.38 273.25,105.29 273.25,105.16 273.19,105.1 273.19,104.27 273.03,104.1 273.03,103.92 J1F3.12
  TOP w0.165: v3(238.15,173.86) J3D1.AG36
  LAY9 w0.088: 243.7,173.32 242.61,173.32 242.12,173.8 241.79,173.8 241.73,173.74 241.54,173.74 241.08,174.2 240.68,174.2 240.52,174.04 240.31,174.04 240.15,174.2 239.82,174.2 239.66,174.04 239.39,174.04 239.23,174.2 238.9,174.2 238.56,173.86 v3(238.15,173.86)
  LAY9 w0.089: v1(273.33,107.13) 272.78,107.68 272.78,108.33 273.63,109.18 273.63,110.74 272.78,111.59 272.78,112.34 271.93,113.19 271.93,114.17 271.48,114.62 271.48,117.8 271.06,118.22 271.06,118.75 271.91,119.6 271.91,121.17 271.06,122.02 271.06,122.55 271.91,123.4 271.91,125.16 271.08,125.99 271.08,126.52 271.93,127.37 271.93,128.94 271.08,129.79 271.08,130.54 270.23,131.39 270.23,131.92 270.32,132.02 270.32,133.17 269.31,134.18 269.31,142.16 269.4,142.25 269.85,142.25 269.94,142.16 269.94,139.92 270.05,139.81 270.49,139.81 270.57,139.9 270.57,146.39 255.93,161.04 255.93,165.68 248.29,173.32 248.1,173.32 248.01,173.23 248.01,172.67 247.92,172.58 247.47,172.58 247.38,172.67 247.38,173.23 247.29,173.32 246.83,173.32 246.75,173.23 246.75,172.67 246.66,172.58 246.2,172.58 246.11,172.67 246.11,173.23 246.02,173.32 245.6,173.32 245.6,173.31 245.5,173.21 245.5,172.9 245.41,172.81 245.16,172.81 245.04,172.94 245.04,173.21 244.93,173.32 243.7,173.32
M_DATA_B<3>: length 113
  TOP w0.088: J1F3.157 272.34,103.22 271.91,104.3 271.91,104.83 v1(272.46,105.5) 272.36,105.84 272.36,106.58 272.17,106.78 272.17,106.91 272.26,106.99 272.59,106.99 272.67,107.08 272.67,107.24 272.59,107.33 272.45,107.33 272.36,107.42 272.36,108.33 272.19,108.5 272.19,108.77 J1F2.157
  TOP w0.165: v3(237.24,173.86) J3D1.AG35
  LAY9 w0.088: v3(237.24,173.86) 237.7,173.4 241.28,173.4 241.76,172.93 242.13,172.93 242.38,172.68 244.33,172.68
  LAY9 w0.089: 244.33,172.68 245.07,171.94 248.77,171.94 248.86,171.85 248.86,171.4 248.77,171.31 246.21,171.31 246.11,171.21 246.11,170.76 246.2,170.68 250.04,170.68 255.29,165.42 255.29,160.78 268.6,147.47 268.6,144.48 268.7,144.38 269.14,144.38 269.23,144.48 269.23,146.15 269.34,146.26 269.78,146.26 269.87,146.17 269.87,143.81 268.6,142.54 268.6,133.99 269.59,133 269.59,132.14 269.81,131.92 269.81,131.52 269.81,131.52 269.81,131.17 270.66,130.32 270.66,129.59 270.67,129.58 271.51,128.09 271.51,127.59 270.66,126.74 270.66,125.88 271.49,124.12 271.49,123.62 270.65,122.77 270.65,121.74 271.49,120.28 271.49,119.82 270.65,118.97 270.65,117.31 270.78,117.17 270.78,114.46 271.51,113.73 271.51,112.97 272.36,112.13 272.36,110.78 273.21,109.93 273.21,109.39 272.36,108.54 272.36,106 272.46,105.89 v1(272.46,105.5)
M_DATA_B<4>: length 112.7
  TOP w0.088: J1F3.3 281.05,107.58 280.97,107.66 280.97,107.86 281.08,107.96 281.08,108.15 280.99,108.25 280.99,108.42 281.11,108.54 281.11,108.77 280.95,108.92 v1(280.52,108.92) 280.12,109.33 280.12,109.92 281.07,110.86 J1F2.3
  TOP w0.165: v3(236.33,176.66) J3D1.AD34
  LAY9 w0.088: v3(236.33,176.66) 236.35,176.66 236.78,177.09
  LAY9 w0.089: 236.78,177.09 236.78,178.67 236.98,178.87 244.4,178.87 245.07,178.19 250.09,178.19 260.69,167.59 260.69,162.96 275.74,147.9 275.74,136.96 275.87,136.84 276.29,136.84 276.38,136.93 276.38,137.64 276.47,137.73 276.92,137.73 277.01,137.64 277.01,135.55 277.28,135.27 277.28,132.95 278.31,131.92 278.31,130.76 277.88,130.32 277.88,129.79 279.01,128.66 279.01,128.41 278.73,128.12 278.73,127.59 279.23,127.09 279.23,124.67 278.71,124.15 278.71,123.62 279.23,123.1 279.23,120.88 278.73,120.38 278.73,120.37 278.71,120.35 278.71,119.47 279.29,118.88 279.29,117.91 279.08,117.7 279.08,114.08 278.73,113.73 278.73,113.19 279.58,112.34 279.58,111.59 280.43,110.74 280.43,109.39 280.52,109.3 v1(280.52,108.92)
