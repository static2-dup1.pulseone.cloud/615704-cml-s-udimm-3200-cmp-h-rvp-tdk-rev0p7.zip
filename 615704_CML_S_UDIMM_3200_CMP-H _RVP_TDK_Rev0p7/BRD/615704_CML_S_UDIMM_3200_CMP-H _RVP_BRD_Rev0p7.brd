# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MRESET_TR_AIC: length 95.5
  LAY6 w0.125: v1(111.88,104.65) 111.88,104.62 112.39,104.11 112.39,101.14 114.42,99.11 114.42,88.21 119.79,82.84 119.79,79.5 122.04,77.25 122.04,72.39 119.25,69.59 119.25,60.96 121.92,58.29 122.93,58.29 124.12,57.1 124.12,38.78 119.5,34.16 119.5,31.65 J6J1.6
  BOTTOM w0.1: v1(111.88,104.65) 111.37,105.15 111.37,110.08 109.98,111.47 109.25,111.47 108.55,112.17 108.55,112.74 R6T9.1 R6T7.1
MSCLK: length 6.5
  TOP w0.1: U7H4.9 73.52,31.11 72.64,30.22 R7J5.2 72.93,29.56 72.93,28.26 72.48,27.81 R7J9.1
MSCLK_FB: length 23.7
  TOP w0.1: v1(76.58,28.19) 75.69,29.08 74.54,29.08 74.16,28.7 74.16,27.68 CRP7J1.6 73.78,27.56 73.78,29.21 74.04,29.46 C7J2.1 73.53,29.59 73.4,29.46 73.4,28.07 R7J9.2
  LAY6 w0.125: J7J6.11 80.53,25.25 77.59,28.19 v1(76.58,28.19)
MSDATA: length 6
  TOP w0.1: R7J8.1 70.38,28.42 70.38,30 70.61,30.22 R7J4.2 70.99,30.82 71.57,31.41 U7H4.6
MSDATA_FB: length 23
  TOP w0.1: R7J8.2 C7J6.1 71.62,25.53 72.73,26.64 75.65,26.64 75.81,26.79 CRP7J1.4 v1(76.58,27.43)
  LAY6 w0.125: v1(76.58,27.43) 76.58,24.13 77.59,23.11 78.03,23.11 79.53,21.61 79.53,18.03 78.42,16.92 J7J6.7
Net_252:
  vias: v1(164.94,193.22)
NET_CLR_CMOS_JUMPER: length 2.6
  TOP w0.1: J8J9.3 44.19,14.6 R8J22.1
NET_CLR_RTC_JUMPER: length 4.5
  TOP w0.1: J9E6.3 12.19,140.97 14.35,143.13 R9E27.1
NMI_GATE_SLG_INPUT: length 1.9
  TOP w0.1: R8F17.2 25.91,119.37 EU8F1.2
NPN_EC_AMP_PD_BASE: length 1.4
  TOP w0.1: R8B2.2 33.78,259.46 Q8B2.1
NPN_RESETO_BASE: length 1.7
  TOP w0.1: R8B1.2 29.97,258.82 Q8B1.1
OE_N: length 4.5
  TOP w0.1: EU8G3.9 36.96,72.02 37.46,72.52 37.46,74.29 37.21,74.55 R8G60.2
PA_HPD_SCL: length 9.6
  TOP w0.089: 160.83,265.47 161.54,265.47 U5A2.T2
  TOP w0.1: 160.83,265.47 160.73,265.47 160.6,265.61 160.14,265.61 160.06,265.69 159.39,265.69 159.13,265.43 159.13,265.3 R5A41.1 158.87,265.3 158.72,265.45 157.6,265.45 157.48,265.58 156.87,265.58 156.79,265.5 154.48,265.5 153.79,266.19 R5A39.2
PA_USB2_MXCTL: length 6.1
  TOP w0.089: U5A2.R2 161.54,265.93 161.03,265.93 160.83,266.13 159.61,266.13 159.34,266.39
  TOP w0.1: 159.34,266.39 157.6,266.39 157.42,266.57 156.99,266.57 156.36,265.94 R5A34.1
PA_USB2_RBIAS: length 1.1
  TOP w0.1: U5A2.H19 169.64,269.03 v2(169.94,269.33)
  BOTTOM w0.1: R5L5.1 169.98,269.37 v2(169.94,269.33)
PB_HPD_SDA: length 7.3
  TOP w0.1: v2(159.63,265.3) 159.69,265.24 U5A2.T1
  BOTTOM w0.1: v2(159.63,265.3) 159,265.94 R5L9.1 158.36,265.43 157.6,265.43 157.45,265.58 156.87,265.58 156.76,265.48 156.76,265.2 156.61,265.05 155.54,265.05 155.44,265.15 R5L12.2
PB_USB2_MXCTL: length 2.5
  TOP w0.089: R5A35.1 160.67,265.94 160.9,265.7 U5A2.R1
PB_USB2_RBIAS: length 1.6
  TOP w0.1: v2(169.94,270.03) 169.94,270 U5A2.F19
  BOTTOM w0.089: 170.17,270.26 v2(169.94,270.03)
  BOTTOM w0.1: 170.17,270.26 170.55,270.64 170.55,270.89 R5L3.1
PCA9555_RST_N: length 3.8
  TOP w0.1: R8E36.2 28.32,147.19 26.92,148.59 U8E3.1
PCH_2_CPU_TRIGGER: length 227.3
  TOP w0.089: 213.86,203.2 213.86,199.64 214.12,199.39 214.12,196.47 213.99,196.34 213.99,195.79 213.55,195.35 J3D1.E12
  TOP w0.1: 213.86,203.2 213.86,203.81 207.77,209.91 194.87,209.91 193.38,211.39 182.81,211.39 178.77,215.44 176.53,215.44 176.08,215 174.47,215 173.57,215.9 173.57,225.68 172.58,226.67 172.58,229.55 171.66,230.47 170.84,230.47 170.3,231.01 v1(170.3,231.65) ; v1(134.62,215.77) 129.92,215.77 128.3,214.16 126.82,214.16 125.58,215.39 124.2,215.39 123.92,215.11 122.17,215.11 121.8,214.74 118.32,214.74 117.81,214.23 101.65,214.23 94.38,206.95 94.38,192.48 93.71,191.81 93.71,187.08 94.26,186.54 94.26,186.01 90.83,182.59 90.83,176.61 97.53,169.91 R7D47.1
  BOTTOM w0.1: v1(170.3,231.65) 169.17,232.78 169.17,233.63 166.56,236.24 164.95,236.24 164.41,236.78 162.29,236.78 162.17,236.89 160.05,236.89 160.04,236.88 158.14,236.88 156.1,238.91 156.1,239.69 155.51,240.28 154.65,240.28 152.86,242.07 147.25,242.07 146.9,242.42 145.24,242.42 144.23,243.44 140.76,243.44 139.74,242.42 138.59,242.42 136.52,240.35 136.52,235.46 135.05,233.98 135.05,216.2 v1(134.62,215.77)
PCH_2_CPU_TRIGGER_R: length 10.5
  TOP w0.089: U6E1.AK3 99.76,157.52 99.68,157.6 99.68,157.95 99.77,158.04 99.77,159.89 99.76,159.91 99.68,160 99.68,161.75 99.68,162.46 98.44,163.69 98.44,164.34
  TOP w0.1: R7D47.2 97.53,165.61 98.44,164.69 98.44,164.34
PCH_CODEC_PWR_EN: length 208.3
  TOP w0.089: U6E1.AE48 102.11,135.47 102.15,135.43 102.15,131.61 101.22,130.68 101.22,130.3
  TOP w0.1: v1(101.6,123.11) 101.6,126.36 101.22,126.73 101.22,130.3 ; R6A20.1 v1(101.98,281.18) R6A25.1
  LAY5 w0.125: v1(101.6,123.11) 105.86,127.38 111.25,127.38 113.79,129.92 113.79,130.94 114.17,131.32 115.29,131.32 116.07,132.1 116.07,137.25 114.42,138.9 114.42,156.23 115.31,157.12 115.31,160.12 114.55,160.88 114.55,164.34 114.29,164.59 114.29,166.14 115.06,166.9 115.06,171.7 116.34,172.98 116.34,177.04 117.03,177.74 117.03,183.12 115.56,184.59 115.56,187.34 v1(116.58,188.36)
  LAY6 w0.125: v1(116.58,188.36) 116.26,188.36 115.69,188.94 115.69,189.51 114.57,190.63 111.99,190.63 104.86,197.77 104.08,197.77 99.12,202.73 99.12,215.21 100.07,216.15 100.07,216.81 99.12,217.76 99.12,223.03 100.34,224.25 100.34,227.63 98.17,229.81 98.17,233.3 97.86,233.6 97.86,237.58 105.53,245.25 105.53,246.87 107.19,248.52 107.19,257.68 105.15,259.71 105.15,264.92 104.19,265.88 101.84,265.88 101.09,265.12 v1(101.09,265.05)
  BOTTOM w0.1: v1(101.09,265.05) 101.09,265.1 100.58,265.61 100.58,266.34 100.23,266.7 100.23,276.38 101.98,278.13 v1(101.98,281.18)
PCH_CONFIG_JUMPER: length 159.5
  TOP w0.1: J8J3.1 35.94,31.49 R8H76.1
  LAY5 w0.125: J8J3.1 36.83,31.11 38.35,29.59 45.33,29.59 47.12,27.81 50.97,27.81 52.61,29.45 61.81,29.45 63.85,31.49 65.76,31.49 66.27,32.01 74.7,32.01 78.89,27.81 85.59,27.81 88.13,25.27 88.9,25.27 v1(89.4,25.78)
  LAY6 w0.125: v1(91.33,102.49) 91.16,102.31 91.16,93.93 91.85,93.24 91.85,88.77 91.18,88.11 91.18,80.47 92.65,79 92.65,74.87 91.88,74.1 91.88,68.26 92.45,67.69 92.45,56.64 92.94,56.15 92.94,46.16 94.43,44.67 94.43,40 92.2,37.77 92.2,27.81 90.8,26.41 89.91,26.41 89.4,25.91 v1(89.4,25.78)
  BOTTOM w0.1: v1(91.33,102.49) 90.83,103 90.83,103.66 90.87,103.71 90.87,106.19 90.37,106.7 90.37,110.12 91.78,111.53 91.78,115.28 92.2,115.7 R7T16.1
PCH_CPU_BCLK_DN: length 39.8
  TOP w0.089: U6E1.C8 113.09,155.18 113.33,155.42 114.62,155.42 114.84,155.64
  TOP w0.1: R5E25.1 140.4,150.69 139.78,150.69 135.36,155.11 133.84,155.11 125.68,163.27 122.94,163.27 121.92,164.29 119.23,164.29 116.63,161.69 116.63,157.43 114.84,155.64
PCH_CPU_BCLK_DP: length 39.8
  TOP w0.089: U6E1.B8 113.54,155.23 114.7,155.23 114.91,155.45 114.93,155.45
  TOP w0.1: 114.93,155.45 116.83,157.35 116.83,161.61 119.31,164.09 121.83,164.09 122.85,163.07 125.6,163.07 133.75,154.91 135.28,154.91 139.7,150.49 140.68,150.49 140.81,150.36 140.81,149.96 R5E29.1
PCH_CPU_BCLK_R_DN: length 98.4
  TOP w0.1: v1(145.66,152.38) 145.37,152.08 145.12,152.08 144.55,151.51 144.55,150.9 144.19,150.54 142.06,150.54 R5E25.2 ; v1(203.95,184.83) J3D1.T1
  BOTTOM w0.089: v1(203.95,184.83) 203.61,185.17 203.61,185.17 203.33,185.45 202.58,185.45 201.92,184.79 201.64,184.79 201.63,184.8 201.62,184.8
  BOTTOM w0.1: 201.62,184.8 191.14,184.8 189.34,186.6 184.92,186.6 183.15,184.83 181.46,184.83 180.29,186 176.74,186 173.94,188.79 173.18,188.79 172.59,189.38 172.59,190.24 171.44,191.39 169.84,191.39 168.71,190.25 168.71,189.18 164.77,185.25 164.77,182.3 162.81,180.34 162.15,180.34 161.96,180.16 160.44,180.16 157.28,176.99 157.28,173.18 156.13,172.04 156.13,168.99 155.11,167.97 154.4,167.97 153.25,166.82 152.31,166.82 149.62,164.13 149.09,164.13 148.08,163.12 148.08,161.14 145.34,158.4 145.34,154.32 146.4,153.26 146.4,152.48 146.07,152.14 145.87,152.14 145.66,152.35 v1(145.66,152.38)
PCH_CPU_BCLK_R_DP: length 98.4
  TOP w0.1: J3D1.U1 v1(203.04,184.83) ; R5E29.2 142.08,150.34 144.27,150.34 144.75,150.82 144.75,151.43 145.2,151.88 145.37,151.88 v1(145.66,151.59)
  BOTTOM w0.089: v1(203.04,184.83) 203.4,184.83 203.48,184.92 203.48,185.04 203.26,185.26 202.66,185.26 201.99,184.6 201.59,184.6
  BOTTOM w0.1: v1(145.66,151.59) 146.02,151.94 146.15,151.94 146.6,152.4 146.6,153.34 145.54,154.41 145.54,158.32 148.28,161.06 148.28,163.03 149.17,163.93 149.7,163.93 152.4,166.62 153.34,166.62 154.48,167.77 155.19,167.77 156.33,168.91 156.33,171.96 157.48,173.1 157.48,176.91 160.52,179.96 162.05,179.96 162.23,180.14 162.89,180.14 164.97,182.21 164.97,185.16 168.91,189.1 168.91,190.17 169.92,191.19 171.36,191.19 172.39,190.16 172.39,189.3 173.1,188.59 173.86,188.59 176.65,185.8 180.21,185.8 181.38,184.63 183.23,184.63 185,186.4 189.26,186.4 191.06,184.6 201.59,184.6
PCH_CPU_NSSC_CLK_DN: length 39.9
  TOP w0.089: 114.47,156 114.28,155.81 113.03,155.81 U6E1.C6
  TOP w0.1: 114.47,156 115.92,157.46 115.92,161.95 118.94,164.97 122.3,164.97 123.19,164.08 125.88,164.08 134.18,155.79 135.7,155.79 138.73,152.75 140.63,152.75 140.79,152.91 140.79,153.34 R5E15.1
PCH_CPU_NSSC_CLK_DP: length 39.9
  TOP w0.089: U6E1.D7 112.63,155.49 113.12,155.49 113.25,155.62 114.35,155.62 114.54,155.81 114.55,155.81 114.59,155.85 114.6,155.85 114.61,155.86
  TOP w0.1: 114.61,155.86 116.12,157.38 116.12,161.86 119.02,164.77 122.22,164.77 123.1,163.88 125.8,163.88 134.09,155.59 135.61,155.59 138.65,152.55 140.43,152.55 R5E19.1
PCH_CPU_PCIBCLK_DN: length 38.5
  TOP w0.1: U6E1.B6 113.51,156.09 113.78,156.35 114.09,156.35 115.24,157.5 115.24,162.22 118.88,165.86 125.12,165.86 134.52,156.46 135.98,156.46 136.92,155.52 140.41,155.52 R5E5.1
PCH_CPU_PCIBCLK_DP: length 38.5
  TOP w0.1: U6E1.A6 114.01,156.15 114.17,156.15 115.44,157.42 115.44,162.13 118.96,165.66 125.04,165.66 134.43,156.26 135.89,156.26 136.83,155.32 140.63,155.32 140.86,155.1 140.86,154.83 R5E8.1
PCH_CPU_PCIBCLK_R_DN: length 92.4
  TOP w0.1: J3D1.T3 205.33,185.29 v1(205.78,184.85) ; R5E5.2 141.35,155.57 141.35,155.32 141.52,155.14 141.78,155.14 142,155.37 146.18,155.37 146.35,155.19 146.66,155.19 146.76,155.29 v1(146.76,155.56)
  BOTTOM w0.089: v1(205.78,184.85) 205.53,184.6 205.28,184.6 205.16,184.47 204.52,184.47 204.32,184.28 204.08,184.28
  BOTTOM w0.1: v1(146.76,155.56) 147.02,155.29 147.11,155.29 147.21,155.39 147.21,159.31 148.77,160.86 148.77,161.96 150.46,163.65 150.89,163.65 151.29,164.05 151.29,164.63 152.47,165.81 153.2,165.81 154.6,167.2 155.36,167.2 156.84,168.68 156.84,171.58 158.62,173.35 158.62,177.32 160.76,179.46 162.23,179.46 162.42,179.65 163.14,179.65 165.48,181.99 165.48,184.94 168.37,187.83 169.61,187.83 169.92,187.52 171.62,187.52 171.87,187.78 173.91,187.78 176.4,185.29 179.73,185.29 180.87,184.15 183.43,184.15 185.21,185.92 189,185.92 190.81,184.11 199.26,184.11 199.42,184.28 204.08,184.28
PCH_CPU_PCIBCLK_R_DP: length 92.4
  TOP w0.1: v1(146.76,154.73) 146.49,154.99 146.27,154.99 146.1,155.17 142.08,155.17 R5E8.2 ; J3D1.T4 v1(206.69,184.85)
  BOTTOM w0.089: v1(206.69,184.85) 206.26,184.41 205.36,184.41 205.23,184.28 204.6,184.28 204.4,184.09 204.17,184.09 204.16,184.08 204.11,184.08 204.1,184.08 204.08,184.08
  BOTTOM w0.1: 204.08,184.08 199.5,184.08 199.34,183.91 190.73,183.91 188.92,185.72 185.29,185.72 183.52,183.95 180.79,183.95 179.65,185.09 176.32,185.09 173.83,187.58 171.95,187.58 171.7,187.32 169.84,187.32 169.53,187.63 168.45,187.63 165.68,184.86 165.68,181.91 163.22,179.45 162.5,179.45 162.32,179.26 160.84,179.26 158.82,177.24 158.82,173.27 157.04,171.49 157.04,168.6 155.44,167 154.68,167 153.28,165.61 152.55,165.61 151.49,164.55 151.49,163.96 150.98,163.45 150.54,163.45 148.97,161.87 148.97,160.78 147.41,159.22 147.41,155.31 147.2,155.09 147.12,155.09 v1(146.76,154.73)
PCH_DPWROK: length 328.4
  TOP w0.1: v1(63.11,118.87) 63.11,119.12 64,120.01 70.61,120.01 Q7F1.1 71.5,119.63 v1(73.05,119.63) ; R8F16.1 v1(28.42,119.51) 29.33,120.42 29.33,121.03 32.34,124.04 35.25,124.04 43.97,115.31 v1(50.03,115.31) ; v1(48.26,181.1) R8D46.1 R8D42.2 R8D43.2 C8D17.1 49.53,181.61 50.03,181.61 50.35,181.92 50.35,184.69 52.83,187.17 R8D21.1 52.89,188.28 52.89,191.77 51.88,192.78 R8D8.2 ; 16.89,109.85 v1(16.89,111.63)
  LAY5 w0.125: J8J13.25 49.52,6.96 51.02,5.47 64.54,5.47 65.51,6.44 65.51,7.72 67.95,10.16 v1(69.08,10.16)
  LAY6 w0.125: v1(48.26,181.1) 48,180.85 48,179.83 48.68,179.15 48.68,169.24 51.11,166.82 51.11,160.87 50.64,160.4 50.64,159.26 51.31,158.59 51.31,156.07 51.43,155.95 51.43,147.06 53.21,145.28 53.21,128.4 53.59,128.02 53.59,118.87 v1(50.03,115.31) ; v1(73.05,119.63) 73.05,118.01 71.62,116.58 71.62,113.41 72.54,112.49 72.54,105.99 75.47,103.07 75.47,96.22 77.23,94.45 77.23,91.65 77.73,91.15 77.73,89.78 78.11,89.41 78.11,86.87 77.73,86.49 77.73,83.46 78.46,82.73 78.46,80.83 77.64,80.01 77.64,77.1 77.08,76.55 77.08,73.55 77.35,73.28 77.35,67.28 78.35,66.28 78.35,60.33 77.2,59.17 77.2,55.64 78.35,54.48 78.35,51.32 76.7,49.67 76.7,48.64 75.74,47.68 75.74,42.35 70.75,37.36 70.75,30.08 70.32,29.66 70.32,28.07 69.72,27.46 69.72,19.18 67.94,17.4 67.94,11.3 v1(69.08,10.16)
  BOTTOM w0.1: v1(50.03,115.31) 50.05,115.3 55.3,115.3 58.87,118.87 v1(63.11,118.87) ; v1(28.42,119.51) 28.29,119.63 19.55,119.63 18.44,118.52 18.44,113.19 v1(16.89,111.63) ; v1(73.05,119.63) 73.05,119.97 73.83,120.74 76.11,120.74 82.71,127.34 82.71,130.07 84.31,131.67 84.31,132.49 85.47,133.65 TP7R1.1 86.36,134.75 R7R58.1
PCH_DPWROK_SLG_IN: length 1.7
  TOP w0.1: EU8F1.3 26.08,119.87 26.45,119.51 R8F16.2
PCH_HOT_N: length 301.1
  TOP w0.1: v1(24.02,92.05) U8F6.77 24.02,90.12 23.24,89.34 23.24,88.11 C9G3.1 23.24,88.01 23.57,87.68 23.57,85.7 R9G20.2 ; R7E46.1 67.69,136.65 v1(64.26,133.22) ; R5J8.2 140.08,7.75 v1(139.95,7.62)
  LAY3 w0.1: v1(73.91,36.83) 75.03,37.94 80.72,37.94 81.49,38.72 88.3,38.72 89.25,39.67 89.74,39.67 90.06,39.34 102.74,39.34 103.81,38.27 107.61,38.27 108.2,38.86 108.77,38.86 109.98,37.65 120.38,37.65 123.44,34.58 146.98,34.58 153.6,27.96 153.6,22.84 154.48,21.96 154.48,19.29 153.6,18.41 153.6,9.12 152.2,7.72 141.32,7.72 140.97,7.36 140.2,7.36 v1(139.95,7.62)
  LAY5 w0.125: v1(24.38,130.05) 23.49,129.16 23.49,118.97 24.38,118.09 24.38,114.16 24.06,113.84 24.06,108.87 23.76,108.57 23.76,98.91 24.51,98.17 24.51,92.54 v1(24.02,92.05)
  LAY8 w0.1: v1(24.02,92.05) 24.02,91.61 28.04,87.59 28.04,84.43 31.88,80.58 34.54,80.58 37.87,77.25 37.87,70.2 38.73,69.34 38.73,67.51 42.7,63.54 46.24,63.54 49.37,60.41 49.37,59.28 54.27,54.39 54.27,53.24 56.18,51.33 56.18,50.45 57.22,49.4 59.3,49.4 61.46,47.24 62.79,47.24 72.06,37.97 72.77,37.97 v1(73.91,36.83)
  BOTTOM w0.1: v1(24.38,130.05) 27.3,130.05 29.84,127.51 36.58,127.51 39.65,124.43 50.03,124.43 52.35,126.74 55.81,126.74 61.12,132.05 62.65,132.05 63.82,133.22 v1(64.26,133.22)
PCH_HOT_R_N: length 27.1
  TOP w0.089: U6E1.BD33 92.68,142.83 92.01,142.83 91.98,142.86 91.67,142.86 91.48,143.05 89.45,143.05 89.36,142.96 85.68,142.96 85,142.28 84.55,142.28 83.19,140.92 82.21,140.92
  TOP w0.1: R7E46.2 69.97,137.67 71.37,137.67 R7E42.2 72.39,137.67 74.16,137.67 74.75,138.25 78.7,138.25 81.36,140.92 82.21,140.92
PCH_INTRUDER_HDR_N: length 164.9
  TOP w0.089: U6E1.BB44 v1(93.94,137.06)
  TOP w0.1: v1(54.48,109.6) 54.48,112.77 50.67,116.58 43.4,116.58 35.02,124.97 29.33,124.97 28.22,126.08 26.06,126.08 25.65,126.49 23.78,126.49 18.84,121.56 11.17,121.56 9.63,120.01 4.69,120.01 4.31,119.63 4.31,112.01 J9F3.1
  LAY5 w0.125: v1(54.48,109.6) 56.89,109.6 57.15,109.35 57.15,105.54 57.78,104.9 61.08,104.9 61.6,104.38 61.6,102 65.65,97.94 65.65,94.23 67.69,92.2 72.28,92.2 72.79,92.71 79.3,92.71 82.4,95.8 82.4,98.71 v1(82.67,98.98)
  BOTTOM w0.1: v1(82.67,98.98) 82.67,99.19 81.66,100.2 81.66,101.6 81.91,101.85 81.91,111.89 80.79,113 80.79,114.96 81.37,115.54 81.37,118.71 81.4,118.74 81.4,124.02 84.13,126.75 84.13,129.47 84.88,130.22 85.92,130.22 87.83,132.13 88.72,132.13 R7R60.2 89.53,131.7 91.81,133.98 91.81,135.29 92.74,136.23 92.74,136.61 93.19,137.06 v1(93.94,137.06)
PCH_JTAG_TCK: length 432.2
  TOP w0.089: 99.18,164.55 99.18,163.78 100.25,162.71 100.25,161.98 100.25,160.24 100.35,160.14 100.35,157.55 100.34,157.54 100.34,157.52 100.28,157.46 U6E1.AJ3
  TOP w0.1: v1(92.6,181.61) 93.09,181.13 93.09,179.86 92.63,179.4 92.63,178 R7D33.1 93.09,175.86 98.69,170.26 98.69,165.54 99.18,165.04 99.18,164.55 ; R1C35.2 v1(298.57,214.88)
  LAY5 w0.125: v1(102.87,265.3) 103.35,265.78 104.08,265.78 104.9,264.97 104.9,263.7 105.58,263.02 107.52,263.02 109.12,264.62 110.64,264.62 112.08,266.06 119.65,266.06 120.29,266.7 129.14,266.7 130.41,267.98 130.41,269.36 133.46,272.42 133.46,274.79 133.85,275.17 133.85,277.84 137.03,281.02 137.03,282.32 139.14,284.44 142.5,284.44 143.46,283.48 143.46,279.67 147.28,275.84 161.7,275.84 162.93,277.08 162.93,278.73 163.47,279.27 166.73,279.27 168.36,277.63 171.26,277.63 172.52,278.9 176.51,278.9 178.81,281.2 178.81,283.59 176.85,285.55 176.85,286.96 177.92,288.04 197.61,288.04 199,286.64 202.94,286.64 204.85,284.73 204.85,277.94 209.93,272.87 209.93,272.16 210.97,271.12 220.45,271.12 221.19,270.38 223.91,270.38 224.41,270.88 224.41,274.63 226.63,276.86 229.04,276.86 229.47,276.43 233.4,276.43 233.95,276.99 239.39,276.99 239.64,276.73 249.8,276.73 250.46,276.07 250.84,276.07 252.7,274.22 267.66,274.22 268.12,273.76 273.96,273.76 274.21,274.01 274.67,274.01 275.74,272.95 276.83,272.95 278.21,271.57 281.34,271.57 282.02,270.89 289.68,270.89 290.19,270.38 294.15,270.38 294.66,270.89 300.71,270.89 303.13,268.46 303.13,262.62 301.88,261.36 301.88,256.46 302.27,256.07 302.27,218.06 299.73,215.52 299.08,215.52 298.57,215.01 v1(298.57,214.88)
  BOTTOM w0.1: v1(92.6,181.61) 92.6,185.82 94.46,187.69 94.46,192.45 95.12,193.11 95.12,204.09 95.71,204.68 95.71,211.63 97.39,213.31 97.39,217.42 98.21,218.24 98.21,227.95 97.87,228.29 97.87,237.82 102.36,242.31 102.36,246.22 102.77,246.63 102.77,252.25 104.4,253.89 104.4,257.03 103.97,257.45 102.71,257.45 101.85,258.32 101.85,264.34 102.81,265.3 v1(102.87,265.3)
PCH_JTAG_TDI: length 352.1
  TOP w0.089: U6E1.AH2 100.73,158.05 100.73,160.3 100.63,160.39 100.63,162.14 100.63,162.97 99.92,163.68
  TOP w0.1: v1(94.1,179.96) 94.61,179.45 94.61,178.05 R7D27.2 95.12,174.48 99.14,170.46 99.14,165.78 99.69,165.23 99.69,163.91 99.92,163.68 ; v1(290.9,220.88) 290.95,220.83 R1C28.2
  LAY5 w0.125: v1(103.32,244.5) 103.84,243.98 105.18,243.98 105.92,244.72 107.64,244.72 108.89,243.47 111.96,243.47 112.17,243.67 113.7,243.67 114.17,243.2 114.17,241.93 114.54,241.56 115.75,241.56 117.33,243.14 126.22,243.14 127.42,244.34 130.8,244.34 132.71,246.25 134.25,246.25 138.7,250.69 148.24,250.69 149.38,249.55 156.85,249.55 158.5,251.2 172.44,251.2 174.74,248.9 181.12,248.9 183.93,251.71 191.38,251.71 191.68,251.42 193.27,251.42 194.31,252.45 194.31,252.88 195.4,253.98 198.43,253.98 199.12,254.68 199.38,254.68 200.11,255.41 210.37,255.41 210.64,255.68 213.06,255.68 213.91,256.54 215.77,256.54 216.4,255.9 222.78,255.9 223.28,255.41 225.86,255.41 226.39,255.93 229.26,255.93 229.38,255.81 233.77,255.81 233.93,255.65 244.59,255.65 247.28,258.34 252.35,258.34 252.96,258.95 254.61,258.95 255.88,260.22 258.51,260.22 259.4,259.33 260.37,259.33 264.18,263.14 267.97,263.14 269.99,265.17 272.79,265.17 273.67,264.29 274.7,264.29 275.59,265.17 276.73,265.17 276.87,265.03 279.67,265.03 280.32,265.68 282.26,265.68 283.07,266.48 289.69,266.48 292.49,263.68 292.49,253 291.72,252.22 291.72,247.58 292.49,246.81 292.49,241.38 294.6,239.27 294.6,227.54 293.24,226.19 293.24,225.42 291.71,223.9 291.71,222.37 290.9,221.56 v1(290.9,220.88)
  BOTTOM w0.1: v1(103.32,244.5) 103.32,242.32 98.55,237.54 98.55,233.81 100.45,231.91 100.45,222.04 99.52,221.11 99.52,217.57 98.7,216.75 98.7,212.77 97.02,211.09 97.02,204.09 96.48,203.55 96.48,192.62 95.77,191.91 95.77,186.02 94.86,185.11 94.86,180.71 v1(94.1,179.96)
PCH_JTAG_TDO: length 357.4
  TOP w0.089: U6E1.AH3 100.63,157.62 100.63,157.77 100.54,157.86 100.54,157.98 100.54,160.22 100.44,160.31 100.44,162.06 100.44,162.83 99.44,163.83 99.44,164.18
  TOP w0.1: 99.44,164.18 99.44,165.1 98.91,165.62 98.91,170.36 94.1,175.17 R7D26.2 93.59,178.05 93.59,180.21 v1(94.1,180.72) ; v1(294.36,219.96) 293.62,219.23 R1C30.2
  LAY5 w0.125: v1(294.36,219.96) 296.1,221.71 296.1,240.7 294.52,242.27 294.52,246.79 295.65,247.92 295.65,248.64 294.27,250.02 294.27,251.08 294.96,251.76 294.96,264.02 290.99,267.99 282.44,267.99 281.63,267.18 279.87,267.18 279.37,267.68 278.53,267.68 277.53,266.68 274.95,266.68 274.55,267.08 269.03,267.08 268.53,267.58 261.86,267.58 261.49,267.21 261.49,266.8 261.11,266.42 254.25,266.42 253.19,265.36 249.09,265.36 247.82,264.09 245.55,264.09 245.23,263.78 243.2,263.78 242.57,264.41 235.96,264.41 235.57,264.02 233.51,264.02 232.11,265.43 229.05,265.43 228.83,265.2 222.07,265.2 221.59,264.73 216.42,264.73 214.27,266.88 210.61,266.88 207.78,264.05 200.92,264.05 199.26,265.71 196.61,265.71 196.22,265.32 192.14,265.32 191.82,265 179.72,265 178.62,263.91 175.36,263.91 171.69,260.23 163.06,260.23 162.69,259.86 159.49,259.86 157.17,257.54 155.2,257.54 154.17,258.58 150.2,258.58 149.43,257.81 143.76,257.81 143.47,257.52 136.37,257.52 132.78,253.94 129.96,253.94 128.61,252.59 126.59,252.59 124.34,250.34 117.94,250.34 117.33,250.95 113.89,250.95 113.7,250.76 104.58,250.76 v1(104.14,250.32)
  BOTTOM w0.1: v1(104.14,250.32) 104.14,247.35 102.81,246.03 102.81,242.13 98.32,237.64 98.32,233.72 100.22,231.82 100.22,222.13 99.29,221.2 99.29,217.67 98.47,216.85 98.47,212.87 96.79,211.18 96.79,204.23 96.25,203.69 96.25,192.71 95.54,192.01 95.54,186.12 94.63,185.21 94.63,181.12 94.23,180.72 v1(94.1,180.72)
PCH_JTAG_TMS: length 355.3
  TOP w0.089: 98.93,164.34 98.93,163.76 100.06,162.63 100.06,161.9 100.06,160.16 100.16,160.06 100.16,157.63 100.04,157.51 100.04,157.11 U6E1.AJ4
  TOP w0.1: 98.93,164.34 98.93,164.97 98.46,165.44 98.46,170.11 92.07,176.5 R7D22.2 91.63,178.87 91.63,179.9 92.58,180.85 v1(92.6,180.85) ; R1C27.2 288.29,219.07 v1(288.92,219.71)
  LAY5 w0.125: v1(288.92,219.71) 288.92,220.65 290.95,222.68 290.95,226.52 291.63,227.2 292.73,227.2 293.49,227.96 293.49,229.61 292.98,230.12 292.98,231.25 293.54,231.8 293.54,236.8 292.98,237.36 292.98,239.79 291.73,241.04 291.73,246.49 290.44,247.79 290.44,255.01 291.08,255.65 291.08,264.38 289.48,265.98 283.27,265.98 281.45,264.16 276.47,264.16 275.71,263.4 271.24,263.4 269.98,262.13 263.52,262.13 260.47,259.08 259.29,259.08 258.4,259.97 255.98,259.97 254.71,258.7 253.07,258.7 252.45,258.09 247.38,258.09 244.69,255.4 229.44,255.4 229.15,255.68 226.49,255.68 225.97,255.16 223.17,255.16 222.68,255.65 216.3,255.65 215.66,256.29 214.02,256.29 213.16,255.43 210.75,255.43 210.47,255.15 200.21,255.15 199.48,254.42 199.23,254.42 198.53,253.73 195.51,253.73 194.56,252.78 194.56,252.35 193.38,251.17 191.58,251.17 191.28,251.46 184.04,251.46 181.23,248.65 174.63,248.65 172.34,250.95 158.61,250.95 156.96,249.3 149.28,249.3 148.14,250.44 138.86,250.44 134.41,246 132.94,246 131.03,244.09 127.53,244.09 126.33,242.89 117.44,242.89 115.85,241.3 109.77,241.3 108.98,242.09 108.98,243.02 107.54,244.46 106.07,244.46 105.33,243.73 99.93,243.73 v1(99.82,243.84)
  BOTTOM w0.1: v1(92.6,180.85) 92.58,180.85 92.07,181.36 92.07,185.61 94.24,187.78 94.24,192.55 94.89,193.2 94.89,204.19 95.48,204.78 95.48,211.72 97.16,213.41 97.16,217.52 97.98,218.34 97.98,227.86 97.64,228.2 97.64,237.98 100.33,240.66 100.33,243.33 v1(99.82,243.84)
PCH_JTAG_TRST_N: length 361.5
  TOP w0.089: U6E1.AM4 98.7,157.07 98.78,157.16 98.78,157.69 98.81,157.72 98.81,158.16 99,158.36 99,159.59 98.92,159.68 98.92,159.68 98.92,161.43 98.92,162 97.54,163.38 97.54,163.95 97.15,164.34
  TOP w0.1: R1C29.2 292.73,219.33 v1(293.11,219.71) ; v1(89.15,183.13) 88.8,183.13 88.14,182.47 88.14,177.42 96.26,169.29 96.26,165.23 97.15,164.34
  LAY5 w0.125: v1(97.79,248.66) 98.27,248.18 110.52,248.18 111.36,247.34 116.38,247.34 116.8,247.76 125.42,247.76 127.67,250.01 129.69,250.01 131.04,251.36 133.86,251.36 136.98,254.47 146.38,254.47 146.87,254.96 158.23,254.96 159.37,256.1 160.54,256.1 161.72,257.28 163.76,257.28 164.13,257.65 172.76,257.65 174.96,259.85 178.35,259.85 179.49,258.71 181.18,258.71 184.22,261.75 189.35,261.75 190.37,262.76 191,262.76 193.39,260.37 198.52,260.37 199.54,261.39 207.95,261.39 211.43,264.88 213.44,264.88 217.21,261.11 223.24,261.11 224.27,260.09 232.52,260.09 232.79,260.35 251.52,260.35 254.43,263.26 259.76,263.26 262.17,265.67 262.4,265.67 263.55,266.83 268.22,266.83 268.75,266.3 272.72,266.3 273.47,265.55 274.67,265.55 275.05,265.93 278,265.93 278.51,266.43 281.95,266.43 282.75,267.24 290,267.24 293.25,263.99 293.25,256.84 293.48,256.6 293.48,251.35 293.24,251.11 293.24,242.43 295.35,240.33 295.35,222.58 293.11,220.34 v1(293.11,219.71)
  BOTTOM w0.1: v1(89.15,183.13) 89.15,184.33 93.09,188.26 93.09,193.02 93.74,193.67 93.74,204.67 94.32,205.26 94.32,212.2 95.5,213.38 95.5,237.47 97.66,239.63 97.66,245.24 97.91,245.49 97.91,248.54 v1(97.79,248.66)
PCH_JTAGX: length 405.6
  TOP w0.089: 100.58,164.34 101.08,163.84 101.08,162.33 101.08,160.58 101.08,160.57 101.19,160.46 101.19,158.34 101.01,158.16 101.01,157.74 100.98,157.71 100.98,157.16 U6E1.AH4
  TOP w0.1: R1C34.2 v1(298.57,215.9) ; v1(94.1,181.48) 94.1,181.39 95.56,179.93 95.56,174.36 99.37,170.55 99.37,165.93 100.2,165.1 100.2,164.72 100.58,164.34
  LAY5 w0.125: v1(298.57,215.9) 299.35,215.9 302.01,218.57 302.01,255.97 301.63,256.35 301.63,261.47 302.88,262.72 302.88,268.36 300.6,270.64 294.76,270.64 294.25,270.13 290.06,270.13 289.56,270.64 281.92,270.64 281.24,271.32 278.1,271.32 276.72,272.7 275.63,272.7 275.28,273.05 274.19,273.05 273.73,273.51 268.01,273.51 267.56,273.96 252.57,273.96 250.71,275.82 250.36,275.82 249.7,276.48 239.54,276.48 239.29,276.73 234.06,276.73 233.5,276.18 229.36,276.18 228.93,276.61 226.74,276.61 224.66,274.53 224.66,270.78 224.01,270.13 221.08,270.13 220.34,270.87 207.79,270.87 207.51,271.14 206.45,271.14 205.97,271.62 204.63,271.62 203.7,272.54 195.91,272.54 192.8,275.66 181.15,275.66 180.84,275.97 176.14,275.97 174.63,274.46 171.18,274.46 166.62,279.01 163.57,279.01 163.18,278.62 163.18,276.97 161.8,275.59 147.18,275.59 143.37,279.4 135.76,279.4 134.1,277.73 134.1,275.07 133.72,274.69 133.72,272.31 130.66,269.26 130.66,267.87 129.24,266.45 120.4,266.45 119.76,265.81 112.18,265.81 110.74,264.37 109.22,264.37 107.62,262.77 105.47,262.77 104.65,263.59 104.65,264.86 104.21,265.3 v1(103.58,265.3)
  BOTTOM w0.1: v1(103.58,265.3) 103.07,264.79 102.66,264.79 102.1,264.23 102.1,258.38 102.81,257.68 104.07,257.68 104.63,257.12 104.63,253.8 102.99,252.16 102.99,246.53 102.58,246.12 102.58,242.22 98.09,237.73 98.09,233.63 99.06,232.66 99.06,232.66 99.99,231.73 99.99,222.22 99.07,221.3 99.07,217.76 98.25,216.94 98.25,212.96 96.56,211.27 96.56,204.33 96.02,203.79 96.02,192.8 95.32,192.1 95.32,186.21 94.1,185 v1(94.1,181.48)
PCH_PCIESLOT2_PWREN: length 169.6
  TOP w0.089: 101.43,129.63 101.43,130.61 102.34,131.53 102.34,135.59 U6E1.AD47
  TOP w0.1: v1(101.85,121.72) 102.05,121.92 102.05,126.31 101.43,126.94 101.43,129.63 ; R8C2.1 v1(50.41,225.42)
  LAY6 w0.125: v1(43.43,210.95) 43.43,210.82 44.43,209.81 44.43,204.84 44.06,204.47 44.06,201.83 45.08,200.81 45.08,189.61 45.33,189.36 45.84,189.36 46.45,188.74 46.45,188.01 47.24,187.22 47.24,186.05 47.87,185.42 49.04,185.42 50.67,183.79 50.67,170.05 50.92,169.8 57.02,169.8 59.43,167.38 59.43,163.42 59.95,162.9 59.95,152.96 63.63,149.28 63.63,146.67 64.09,146.2 64.09,145.17 67.05,142.21 67.05,140.06 68.7,138.41 68.7,137.26 69.83,136.13 70.99,136.13 73.15,133.98 73.15,131.93 76.72,128.36 76.72,127.37 79.86,124.22 79.86,123.68 85.45,118.09 94.84,118.09 98.46,121.72 v1(101.85,121.72)
  BOTTOM w0.1: v1(50.41,225.42) 51.18,224.66 51.18,215.65 46.09,210.56 43.81,210.56 v1(43.43,210.95)
PCH_PCIESLOT3_PWREN: length 311.7
  TOP w0.089: U6E1.AR48 97.06,135.32 97.19,135.19 97.19,133.76 94.51,131.08 94.51,129.67
  TOP w0.1: R8B41.1 27.94,227.33 27.05,228.22 27.05,228.34 26.41,228.98 17.9,228.98 v1(17.65,229.23) ; v1(90.17,105.92) 90.42,106.17 90.42,108.53 90.55,108.65 90.55,110.05 90.86,110.36 90.86,112 92.02,113.16 92.02,116.41 92.51,116.9 92.51,118.5 94.51,120.5 94.51,129.67
  LAY5 w0.125: v1(90.17,105.92) 90.17,104.39 89.53,103.76 89.53,99.31 89.28,99.06 89.28,90.13 85.52,86.37 82.8,86.37 82.16,85.72 81.35,85.72 79.45,83.83 74.14,83.83 73.74,83.42 68.57,83.42 67.47,82.32 65.89,82.32 64.21,80.64 60.39,80.64 59.17,79.42 55.47,79.42 54.97,78.93 53.91,78.93 52.17,77.19 50.63,77.19 50.12,76.68 46.33,76.68 45.96,76.31 43.74,76.31 40.38,72.96 40.38,71.74 37.71,69.06 37.71,66.72 36.45,65.47 36.45,64.73 35.99,64.26 34.67,64.26 33.98,64.95 33.11,64.95 32.63,65.43 28.66,65.43 27.06,67.02 27.06,70.83 28.98,72.74 28.98,74.96 29.35,75.33 29.35,80.44 28.71,81.07 28.71,82.3 27.92,83.1 27.92,87.23 32.51,91.82 32.51,108.33 31.75,109.09 31.75,112.84 31.11,113.47 31.11,115.49 29.05,117.55 29.05,122.22 29.98,123.14 29.98,124.45 29.21,125.22 29.21,126.49 29.71,127 29.71,128.01 26.99,130.74 26.99,137.6 25.76,138.83 25.76,153.15 18.41,160.5 18.41,167.38 20.03,169.01 20.03,171.22 19.58,171.68 19.58,181.71 18.41,182.88 18.41,205.59 18.13,205.87 18.13,208.28 18.79,208.94 18.79,218.69 17.65,219.84 v1(17.65,229.23)
PCH_PECI: length 22.7
  TOP w0.089: U6E1.AF2 101.45,158.07 101.5,158.11 101.57,158.18 101.57,160.62 101.46,160.74 101.46,164.22 101.29,164.39
  TOP w0.1: R7D24.2 96.52,177.67 96.52,176.27 R7D39.1 97.02,174.24 100.33,170.94 100.33,165.86 100.96,165.23 100.96,164.72 101.29,164.39
PCH_PEGSLOT_PWREN: length 158.4
  TOP w0.089: U6E1.L48 108.91,135.1 109.01,135 109.01,134.75 108.93,134.67 108.93,131.66 110.09,130.5 110.26,130.5
  TOP w0.1: v1(109.7,251.84) 109.72,251.84 R6B13.1 ; 110.26,130.5 110.79,130.5 111.83,129.46 v1(111.83,129.21)
  LAY5 w0.125: v1(111.83,129.21) 111.83,129.36 114.04,131.57 115.18,131.57 115.82,132.21 115.82,137.15 114.17,138.8 114.17,156.34 115.06,157.22 115.06,160.02 114.3,160.78 114.3,164.21 114.04,164.46 114.04,166.24 114.8,167 114.8,171.8 116.09,173.08 116.09,177.15 116.78,177.84 116.78,183.01 115.3,184.49 115.3,187.44 116.06,188.2 116.06,188.61 v1(116.58,189.13)
  LAY6 w0.125: v1(109.7,251.84) 109.72,251.81 109.72,249.82 106.53,246.63 106.53,244.81 105.79,244.07 105.79,242.34 106.28,241.84 106.28,239.63 105.94,239.29 105.33,239.29 104.34,240.28 100.92,240.28 98.12,237.48 98.12,233.7 99.94,231.88 99.94,228.4 100.59,227.74 100.59,224.14 99.37,222.92 99.37,217.86 100.32,216.92 100.32,216.05 99.37,215.1 99.37,205.5 113.99,190.88 114.83,190.88 v1(116.58,189.13)
PCH_PLN_DELAY_EN: length 149.9
  TOP w0.089: U6E1.AE44 v1(101.52,137.32)
  TOP w0.1: Q8H3.1 33.9,46.73 34.29,47.12 36.7,47.12 R8H38.1 v1(37.89,46.61)
  LAY5 w0.125: v1(101.6,96.14) 100.82,95.36 97.38,95.36 94.23,92.21 94.23,89.65 91.18,86.6 91.18,85.14 90.88,84.83 90.31,84.83 90.06,84.58 88.16,84.58 86.28,82.71 83.47,82.71 82.97,82.21 82.2,82.21 80.4,80.41 79.19,80.41 76.13,77.35 75.29,77.35 74.65,76.71 72.74,76.71 72.41,76.38 62.97,76.38 58.71,72.12 56.36,72.12 55.98,72.5 52.56,72.5 50.4,70.34 46.69,70.34 44.7,68.36 44.7,67.21 43.4,65.91 41.74,65.91 37.76,61.94 v1(37.43,61.94)
  LAY6 w0.125: v1(37.89,46.61) 37.84,46.61 37.46,46.99 37.46,48.95 38.73,50.22 38.73,50.87 39.88,52.02 39.88,55.14 37.72,57.29 37.72,61.65 v1(37.43,61.94)
  BOTTOM w0.1: v1(101.52,137.32) 100.83,136.63 100.83,128.65 99.94,127.75 99.94,119.78 101.39,118.32 101.39,116.81 102.48,115.72 102.48,110.51 101.57,109.6 101.57,102.89 102.61,101.85 102.61,100.58 102.36,100.33 101.34,100.33 101.09,100.07 101.09,96.65 v1(101.6,96.14)
PCH_PLN_DELAY_SEL: length 148
  TOP w0.1: R8H42.1 39.42,44.78 39.42,39.42 v1(38.98,38.99) ; v1(99.06,102.23) 98.8,102.49 98.8,105.76 99.34,106.3 99.34,107.92 98.76,108.5 98.76,110.04 98.44,110.36 98.44,112.99 99.28,113.83 99.28,114.4 R6F6.2
  LAY5 w0.125: v1(101.98,45.21) 101.81,45.38 96.02,45.38 94.99,44.35 91.63,44.35 87.59,40.31 82.16,40.31 81.69,40.78 77.34,40.78 76.87,40.31 71.57,40.31 70.73,41.15 63.32,41.15 62.48,40.31 60.74,40.31 60.11,40.94 54.82,40.94 54,40.12 44.95,40.12 44.57,39.75 43.32,39.75 42.56,38.99 v1(38.98,38.99)
  LAY6 w0.125: v1(101.98,45.21) 101.98,46.99 102.23,47.25 102.23,60.22 99.41,63.04 99.41,70.01 100.11,70.71 100.11,73.24 99.43,73.91 99.43,84.76 100.23,85.55 100.23,93.41 98.04,95.6 98.04,101.22 v1(99.06,102.23)
PCH_PLN_DELAY_SEL_LED_DRIVE: length 31.4
  TOP w0.089: 98.04,127.63 98.94,128.53 98.94,129.98 99.25,130.29 99.25,131.21 100.35,132.31 100.35,135.48 100.35,135.82 100.28,135.89 U6E1.AJ47
  TOP w0.1: R6F22.1 98.55,107.77 97.8,108.52 97.8,110.02 98.21,110.44 98.21,113.08 99.06,113.93 99.06,115.06 R6F6.1 99.82,115.83 99.82,116.96 99.56,117.22 99.56,117.73 R6F2.2 99.06,118.62 98.04,119.63 98.04,127.63
PCH_PLN_DELAY_SEL_R: length 1.3
  TOP w0.1: U8H5.3 38.08,45.23 R8H42.2
PCH_PORT80_LED: length 174.8
  TOP w0.089: U6E1.BE25 92.05,146.99 91.89,146.99 88.12,146.99 87.99,147.11 85.17,147.11 85.1,147.19 84.45,147.19 R7E22.1 ; 78.99,146 80.85,146 R7E21.2
  TOP w0.1: 78.99,146 76.13,146 75.74,146.39 70.62,146.39 69.98,145.74 64.65,145.74 62.29,143.38 62.2,143.38 v1(61.31,142.49) ; R7E21.2 82.1,146.37 83.63,146.37 R7E22.1 ; v1(27.81,35.84) 28.19,35.46 R8H73.1
  LAY5 w0.125: v1(27.81,35.84) 28.21,35.43 28.67,35.43 28.94,35.17 38.65,35.17 39.29,35.81 46.1,35.81 v1(46.48,35.43)
  LAY6 w0.125: v1(46.48,35.43) 46.48,37.97 51.1,42.59 51.1,47.95 51.41,48.26 51.41,50.8 50.92,51.29 50.92,53.64 52.45,55.17 52.45,61.77 51.81,62.41 51.81,66.24 51.38,66.68 50.82,66.68 50.67,66.82 50.67,68.17 51.25,68.75 51.25,72.37 50.66,72.96 50.66,78.22 52.19,79.75 53.71,79.75 54.22,80.26 54.22,80.75 51.89,83.08 51.89,93.24 50.14,94.99 50.14,109.99 57.28,117.13 57.28,130.84 57.66,131.22 57.66,139.58 60.07,141.98 60.8,141.98 v1(61.31,142.49)
PCH_PRDY_N: length 416.5
  TOP w0.089: U6E1.AM5 98.85,156.83 98.89,156.87 98.89,156.99 98.97,157.07 98.97,157.61 99,157.64 99,158.08 99.06,158.15 99.19,158.28 99.19,159.67 99.11,159.76 99.11,159.76 99.11,161.51 99.11,162.11 97.8,163.41 97.8,163.42 97.8,164.21 97.67,164.34
  TOP w0.1: v1(90.29,183.13) 89.91,183.13 R7D12.2 88.61,181.83 88.61,177.62 96.62,169.61 96.62,165.39 97.67,164.34 ; R1C99.2 297.94,196.72 v1(298.57,196.72)
  LAY5 w0.125: v1(298.57,196.72) 298.09,197.2 298.09,208.63 297.64,209.08 297.64,216.4 300.46,219.22 300.46,223.59 300.78,223.92 300.78,238.4 299.86,239.33 299.86,239.91 301.51,241.56 301.51,255.76 301.12,256.14 301.12,264.28 298.32,267.08 298.32,268.48 297.55,269.24 282.02,269.24 280.9,270.35 274.02,270.35 273.25,271.12 272.23,271.12 271.97,271.38 253.06,271.38 252.73,271.04 250.52,271.04 249.4,272.16 245.99,272.16 245.12,273.03 229.72,273.03 227.33,270.64 227.33,269.24 226.82,268.73 224.79,268.73 223.52,267.46 222.37,267.46 221.74,268.1 220.34,268.1 218.72,269.71 210,269.71 207.9,267.61 204.87,267.61 204.31,267.06 202.05,267.06 201.41,267.7 201.41,268 199.71,269.7 197.1,269.7 192.74,274.06 181.25,274.06 180.59,273.41 180.59,271.91 179.32,270.64 173.1,270.64 171.41,272.32 162.3,272.32 161.16,273.46 144.7,273.46 141.68,276.48 138.4,276.48 135.62,273.7 135.62,271.51 135.38,271.27 135.38,266.67 135.14,266.43 134.35,266.43 129.08,261.16 126.46,261.16 124.86,259.56 115.79,259.56 115.31,259.08 109.51,259.08 107.84,257.4 102.89,257.4 101.34,258.95 v1(100.55,258.95)
  BOTTOM w0.1: v1(90.29,183.13) 90.29,184.8 93.56,188.07 93.56,192.83 94.21,193.48 94.21,204.47 94.8,205.06 94.8,212 96.48,213.69 96.48,217.8 97.3,218.62 97.3,227.57 96.96,227.92 96.96,238.26 98.17,239.47 98.17,244.7 102.31,248.85 102.31,255.09 99.94,257.45 99.94,258.57 100.33,258.95 v1(100.55,258.95)
PCH_PREQ_N: length 414.6
  TOP w0.089: U6E1.AL2 99.25,158.07 99.38,158.2 99.38,159.75 99.3,159.83 99.3,159.84 99.3,161.59 99.3,162.19 97.99,163.5 97.99,164.39 97.93,164.44
  TOP w0.1: 97.93,164.44 96.85,165.53 96.85,169.71 89.15,177.4 R7D18.2 89.61,179.53 89.61,181.4 v1(90.14,181.93) ; R1C102.2 v1(298.57,195.07)
  LAY5 w0.125: v1(298.57,195.07) 297.84,195.81 297.84,208.53 297.39,208.98 297.39,216.56 300.21,219.38 300.21,223.7 300.53,224.02 300.53,238.3 299.6,239.23 299.6,240.01 301.26,241.67 301.26,252.58 295.96,257.88 295.96,266.77 293.74,268.99 281.91,268.99 280.8,270.1 272.49,270.1 272.21,270.38 272.21,270.79 271.87,271.13 253.17,271.13 252.83,270.79 250.41,270.79 250.08,271.12 246.23,271.12 244.57,272.78 230.48,272.78 228.37,270.66 228.37,268.35 227.23,267.21 222.27,267.21 221.89,267.59 216.91,267.59 215.04,269.46 210.1,269.46 208,267.36 204.98,267.36 204.42,266.8 201.95,266.8 201.04,267.71 199.9,267.71 198.16,269.45 196.99,269.45 192.63,273.81 181.35,273.81 180.84,273.3 180.84,271.78 179.45,270.38 172.97,270.38 171.28,272.07 162.2,272.07 161.05,273.21 144.59,273.21 141.58,276.23 138.68,276.23 137.03,274.57 137.03,273.68 135.87,272.53 135.87,271.41 135.63,271.17 135.63,266.57 135.24,266.18 134.45,266.18 129.18,260.91 126.57,260.91 124.97,259.31 115.9,259.31 115.42,258.83 109.62,258.83 107.22,256.43 102.6,256.43 100.84,258.19 100.48,258.19 v1(100.45,258.22)
  BOTTOM w0.1: v1(100.45,258.22) 100.45,257.55 101.72,256.28 102.36,256.28 103.37,255.27 103.37,253.18 102.54,252.35 102.54,248.75 99.31,245.52 99.31,240.29 97.19,238.17 97.19,228.01 97.53,227.67 97.53,218.53 96.71,217.71 96.71,213.6 95.03,211.91 95.03,204.96 94.44,204.38 94.44,193.38 93.79,192.73 93.79,187.97 90.8,184.98 90.8,182.59 v1(90.14,181.93)
PCH_PS_ON_B_1G97_5: length 1.8
  TOP w0.1: 26.79,172.21 27.81,172.21 28.06,171.96 U8D9.6
PCH_PWROK: length 423.2
  TOP w0.089: v1(94.2,138.16) U6E1.AY42
  TOP w0.1: R8C40.2 46.35,208.63 v1(46.76,209.04) ; v1(27.05,209.17) R8C35.1 ; Q7C1.5 85.1,225.95 85.34,226.19 87.63,226.19 88.13,225.68 v1(88.51,225.68) ; v1(36.29,9.9) 36.17,10.03 35.05,10.03 33.65,11.43 TP8J1.1 33.65,16 J8J6.2
  LAY5 w0.125: v1(90.8,202.44) 91.31,201.93 91.31,201.7 95,198.01 95,188.1 97.38,185.72 97.38,179.46 98.4,178.44 98.4,162.05 102.62,157.83 102.62,151.7 102.18,151.27 102.18,151.03 101.98,150.82 101.98,148.86 101.7,148.59 100.94,148.59 100.59,148.24 100.59,147.24 100.28,146.94 99.69,146.94 98.93,146.18 98.93,142.62 98.55,142.24 97.53,142.24 97.28,141.98 97.28,140.08 96.9,139.7 96.9,139.32 96.19,138.61 96.19,138.35 95.88,138.05 95.88,137.41 95.56,137.1 95.56,136.33 95.25,136.02 94.61,136.02 94.43,136.19 94.43,137.92 v1(94.2,138.16) ; v1(36.29,9.9) 36.42,10.03 48.6,10.03 J8J13.26 50.41,8.22 50.41,6.6 51.17,5.84 64.2,5.84 65.01,6.65 65.01,9.52 66.42,10.92 v1(69.08,10.92) ; v1(88.51,225.68) 87.75,226.44 87.75,226.97 80.8,233.92 72.78,233.92 71.88,234.82 70.58,234.82 67.29,238.11 67.29,245.43 66.11,246.62 64.37,246.62 63.24,245.49 59.3,245.49 58.29,246.5 54.61,246.5 v1(54.61,246.51) ; v1(46.76,209.04) 46.12,208.41 44.28,208.41 42.46,206.58 39.47,206.58 38.15,207.9 36.35,207.9 34.83,209.42 33.14,209.42 32.89,209.17 v1(27.05,209.17)
  LAY6 w0.125: v1(90.8,202.44) 90.29,202.94 90.29,203.18 87.69,205.77 87.69,224.86 v1(88.51,225.68) ; v1(69.08,10.92) 68.44,11.56 68.44,17.19 70.7,19.45 70.7,24.89 70.99,25.18 70.99,26.92 70.7,27.21 70.7,29.5 71.12,29.92 71.12,32.46 72.51,33.85 72.51,36.96 76.83,41.27 76.83,48.24 77.35,48.75 77.35,49.61 78.99,51.25 78.99,55.41 79.39,55.81 79.39,65.95 77.73,67.61 77.73,73.43 77.46,73.7 77.46,76.39 78.02,76.95 78.02,79.85 78.83,80.67 78.83,82.89 78.11,83.61 78.11,86.34 78.48,86.71 78.48,89.57 78.11,89.94 78.11,91.3 77.61,91.8 77.61,94.61 75.84,96.37 75.84,103.4 73.04,106.2 73.04,112.04 73.53,112.52 73.53,113.92 v1(74.04,114.43)
  BOTTOM w0.1: v1(54.61,246.51) 54.22,246.12 54.22,233.17 54.64,232.75 54.64,212.6 53.12,211.07 50.8,211.07 48.76,209.04 46.76,209.04 v1(46.76,209.04) ; v1(94.2,138.16) 93.32,138.16 92.83,137.67 92.07,137.67 91.44,137.03 91.44,136.26 90.86,135.69 90.86,135.19 89.02,133.35 87.7,133.35 85.55,131.19 C7R6.1 84.5,131.19 83.18,129.87 83.18,127.14 76.31,120.27 74.03,120.27 73.53,119.77 73.53,114.93 v1(74.04,114.43)
PCH_PWROK_EC: length 178.7
  TOP w0.1: R6J26.2 114.93,10.08 v1(115.39,10.54) J6J2.32 ; U8F6.73 22.42,90.11 21.84,89.53 21.84,89.25 v1(21.36,88.77) 20.82,88.24 R9G11.1 R9G17.2
  LAY3 w0.1: v1(21.36,88.77) 21.36,87.35 21.46,87.25 21.46,85.09 19.39,83.02 19.39,74.41 17.14,72.16 17.14,62.56 13.55,58.97 13.55,51.06 16.38,48.23 16.38,45.59 16.95,45.02 18.45,45.02 19.75,43.72 19.75,40.33 21.3,38.77 21.3,37.5 21.84,36.96 21.84,35.56 23.86,33.54 23.86,33.16 25.27,31.75 25.65,31.75 27.36,30.03 28.38,30.03 31.11,27.3 33.4,27.3 35.81,24.89 47.37,24.89 48.66,23.6 53.27,23.6 53.87,24.2 55.88,24.2 56.84,23.24 58.95,23.24 60.67,21.52 61.83,21.52 62.31,21.04 64.28,21.04 64.65,20.67 76.29,20.67 76.45,20.51 80.83,20.51 82.39,22.07 85.18,22.07 87.23,20.01 98.74,20.01 99.36,19.4 100.41,19.4 100.92,18.89 104.42,18.89 v1(104.76,18.54)
  LAY6 w0.125: v1(115.39,10.54) 114.3,10.54 112.8,9.04 111.98,9.04 111.4,9.62 108.04,9.62 107.82,9.4 106.7,9.4 104.76,11.34 v1(104.76,18.54)
PCH_PWROK_N: length 3.7
  TOP w0.1: Q7C1.2 85.1,221.85 85.21,221.74 85.72,221.74 85.75,221.77 Q7C1.3 86.61,222.63 R7C6.2
PCH_RSMRST_AND_N: length 1.6
  TOP w0.1: R8D91.1 27.43,162.31 U8D13.4
PCH_RSMRST_EC_AND_N: length 318.8
  TOP w0.1: U8F6.12 27.22,105.04 26.19,104.01 v1(25.14,104.01) ; v1(16.25,168.91) 16.41,168.75 24.86,168.75 24.98,168.88 25.74,168.88 27.61,167 28.14,167 28.38,166.76 U8D13.2 28.38,163.38 28.32,163.32 R8D92.1 ; J6J2.231 v1(147.66,12.14)
  LAY3 w0.1: v1(147.66,12.14) 146.95,11.43 143.49,11.43 141.59,13.33 136.52,13.33 136.14,13.71 130.17,13.71 129.15,12.7 126.49,12.7 125.12,11.33 111.7,11.33 109.41,13.61 109.41,13.91 107.19,16.13 86.22,16.13 84.08,18.28 73.15,18.28 72.21,17.34 69.15,17.34 68.84,17.03 65.14,17.03 63.36,18.81 60.66,18.81 60.1,18.26 58.55,18.26 57.79,19.02 56.52,19.02 55.76,18.26 54.59,18.26 53.95,18.89 31.24,18.89 28.81,21.32 28.81,22.58 26.57,24.82 26.57,26.75 22.49,30.83 22.11,30.83 19.9,33.04 19.9,34.25 19.65,34.5 19.65,38.09 19.38,38.35 14.47,38.35 13.08,39.75 13.08,49.2 10.86,51.41 10.86,58.62 14.22,61.97 14.22,72.66 17.1,75.54 17.1,83.18 17.78,83.86 17.78,87.13 19.14,88.5 19.14,93.53 23.46,97.85 23.46,99.17 25,100.71 25.31,100.71 25.65,101.05 25.65,103.5 v1(25.14,104.01)
  LAY5 w0.125: v1(25.14,104.01) 24.39,104.76 24.39,108.31 24.68,108.61 24.68,113.23 25.14,113.68 25.14,124.47 25.48,124.81 25.48,130.33 24.37,131.44 24.37,150.25 20.83,153.79 20.83,155.41 16.1,160.14 16.1,168.75 v1(16.25,168.91)
PCH_RSMRST_EC_N: length 61.9
  TOP w0.1: v1(19.93,114.55) 19.81,114.68 R9F8.2 ; v1(26.67,161.42) R8D91.2 R8D92.2
  LAY6 w0.125: v1(19.93,114.55) 19.43,115.06 19.43,121.03 19.93,121.53 19.93,134.75 19.01,135.67 19.01,140.4 21.07,142.46 21.07,148.54 20.31,149.3 20.31,154.21 19.05,155.47 v1(19.05,161.42)
  BOTTOM w0.1: v1(26.67,161.42) 25.78,161.42 23.74,163.45 19.93,163.45 19.55,163.07 19.55,161.67 19.3,161.42 v1(19.05,161.42)
PCH_RSMRST_N: length 891.4
  TOP w0.1: v1(176.91,45.55) 176.93,45.55 177.03,45.65 R4H48.1 ; R9F8.1 C9F1.1 ; C9F1.1 R9F11.2 ; C9F1.1 TP9F2.1 15.84,112.61 15.84,110.75 12.95,107.86 12.95,105.41 v1(13.58,104.77) ; R6H22.2 v1(118.11,40) ; v1(48.51,180.34) 49.12,179.73 49.99,179.73 50.82,180.56 50.82,184.5 53.46,187.14 53.46,187.96 R8D21.2 ; R1C47.1 301.37,209.93 302.92,208.37 302.92,196.88 v1(302.38,196.34) ; R7F7.1 78.23,124.08 77.08,124.08 75.69,122.68 75.69,121.41 76.32,120.78 76.32,117.6 76.45,117.47 v1(76.45,117.35)
  LAY5 w0.125: v1(302.38,196.34) 302.83,195.89 302.83,133.54 301.87,132.59 301.87,120.65 302.83,119.69 302.83,93.74 302.12,93.03 302.12,91.74 302.77,91.09 302.77,68.15 302.3,67.68 295.01,67.68 291.82,64.48 288.52,64.48 285.88,61.85 283.59,61.85 283.21,61.47 283.21,61.13 281.76,59.68 279.19,59.68 278.43,58.92 276.65,58.92 275.68,57.95 275.68,56.68 274.25,55.25 271.17,55.25 269.42,53.5 265.63,53.5 263.73,51.6 253.76,51.6 251.3,49.13 234,49.13 232.26,47.4 220.82,47.4 218.44,49.78 218.44,51.2 214.88,54.75 213.13,54.75 211.46,56.42 202.39,56.42 202.13,56.17 200.74,56.17 199.76,55.19 199.76,53.3 194.32,47.86 185.51,47.86 183.19,45.55 v1(176.91,45.55) 168.9,45.55 166.61,43.26 163.88,43.26 160.22,39.6 160.22,36.22 152.59,28.58 150.12,28.58 149.47,27.94 148.71,27.94 147.81,28.85 137.77,28.85 132.56,23.64 131.46,23.64 130.17,22.35 122.4,22.35 121.88,22.87 120.13,22.87 v1(119.63,23.37) 119.12,22.86 115.13,22.86 114.12,21.85 111.98,21.85 111.85,21.98 108.14,21.98 106.6,20.45 104.77,20.45 102.19,17.87 99.82,17.87 98.88,18.8 89.85,18.8 89.2,18.15 87.08,18.15 85.46,19.77 85.46,22.05 84.14,23.37 72.39,23.37 v1(71.88,23.87) 71.37,23.37 68.64,23.37 67.37,22.1 59.95,22.1 59.94,22.09 59.38,22.09 59.26,22.22 55.62,22.22 55.47,22.06 52.07,22.06 49.78,19.77 49.78,19.43 49.39,19.04 27.18,19.04 26.54,19.68 v1(26.54,22.1) 14.35,22.1 v1(13.71,21.46)
  LAY6 w0.125: v1(26.54,22.1) 26.54,8.09 J8J13.3 ; v1(76.45,117.35) 76.35,117.45 76.17,117.45 74.67,115.95 74.67,112.72 73.54,111.59 73.54,106.41 76.34,103.61 76.34,96.58 79.12,93.8 79.12,90.68 v1(78.61,90.17) 78.98,89.8 78.98,86.5 78.61,86.13 78.61,83.82 79.33,83.09 79.33,80.46 78.52,79.65 78.52,76.74 77.96,76.18 77.96,73.91 78.35,73.52 78.35,67.69 79.89,66.16 79.89,55.6 79.49,55.21 79.49,51.04 78.1,49.66 78.1,41.65 75.43,38.99 75.43,36.07 71.62,32.26 71.62,29.72 71.2,29.29 71.2,27.58 71.88,26.91 v1(71.88,23.87) ; v1(48.51,180.34) 49.18,179.67 49.18,169.45 51.61,167.02 51.61,159.38 51.81,159.18 51.81,157.1 v1(52.19,156.72) ; v1(13.71,21.46) 13.08,22.1 12.82,22.1 11.45,23.47 11.45,50.2 10.46,51.19 10.46,62.24 11.27,63.05 11.27,69.22 12.17,70.12 12.17,73.05 13.88,74.76 13.88,79.43 11.4,81.91 11.4,95.89 12.37,96.86 12.37,103.56 v1(13.58,104.77) 12.69,105.67 12.69,109.73 13.83,110.87 13.83,119.87 11.64,122.06 11.64,131.46 14.32,134.14 14.32,136.17 14.97,136.82 14.97,137.4 16.87,139.29 16.87,144.76 16.5,145.13 16.5,158.29 v1(16.21,158.58)
  BOTTOM w0.1: R7U30.1 70.86,89.03 72.37,90.53 74.54,90.53 74.91,90.17 v1(78.61,90.17) ; v1(119.63,23.37) 119.88,23.62 123.69,23.62 128.77,28.7 128.77,32 128.27,32.51 119.88,32.51 119.12,33.27 117.85,33.27 116.55,34.57 116.55,38.45 v1(118.11,40) ; v1(16.21,158.58) 18.95,155.84 24.69,155.84 25.11,156.25 27.48,156.25 27.89,155.84 30.77,155.84 30.88,155.73 33.22,155.73 33.7,156.2 41.3,156.2 42.43,155.07 45.97,155.07 46.99,156.08 46.99,156.72 47.24,156.97 51.94,156.97 v1(52.19,156.72)
PCH_RST_GPIO: length 247.6
  TOP w0.089: U6E1.V48 105.37,135.48 105.33,135.44 105.33,128.87
  TOP w0.1: R8D61.1 v1(42.67,175.64) ; v1(106.94,107.69) 106.94,108.45 107.04,108.56 107.04,112.08 106.96,112.16 106.96,113.45 107.65,114.14 107.65,120.89 107.11,121.43 107.11,127.08 105.33,128.87
  LAY5 w0.125: v1(106.94,107.69) 106.94,107.42 106.93,107.41 106.93,105.54 106.04,104.65 106.04,103 106.8,102.23 106.8,93.85 104.52,91.57 102.58,91.57 98.69,87.67 98.69,86.97 92.98,81.26 92.1,81.26 90.44,79.6 86.32,79.6 84.63,77.9 84.63,77.01 83.96,76.34 83.7,76.34 82.93,75.56 82.93,75.06 82.23,74.36 81.85,74.36 81.15,73.66 81.15,73.02 78.99,70.86 76.24,70.86 72.29,66.92 60.71,66.92 60.04,66.25 60.04,65.43 60.15,65.31 60.15,64.39 59.08,63.32 52.75,63.32 52.06,64.01 v1(50.52,64.01)
  LAY6 w0.125: v1(57.91,167.13) 57.91,166.88 58.18,166.6 58.18,162.95 57.2,161.97 57.2,142.92 54.23,139.96 54.23,132.31 56.4,130.15 56.4,117.49 49.26,110.35 49.26,94.62 50.93,92.95 50.93,90.06 50.03,89.16 50.03,88.13 51.01,87.16 51.01,81.25 48.75,78.99 48.75,73.8 49.5,73.05 49.5,69.85 49.54,69.8 49.54,66.7 49.14,66.29 49.14,65.79 49.53,65.4 49.53,65 v1(50.52,64.01)
  BOTTOM w0.1: v1(42.67,175.64) 42.76,175.64 45.84,172.56 51.08,172.56 56,167.64 57.4,167.64 v1(57.91,167.13)
PCH_RTCRST_PULLUP: length 194.6
  TOP w0.089: U6E1.BE47 v1(92.87,135.69)
  TOP w0.1: R7H11.1 78.14,61.85 83.18,61.85 84.45,63.12 v1(86.74,63.12) ; J8J13.17 42.54,8.13 42.54,11.56 42.92,11.94 42.92,15.87 J8J9.2
  LAY5 w0.125: J8J9.2 45.59,18.54 49.6,18.54 50.28,19.22 50.28,19.56 52.28,21.56 55.01,21.56 55.49,21.08 57.65,21.08 58.18,20.56 60.23,20.56 60.76,21.08 67.59,21.08 68.73,22.22 83.82,22.22 v1(84.45,21.59)
  LAY6 w0.125: v1(84.45,21.59) 84.95,22.08 84.95,26.17 83.69,27.43 83.69,43.62 85.1,45.04 85.1,50.32 87.04,52.26 87.04,59.64 87.83,60.43 87.83,61.9 86.74,62.99 v1(86.74,63.12) 88.51,64.89 88.52,64.89 88.92,65.29 88.92,72.39 86.99,74.31 86.99,79.88 86.92,79.96 86.92,89.59 86.54,89.97 86.54,96.08 v1(82.67,99.95)
  BOTTOM w0.1: v1(92.87,135.69) 92.87,135.68 92.29,135.1 92.29,133.78 91.05,132.55 91.05,131.7 TP7R2.1 R7R62.2 C7R9.1 89.15,128.9 86.23,125.98 84.45,125.98 82.93,124.46 82.93,117.98 82.07,117.13 82.07,115.41 82.42,115.06 82.42,101.47 82.16,101.22 82.16,100.46 v1(82.67,99.95)
PCH_RTCX1: length 23.3
  TOP w0.089: U6E1.BA49 94.32,134.52 90.87,131.07 90.87,130.94
  TOP w0.1: 90.87,130.94 90.87,130.49 87.64,127.25 83.58,127.25 79.52,123.19 79.24,123.19 C7F6.1 R7F11.2 R7F15.2
PCH_RTCX1_XTAL: length 1.7
  TOP w0.1: Y7F1.1 78.74,118.08 R7F15.1
PCH_RTCX2: length 24.6
  TOP w0.089: 90.65,130.94 90.65,131.12 94.06,134.53 94.06,135.01 94.12,135.06 U6E1.BA48
  TOP w0.1: 90.65,130.94 90.65,130.69 87.51,127.55 83.45,127.55 79.82,123.93 78.86,123.57 C7F5.1 77.47,121.79 R7F11.1 R7F14.2
PCH_RTCXO_XTAL: length 1.7
  TOP w0.1: R7F14.1 Y7F1.2
PCH_SATA1_PWR_EN: length 145.3
  TOP w0.089: 98.71,129.07 98.71,130.03 99.06,130.37 99.06,131.29 100.16,132.39 100.16,135.57 100.16,135.57 100.16,135.74 100.04,135.86 100.04,136.26 U6E1.AJ46
  TOP w0.1: U6J1.2 104.28,4.42 R6J32.2 104.64,3.43 v1(104.77,3.3) ; 98.71,129.07 98.71,128.59 97.81,127.69 97.81,119.43 98.55,118.7 98.55,115.95 98.83,115.67 98.83,114.02 97.98,113.18 97.98,110.53 97.57,110.12 97.57,108.42 98.04,107.96 98.04,100.84 v1(99.06,99.82)
  LAY6 w0.125: v1(99.06,99.82) 98.3,99.06 98.3,95.7 100.48,93.52 100.48,85.45 99.69,84.65 99.69,74.09 100.36,73.41 100.36,70.6 99.66,69.9 99.66,63.15 102.49,60.32 102.49,42.97 104.52,40.94 104.52,37.49 102.48,35.45 102.48,24.13 103.12,23.5 103.12,8.13 102.61,7.62 102.61,5.46 v1(104.77,3.3)
PCH_SATA2_PWR_EN: length 190.7
  TOP w0.089: U6E1.R47 107.21,135.91 107.14,135.85 107.14,135.81 107.14,130.88 109.7,128.33 109.7,127.55
  TOP w0.1: 45.97,36.96 45.97,38.35 v1(45.33,38.99) ; v1(108.83,105.54) 108.35,106.02 108.35,106.57 108.58,106.81 108.81,106.81 109.13,107.12 109.13,107.53 108.81,107.85 108.81,109.83 109.7,110.72 109.7,127.55
  LAY5 w0.125: v1(123.06,40.77) 119.08,40.77 118.57,41.28 105.78,41.28 105.66,41.4 94.2,41.4 90.78,37.98 90.78,37.34 89.72,36.28 79.43,36.28 78.85,36.87 75.62,36.87 74.9,37.59 67.96,37.59 67.07,36.7 66.14,36.7 65.76,37.08 64.92,37.08 64.4,36.57 51.97,36.57 49.56,38.98 47.79,38.98 47.16,38.35 45.98,38.35 v1(45.33,38.99)
  LAY6 w0.125: v1(123.06,40.77) 122.55,41.27 122.55,49.09 122.35,49.29 122.35,55.83 121.62,56.55 121.62,57.52 118.49,60.65 118.49,69.9 120.52,71.94 120.52,76.84 118.54,78.82 118.54,82.32 113.17,87.69 113.17,98.59 109.85,101.91 109.85,104.52 v1(108.83,105.54)
