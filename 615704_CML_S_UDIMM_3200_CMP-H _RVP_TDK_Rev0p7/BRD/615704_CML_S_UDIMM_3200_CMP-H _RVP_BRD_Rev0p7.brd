# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Library data of the parts (continued)
C7A5 C7A6 C7A9 C7A10 = CAP: alternate symbols: (); part number: CAP_0402-A36095-011,C0G,68PF,50V,5%,LPDB,GENERIC
C7A7 C7A8 = CAP: alternate symbols: (); part number: CAP_0402-A36095-005,C0G,20PF,50V,5%,LPDB,GENERIC
C7B2 = CAPP: alternate symbols: (); part number: CAPP_RDL-A93544-018,ALUM,100UF,25V,20%,LPDB,GENERIC; room: VREG
C7B6 C8B13 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,X7R,0.1UF,50V,10%,LPDB,GENERIC; room: 101
C7B7 C7B8 C7C3 C7C4 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 90
C7B9 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,EMPTY,0.1UF,50V,10%,LPDB,GENERIC; room: VREG
C7B10 C7C1 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 90
C7B11 C7B12 C7C6 C7C7 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 90
C7B16 C7B17 = CAP: alternate symbols: (); part number: CAP_0402-A36096-104,X7R,0.22UF,16V,10%,LPDB,GENERIC; room: 90
C7C9 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,X5R,4.7UF,16V,10%,LPDB,GENERIC; room: 88
C7E2 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,X5R,4.7UF,16V,10%,LPDB,GENERIC; room: 155
C7E4 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,EMPTY,4.7UF,16V,10%,LPDB,GENERIC
C7E5-C7E7 C8B1 C8B3 C8B5 C9D1 C9D2 = CAP: alternate symbols: (); part number: CAP_0402-A98765-008,EMPTY,5PF,50V,0.1PF,LPDB,GENERIC
C7E9 C7R1 = CAP: alternate symbols: (); part number: CAP_0402-A36095-038,C0G,27PF,50V,5%,LPDB,GENERIC; room: 104
C7E11 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,EMPTY,1UF,6.3V,10%,LPDB,GENERIC; room: 36
C7E13 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,EMPTY,1UF,6.3V,10%,LPDB,GENERIC
C7E14 C7F1 C7F8 C7T1 C8H18-C8H22 = CAP: alternate symbols: (); part number: CAP_0402-A36096-135,EMPTY,0.33UF,25V,+/-10%,LPDB,GENERIC
C7E17 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 155
C7E18 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 155
C7F7 C7R9 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: ICH
C7G1 = CAP: alternate symbols: (); part number: CAP_0402-A36096-104,X7R,0.22UF,16V,10%,LPDB,GENERIC
C7G2 C7G5 C7U2 C7U3 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 118
C7G7 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 119
C7H3 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 141
C7H4 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,X7R,0.1UF,50V,10%,LPDB,GENERIC; room: DCL_CORE_GMCH
C7H5 C8H17 C9D6 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: SIO
C7H8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 195
C7J2 C7J4-C7J7 = CAP: alternate symbols: (); part number: CAP_0402-A36096-049,X7R,470PF,50V,10%,LPDB,GENERIC; room: SIO_PS2KEYMOUSE
C7J3 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 204
C7L2 C7M3 C7M5 C7M7 = CAP: alternate symbols: (SMC0402_OCTO_IA,SMC0402_OCTO_IA_PHED); part number: CAP_0402-A36096-114,EMPTY,10UF,6.3V,20%,LPDB,GENERIC
C7R3-C7R5 C7R7 C7R8 C7U1 = CAP: alternate symbols: (); part number: CAP_0402-A36095-038,EMPTY,27PF,50V,5%,LPDB,GENERIC
C8B7 C8B8 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,X7R,0.1UF,50V,10%,LPDB,GENERIC; room: 100
C8B12 C8B14 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,X7R,0.1UF,50V,10%,LPDB,GENERIC; room: DCL_PCIX
C8B22 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 100
C8B23 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 101
C8B35 = CAP: alternate symbols: (); part number: CAP_0402-A36096-075,X7R,2200PF,50V,10%,LPDB,GENERIC; room: 177
C8C3 C8C5 C8D5 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 177
C8C4 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: CORE_VBAT
C8C6 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 177
C8C16 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 182
C8C17 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 180
C8C18 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 180
C8C19 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,EMPTY,1UF,6.3V,10%,LPDB,GENERIC; room: 183
C8C20 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,EMPTY,0.1UF,25V,10%,LPDB,GENERIC; room: 183
C8C21 C8C26 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 183
C8C22 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 176
C8C23 C8C24 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC; room: DCPL_BULK_MISC
C8C25 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 176
C8C27 = CAP: alternate symbols: (); part number: CAP_0402-A36096-075,X7R,2200PF,50V,10%,LPDB,GENERIC; room: 176
C8D2-C8D4 C8D25 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 179
C8D6 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 177
C8D7 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: AUDIO
C8D8 = CAP: alternate symbols: (); part number: CAP_0402-A36096-099,EMPTY,1UF,10V,10%,LPDB,GENERIC; room: 177
C8D10 = CAP: alternate symbols: (); part number: CAP_0402-H29050-001,EMPTY,1UF,25V,10%,LPDB,GENERIC; room: 177
C8D11 C8D14 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC; room: 177
C8D13 C8D19 = CAP: alternate symbols: (); part number: CAP_0603-602431-026,EMPTY,1000PF,50V,10%,LPDB,GENERIC; room: 177
C8D17 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,EMPTY,0.01UF,25V,10%,LPDB,GENERIC; room: 177
C8D23 = CAP: alternate symbols: (); part number: CAP_0402-A36095-026,C0G,100PF,50V,5%,LPDB,GENERIC; room: 178
C8D27 C8D29 C8D30 C8D35 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 178
C8D31 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 178
C8E10 C8L4 C9E2 C9E3 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 128
C8E15 C8E16 C9C7 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 102
C8E17 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 125
C8E18 = CAP: alternate symbols: (); part number: CAP_0402-A36095-025,C0G,47PF,50V,5%,LPDB,GENERIC; room: 125
C8E19 C8F1 C9B2 C9B3 = CAP: alternate symbols: (); part number: CAP_0402-A36095-031,C0G,33PF,50V,5%,LPDB,GENERIC
C8F2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 33
C8F8 C8F11 C8F18 C8F20 C8G3 C8G6 C8G7 C9F2 C9F4 C9G1 C9G2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 126
C8F9 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,EMPTY,0.1UF,10V,10%,LPDB,GENERIC; room: 125
C8F10 = CAP: alternate symbols: (); part number: CAP_0402-A36096-110,EMPTY,0.1UF,16V,10%,LPDB,GENERIC; room: 127
C8F15 C8F17 = CAP: alternate symbols: (); part number: CAP_0402-A36094-025,C0G,10PF,50V,0.5PF,LPDB,GENERIC; room: 126
C8F16 = CAP: alternate symbols: (); part number: CAP_0402-G71847-005,C0G,22PF,50V,5%,LPDB,GENERIC
C8F19 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,EMPTY,0.1UF,10V,10%,LPDB,GENERIC; room: 124
C8G2 = CAP: alternate symbols: (); part number: CAP_0402-A36095-026,EMPTY,100PF,50V,5%,LPDB,GENERIC; room: 124
C8G5 = CAP: alternate symbols: (); part number: CAP_0402-G71847-005,C0G,22PF,50V,5%,LPDB,GENERIC; room: DCL_CORE_FSB
C8G13 C8G16 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 121
C8G17 C8G18 C8H1 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 93
C8G19 C8G20 C8G22 C8H5 C9G9 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 93
C8H4 C8H6 C9G10 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 93
C8H9-C8H16 = CAP: alternate symbols: (); part number: CAP_0402-A36096-104,X7R,0.22UF,16V,10%,LPDB,GENERIC; room: 93
C8H23 C8H24 = CAP: alternate symbols: (); part number: CAP_0603-602431-005,EMPTY,470PF,50V,10%,LPDB,GENERIC; room: 138
C8L1 C8L2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 122
C8L3 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 122
C9B4 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 129
C9C1-C9C4 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,X7R,0.1UF,50V,10%,LPDB,GENERIC; room: 129
C9C8 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 99
C9C9 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,X5R,0.1UF,10V,10%,LPDB,GENERIC; room: 99
C9D7 = CAP: alternate symbols: (); part number: CAP_0402-A36096-107,X5R,4.7UF,6.3V,20%,LPDB,GENERIC; room: 140
C9E1 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 123
C9F3 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 126
C9G5 = CAP: alternate symbols: (); part number: CAP_0603-602431-026,EMPTY,1000PF,50V,10%,LPDB,GENERIC; room: 36
C9G6 C9G7 = CAP: alternate symbols: (); part number: CAP_0402-A36096-049,EMPTY,470PF,50V,10%,LPDB,GENERIC; room: SIO_STDFNTPNL
C9G8 = CAP: alternate symbols: (); part number: CAP_0402-A36096-049,EMPTY,470PF,50V,10%,LPDB,GENERIC
CP9H1 = CPAK_4C4C: alternate symbols: (); part number: CPAK_4C4C_1206-661871-232,EMPTY,470PF,50V,20%,LPDB,GENERIC; room: 138
CR1B1 CR5E1 CR8C1 CR8D1 CR8D2 CR8F4 = BAT54C: alternate symbols: (); part number: BAT54C_SMALLSM-C52251-001,DISCRETE,BAT54C,200MA,LPDB,GENERIC; room: VREG_VBAT
CR1B2 CR1B3 CR5B2 CR5B3 = DIODE: alternate symbols: (); part number: DIODE_SM-J50675-001,DIODE,PMEG4010ER,1.0 A,LPDB,GENERIC
CR2A1 CR3A2 EU2A1-EU2A6 EU3A1 = AOZ8839DI_2: alternate symbols: (); part number: AOZ8839DI_2_LCC-K48341-001,IC,AOZ8839DI-03,TK0,GENERIC; room: NONE
CR2A2 CR8F3 = BAT54A: alternate symbols: (); part number: BAT54A_BAT54A-C81409-002,DIODE,BAT54A,LPDB,GENERIC
CR2A3 = BAT54A: alternate symbols: (); part number: BAT54A_BAT54A-C81409-002,DIODE,BAT54A,LPDB,GENERIC; room: 62
CR2A4 = DIODE: alternate symbols: (); part number: DIODE_SM-D55839-001,EMPTY,1N5819HW,1.0A,LPDB,GENERIC; room: 173
CR3A1 CR4A7 Q3B1 = BAT54C: alternate symbols: (); part number: BAT54C_SMALLSM-C52251-001,EMPTY,BAT54C,200MA,LPDB,GENERIC; room: FAN_CNTL
CR3A3-CR3A10 CR4A8-CR4A11 CR5A3 CR5A4 CR6C1-CR6C5 CR6C7 CR6D3 CR6D4 CR7C5-CR7C8 = DIODE_TVS: alternate symbols: (); part number: DIODE_TVS_SM-J76907-001,DIODE,20KV,3.5A,LPDB,GENERIC
CR4A1-CR4A6 CR4L1 CR4L2 CR5A1 CR5A2 CR5A5 CR5A6 CR6C6 CR6C8 = DIODE_ESD_BIDIR: alternate symbols: (); part number: DIODE_ESD_BIDIR_SOD962-J24007-001,DIO,PESD5V0H1BSF,7A,LPDB,GENERIC
CR4J1 = DIODE: alternate symbols: (); part number: DIODE_SM-D55839-001,DIODE,1N5819HW,1.0A,LPDB,GENERIC
CR5B1 CR6A3 CR8F6 = DIODE_SHOTTKY: alternate symbols: (); part number: DIODE_SHOTTKY_SM-C81938-001,IC,30V,0.5A,LPDB,GENERIC
CR5C1 CR7B1 = DIODE: alternate symbols: (); part number: DIODE_SM-D55839-001,EMPTY,1N5819HW,1.0A,LPDB,GENERIC
CR6A1 = DIODE_TVS_UNI: alternate symbols: (); part number: DIODE_TVS_UNI_SOD-G95181-001,DIO,T5V0S5-7,1MA,LPDB,GENERIC; room: 174
CR6A2 = DIODE_SHOTTKY: alternate symbols: (); part number: DIODE_SHOTTKY_SM-C81938-001,IC,30V,0.5A,LPDB,GENERIC; room: 190
CR6J1 = BAT54C: alternate symbols: (); part number: BAT54C_SMALLSM-C52251-001,DISCRETE,BAT54C,200MA,LPDB,GENERIC
CR7C1 CR7C4 = LED: alternate symbols: (); part number: LED_A1-C97278-001,LED_A1,GREEN,LPDB,GENERIC; room: 90
CR7C2 CR7C3 CR9C1 = DIODE_ESD_BIDIR: alternate symbols: (); part number: DIODE_ESD_BIDIR_SOD962-J71213-001,DIO,PESD5V0R1BSF,4.5A,LPDB,GENERIC
CR7G1 = DIODE_SHOTTKY: alternate symbols: (); part number: DIODE_SHOTTKY_SM-C81938-001,IC,30V,0.5A,LPDB,GENERIC; room: 118
CR7G2 = DIODE_SHOTTKY: alternate symbols: (); part number: DIODE_SHOTTKY_SM-C81938-001,EMPTY,30V,0.5A,LPDB,GENERIC; room: 118
CR7H1 CR8F5 CR9G1-CR9G4 DS7H1 DS8H2-DS8H7 DS9J1 = LED: alternate symbols: (); part number: LED_A1-C97278-001,LED_A1,GREEN,LPDB,GENERIC
CR8A1 = DIODE_SHOTTKY: alternate symbols: (); part number: DIODE_SHOTTKY_SM-C81938-001,EMPTY,30V,0.5A,LPDB,GENERIC; room: 110
CR8F1 CR8F2 R2B2 = DIODE_SHOTTKY: alternate symbols: (); part number: DIODE_SHOTTKY_SM-C81938-001,EMPTY,30V,0.5A,LPDB,GENERIC; room: LPSS
CR8H1 = LED: alternate symbols: (); part number: LED_A1-C97278-001,LED_A1,GREEN,LPDB,GENERIC; room: 95
CR8H2 = LED: alternate symbols: (); part number: LED_A1-C97278-005,LED,RED,LPDB,GENERIC
CR9C2-CR9C4 CR9D1-CR9D3 = DIODE_TVS_UNI: alternate symbols: (); part number: DIODE_TVS_UNI_SM-G90274-001,DIO,ESD102-U1-02ELS,3A,LPDB,GENERIC
CR9E1 = DIODE_SHOTTKY: alternate symbols: (); part number: DIODE_SHOTTKY_SM-C81938-001,IC,30V,0.5A,LPDB,GENERIC; room: 128
CR9H1 = LED_DUAL_2: alternate symbols: (); part number: LED_DUAL_2_SM-K58103-001,LED,YELLOW_GREEN / YELLOW,TK0,GENERIC; room: NONE
CRP7J1 = BZA462A: alternate symbols: (); part number: BZA462A_SOT-C85310-001,EMPTY,BZA462A,LPDB,GENERIC; room: 195
DS8A1-DS8A4 = LED_7SEG_APSC02: alternate symbols: (); part number: LED_7SEG_APSC02_SM-D24357-001,LED,RED,LPDB,GENERIC; room: 122
DS8H1 = LED: alternate symbols: (); part number: LED_A1-C97278-001,LED_A1,GREEN,LPDB,GENERIC; room: 93
E4C1 E4C2 R4C23 R4C24 R5F13 R6D34 R6F16 R8G85 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-E58715-001,CHIP,0.005,1%,1/8W,LPDB,GENERIC
EU1B1 = RT3609BEGQW_R02_2: alternate symbols: (); part number: RT3609BEGQW_R02_2_LCC-K59846-001,IC,RT3609BEGQW-02,TK0,GENERIC; room: NONE
EU1D1 EU1D2 EU2B2-EU2B4 EU3B1-EU3B3 EU4B3 EU4B4 = SIC634CD: alternate symbols: (); part number: SIC634CD_LCC-K35549-001,IC,SIC634CD-T1-GE3,LPDB,GENERIC
EU1E1 EU4G1 EU5C1 EU5C5 EU7B1 EU7B2 EU8B2 EU8B3 = MOSFET_N_1G1D3S_2: alternate symbols: (); part number: MOSFET_N_1G1D3S_2_LCC-K46826-001,IC,30V,TK0,GENERIC; room: NONE
EU1E2 EU8B1 EU8B4 = SLG55021: alternate symbols: (); part number: SLG55021_SM-G56246-001,IC,SLG55021,LPDB,GENERIC
EU2A7 = PS8409A: alternate symbols: (); part number: PS8409A_LCCA-J95788-001,IC,PS8409AQFN48GTR2-A2,LPDB,GENERIC; room: 60
EU2B1 = TPS62125: alternate symbols: (); part number: TPS62125_LCCV-G89337-001,IC,TPS62125,LPDB,GENERIC; room: 173
EU2G1 = RT8231: alternate symbols: (); part number: RT8231_SM-H41785-001,IC,RT8231,LPDB,GENERIC
EU2M1 EU3M1 EU3M2 EU4M1 = RT9637GQW_2: alternate symbols: (); part number: RT9637GQW_2_LCC-K39839-001,IC,RT9637GQW,TK0,GENERIC; room: NONE
EU3B4 EU4B5 = PI3EQX1004B1_2: alternate symbols: (); part number: PI3EQX1004B1_2_TQFN-K44226-001,IC,PI3EQX1004B1,TK0,GENERIC; room: NONE
EU4B1 = I219: alternate symbols: (); part number: I219_LCC-H29350-002,JACKSONVILLE,INJVA0-DT,LPDB,GENERIC; room: 92
EU4B2 EU6B3 U6A1-U6A3 U8A1 U8B1-U8B3 U8D2 U8G3 = SLG7NT402V: alternate symbols: (); part number: SLG7NT402V_SM-G54192-001,IC,SLG7NT402V,LPDB,GENERIC
EU4G2 EU6B2 EU8G2 = MOSFET_N_1D3S: alternate symbols: (); part number: MOSFET_N_1D3S_LCC5-J91717-001,IC,30V,LPDB,GENERIC
EU5A1 = TPS65988D: alternate symbols: (); part number: TPS65988D_LCC-K53306-001,IC,TPS65988DJRSHR,LPDB,GENERIC; room: 190
EU5B1 = CSD87350: alternate symbols: (); part number: CSD87350_LCC-G21163-001,IC,CSD87350,LPDB,GENERIC
EU5B2 = RT3601EAGQW_2: alternate symbols: (); part number: RT3601EAGQW_2_QFN-K41326-001,IC,RT3601EAGQW,TK0,GENERIC; room: NONE
EU5C2 EU5F1 = TLV6208X: alternate symbols: (); part number: TLV6208X_WSON-K23984-001,IC,TLV62084ADSGR,LPDB,GENERIC
EU5C3 EU5D2 = RT6541A: alternate symbols: (); part number: RT6541A_WDFN-H93593-001,IC,RT6541A,LPDB,GENERIC
EU5C4 EU5D3 = CSD87330: alternate symbols: (); part number: CSD87330_SON-G53132-001,IC,LPDB,GENERIC
EU5G1 = MOSFET_N_1D3S: alternate symbols: (); part number: MOSFET_N_1D3S_LCC-J83030-001,IC,30V,LPDB,GENERIC
EU5G2 = MOSFET_N_1D3S: alternate symbols: (); part number: MOSFET_N_1D3S_LCC-J83273-001,IC,30V,LPDB,GENERIC
EU5G3 = RT8237FZQW_2: alternate symbols: (); part number: RT8237FZQW_2_LCC-K39831-001,IC,RT8237FZQW,TK0,GENERIC; room: NONE
EU6A1 = ALC711: alternate symbols: (); part number: ALC711_LCC-J90526-001,IC,ALC711,LPDB,GENERIC; room: 105
EU6A2 = TPS54623: alternate symbols: (); part number: TPS54623_LCC-G60293-001,IC,TPS54623RHLR,LPDB,GENERIC
EU6B1 = SLG55021: alternate symbols: (); part number: SLG55021_SM-G56246-001,IC,SLG55021,LPDB,GENERIC; room: 175
EU6D1 = TUSB1042I_2: alternate symbols: (); part number: TUSB1042I_2_QFN-K44933-001,IC,TUSB1042IRNQR,TK0,GENERIC; room: NONE
EU7A1 EU7A2 = ESD1014: alternate symbols: (); part number: ESD1014_LCC-H33233-001,IC,ESD1014MUTAG,LPDB,GENERIC
EU7A3 = FOXVILLE_IP: alternate symbols: (); part number: FOXVILLE_IP_QFN-J76978-002,IC,FOXVILLE_IP,1.1,LPDB,GENERIC
EU7G3 = W25R256FV: alternate symbols: (); part number: W25R256FV_LCC-J57782-001,IC,W25R256FVEIQ,LPDB,GENERIC; room: 119
EU7H1 = SN74AVC4T774: alternate symbols: (); part number: SN74AVC4T774_QFNV-E57797-001,IC,SN74AVC4T774,LPDB,GENERIC
EU8F1 = SLG7NT4198V: alternate symbols: (); part number: SLG7NT4198V_LCC-H14587-001,IC,SLG7NT4198V,LPDB,GENERIC
EU8F2 EU8G1 = RT8068A: alternate symbols: (); part number: RT8068A_LCC-H33755-001,IC,RT8068AZQW,LPDB,GENERIC
EU8G3 = SN74AVC4T774: alternate symbols: (); part number: SN74AVC4T774_QFNV-E57797-001,IC,SN74AVC4T774,LPDB,GENERIC; room: 121
EU8H1 = SLG7NT4082: alternate symbols: (); part number: SLG7NT4082_LCC-G75552-001,IC,SLG7NT4082V,LPDB,GENERIC; room: 202
EU8H2 = SLG7NT4084: alternate symbols: (); part number: SLG7NT4084_LCC-G74376-001,IC,SLG7NT4084,LPDB,GENERIC; room: 202
EU9E1 = W25R256FV: alternate symbols: (); part number: W25R256FV_LCC-J57782-001,IC,W25R256FVEIQ,LPDB,GENERIC; room: 128
F3A1 F6C1 RT3A1 RT4A1 RT6B1 = FUSE: alternate symbols: (); part number: FUSE_SM-C92281-012,FUSE,2.0A,6.0V,LPDB,GENERIC; room: USB_OUT
F6G1-F6G3 = FUSE: alternate symbols: (); part number: FUSE_SM-H54742-001,EMPTY,1A,6V,LPDB,GENERIC
FB2L1 FB3L1 = FERRITE: alternate symbols: (); part number: FERRITE_0402-A51464-011,FB,120OHM,25%,1.5A,LPDB,GENERIC; room: LSPCON_CHIP
FB2L2 = FERRITE: alternate symbols: (); part number: FERRITE_0603-693286-057,FB,330,25%,1.5A,LPDB,GENERIC; room: 60
FB3A1 FB3A2 FB5A1 FB5A4 FB6A2 = FERRITE: alternate symbols: (); part number: FERRITE_0603-H15756-001,FERRITE,120OHM,25%,3A,LPDB,GENERIC; room: COMBO_JACK
FB5A2 FB5A3 = FERRITE: alternate symbols: (); part number: FERRITE_0603-693286-001,CHIP,60OHM,25%,500MA,LPDB,GENERIC; room: 107
FB5A5 FB5A6 = FERRITE_2: alternate symbols: (); part number: FERRITE_2_0805-656554-069,FERRITE,21,30%,6A,TK0,GENERIC; room: NONE
FB6A1 = FERRITE: alternate symbols: (); part number: FERRITE_0805-656554-046,FERRITE BEAD,30OHM,10OHM,3A,LPDB,GENERIC; room: 174
FB6J1 = FERRITE: alternate symbols: (); part number: FERRITE_0603-693286-001,EMPTY,60OHM,25%,500MA,LPDB,GENERIC
FB9B1 FB9B2 FB9C1 FB9C2 = FERRITE: alternate symbols: (); part number: FERRITE_0603-693286-001,CHIP,60OHM,25%,500MA,LPDB,GENERIC; room: 129
ISO2B1-ISO2B5 ISO2C1 ISO2D1-ISO2D4 ISO3B1-ISO3B8 ISO4B1-ISO4B4 ISO5G1 ISO6L1 ISO6L2 ISO17528 ISO17599 = GND_ISOLATION: alternate symbols: (); part number: GND_ISOLATION_SM-EMPTY,NA_14972,GND_ISO,LPDB,GENERIC
J1A1 = HDR_2X4: alternate symbols: (); part number: HDR_2X4_THMTA-A91854-021,CON,HDR_2X4,LPDB,GENERIC; room: 160
J1A2 = HDR_2X4: alternate symbols: (); part number: HDR_2X4_THMTA-J61784-001,EMPTY,87427-0802,LPDB,GENERIC; room: 160
J1A3 = PWR_2X2: alternate symbols: (); part number: PWR_2X2_THLF-A91848-001,EMPTY,PWR_2X2,LPDB,GENERIC; room: 160
J1A4 J1D9 J8J1 J8J8 J8J12 J9A3 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC
J1B1 J1D1 J1D2 J1D4 J1E1 J2A2 J4J1-J4J4 J7D2 J7D3 J7J3 J8H3 J8H4 J8J4 J9A1 J9A2 J9E1-J9E5 J9E7 J9E8 J9F2-J9F4 J9G1 J9G2 J9G5-J9G8 J9J4 J9J5 = HDR_1X2_2: alternate symbols: (); part number: HDR_1X2_2_THMT-A91829-020,CONN,HDR_1X2,TK0,GENERIC; room: NONE
J1B2 = HDR_1X44_11EM_2M_EDP_2: alternate symbols: (); part number: HDR_1X44_11EM_2M_EDP_2_SM-K44147-001,CONN,HDR_1X44_11EM_2M_EDP,TK0,GENERIC; room: NONE
J1C1 = XDP_2X30A: alternate symbols: (); part number: XDP_2X30A_SM-C21100-002,CONN,XDP_2X30A,LPDB,GENERIC
J1E3 J9C1 = HDR_1X4: alternate symbols: (); part number: HDR_1X4_TH-C74770-001,HDR,HDR_1X4,LPDB,GENERIC; room: FAN_CNTL
J1E5 = DDR4_4X72: alternate symbols: (); part number: DDR4_4X72_THM-G96281-001,IC,DDR4_4X72,LPDB,GENERIC; room: 25
J1F1 = DDR4_4X72: alternate symbols: (); part number: DDR4_4X72_THM-G96281-001,IC,DDR4_4X72,LPDB,GENERIC; room: 23
J1F2 = DDR4_4X72: alternate symbols: (); part number: DDR4_4X72_THM-G96281-001,IC,DDR4_4X72,LPDB,GENERIC; room: 29
J1F3 = DDR4_4X72: alternate symbols: (); part number: DDR4_4X72_THM-G96281-001,IC,DDR4_4X72,LPDB,GENERIC; room: 27
J1G3 J1G5 = HDR_2X2: alternate symbols: (); part number: HDR_2X2_THMT-C77978-002,IO,HDR_2X2,LPDB,GENERIC
J1G4 = HDR_2X2: alternate symbols: (); part number: HDR_2X2_THMT-C77978-002,IO,HDR_2X2,LPDB,GENERIC; room: 198
J2A1 = DP_HDMI_2STK_19P_20P_4M: alternate symbols: (); part number: DP_HDMI_2STK_19P_20P_4M_TH-G98281-001,CONN,DP_HDMI_2STK_19P_20P_4M,LPDB,GENERIC
J3A1 = USB_4STACK_26P_6M: alternate symbols: (); part number: USB_4STACK_26P_6M_TH-J51263-001,CONN,USB_4STACK_26P_6M,LPDB,GENERIC; room: 79
J3A2 = HDMI_SHLD_A_19P_4M: alternate symbols: (); part number: HDMI_SHLD_A_19P_4M_SMTB-D58558-001,HDMI,HDMI_SHLD_19P_4M,LPDB,GENERIC
J3D1 = CML_S_IP_EXT: alternate symbols: (); part number: CML_S_IP_EXT_LGA-NA_58785,SOC,CML_S_IP_EXT,0.9,LPDB,IP; room: NONE
J4A1 = USB3_C_SHLD_24P_6M: alternate symbols: (); part number: USB3_C_SHLD_24P_6M_SMT-J40583-001,CON,USB3_C_SHLD_24P_6M,LPDB,GENERIC
J4A2 = RJ45_2USB3_2LED_32P_8M: alternate symbols: (); part number: RJ45_2USB3_2LED_32P_8M_TH-J49312-001,CONN,RJ45_2USB3_2LED_32P_8M,LPDB,GENERIC; room: 82
J4G1 = PWR_2X12: alternate symbols: (); part number: PWR_2X12_ATX-E44295-002,CON,7943131-3,LPDB,GENERIC; room: 160
J4H1 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC; room: 217
J4R1 = LAI_PCIE3_X8_MIDBUS: alternate symbols: (); part number: LAI_PCIE3_X8_MIDBUS_SM-NA_480,EMPTY,LAI_PCIE3_X8_MIDBUS,LPDB,GENERIC; room: 22
J5A1 = AUDIO_4POLE_8P: alternate symbols: (); part number: AUDIO_4POLE_8P_THMT-J51108-001,CONN,AUDIO_4POLE_8P,LPDB,GENERIC; room: 107
J5B1 = HDR_2X3A: alternate symbols: (); part number: HDR_2X3A_THMT-G29882-002,HDR,HDR_2X3A,LPDB,GENERIC; room: 203
J5B2 = PCIEX16_4X41: alternate symbols: (); part number: PCIEX16_4X41_TH-E14523-001,IO,PCIEX16_4X41,LPDB,GENERIC
J5B3 = PCIEX4_2X37_2M: alternate symbols: (); part number: PCIEX4_2X37_2M_SM-H17033-001,SCONN,PCIEX4_2X37_2M,LPDB,GENERIC; room: 51
J5D1 = STANDOFF: alternate symbols: (M_2_MTG_7000P4320MA); part number: STANDOFF_TH-H18839-001,EMPTY,STANDOFF,LPDB,GENERIC; room: 51
J5E1 = STANDOFF: alternate symbols: (M_2_MTG_7000P4320MA); part number: STANDOFF_TH-H18839-001,STANDOFF,STANDOFF,LPDB,GENERIC; room: 51
J5H1 = SAS_HD_3X9P_2M: alternate symbols: (); part number: SAS_HD_3X9P_2M_THMT-J51101-001,CONN,SAS_HD_3X9P_2M,LPDB,GENERIC; room: 98
J5J1 = SHDR_2X10: alternate symbols: (); part number: SHDR_2X10_SM-H33741-001,HDR,SHDR_2X10,LPDB,GENERIC
J5J2 = SATA_1X22_2E_A: alternate symbols: (); part number: SATA_1X22_2E_A_SM-C47552-002,CON,SATA_1X22_2E,LPDB,GENERIC; room: 96
J6B1 = HDR_2X10_SPI_TPM: alternate symbols: (); part number: HDR_2X10_SPI_TPM_TH-G23263-001,CON,HDR_2X10_SPI_TPM,LPDB,GENERIC; room: 192
J6B2 = STANDOFF: alternate symbols: (M_2_MTG_7000P4320MA); part number: STANDOFF_TH-H18839-001,STANDOFF,STANDOFF,LPDB,GENERIC; room: 90
J6B5 = USB3_UA_SHLD_9P_4M: alternate symbols: (); part number: USB3_UA_SHLD_9P_4M_TH-J51104-001,CONN,USB3_UA_SHLD_9P_4M,LPDB,GENERIC; room: 87
J6C3 = USB3P1_HDR_2X10_6M_GEN2_A: alternate symbols: (); part number: USB3P1_HDR_2X10_6M_GEN2_A_SM-J51302-001,CONN,USB3P1_HDR_2X10_6M_GEN2_A,LPDB,GENERIC; room: 84
J6C4 = USB3P1_C_24P_6M: alternate symbols: (); part number: USB3P1_C_24P_6M_SM-J25330-001,CONN,USB3P1_C_24P_6M,LPDB,GENERIC; room: 86
J6G1 = SATA_1X7_2M: alternate symbols: (); part number: SATA_1X7_2M_TH-E82125-001,SATA,SATA_1X7_2M,LPDB,GENERIC; room: 97
J6G2 J6H1 = SATA_1X7_2M: alternate symbols: (); part number: SATA_1X7_2M_TH-E82125-001,SATA,SATA_1X7_2M,LPDB,GENERIC; room: 96
J6H2 = XDP_2X30A: alternate symbols: (); part number: XDP_2X30A_SM-C21100-002,CONN,XDP_2X30A,LPDB,GENERIC; room: 132
J6J1 = HDR_2X10: alternate symbols: (); part number: HDR_2X10_TH-J51264-001,CONN,HDR_2X10,LPDB,GENERIC
J6J2 = CON_SEAF_8X30: alternate symbols: (); part number: CON_SEAF_8X30_SMTA-G88091-001,SKT,CON_SEAF_8X30,LPDB,GENERIC
J7A1 = RJ45_SHLD_12P_2LED_2M: alternate symbols: (); part number: RJ45_SHLD_12P_2LED_2M_THMT-J89609-001,CONN,RJ45_SHLD_12P_2LED_2M,LPDB,GENERIC
J7A2 = HDR_2X5: alternate symbols: (); part number: HDR_2X5_TH-H86632-001,CONN,HDR_2X5,LPDB,GENERIC
J7B1 = PCIE_64: alternate symbols: (); part number: PCIE_64_THMT-C35285-018,IC,PCIE__64_X4,LPDB,GENERIC; room: 101
J7C1 = PCIE_75P_KEYE_2M_HYBRID: alternate symbols: (); part number: PCIE_75P_KEYE_2M_HYBRID_SM-J51110-001,CONN,PCIE_75P_KEYE_2M_HYBRID,LPDB,GENERIC; room: 90
J7C2 J7C3 = CON_1X2_2M: alternate symbols: (); part number: CON_1X2_2M_SM-J67963-001,SCONN,CON_1X2_2M,LPDB,GENERIC
J7C7 = CON_2X5_K2: alternate symbols: (); part number: CON_2X5_K2_THMT-A91836-003,CONN,CON_2X5_K2,LPDB,GENERIC; room: 88
J7C9 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-D64787-001,HDR,HDR_1X3,LPDB,GENERIC
J7G1 = HDR_2X25_K29_K30_K31: alternate symbols: (); part number: HDR_2X25_K29_K30_K31_SM-K18833-001,CONN,HDR_2X25_K29_K30_K31,LPDB,GENERIC
J7G2 = HDR_2X10_K1: alternate symbols: (); part number: HDR_2X10_K1_SMT-G25403-002,EMPTY,HDR_2X10_K1,LPDB,GENERIC; room: 120
J7H1 = CON_2X5_2M: alternate symbols: (); part number: CON_2X5_2M_SM-A95918-003,EMPTY_KOZ1,CON_2X5_2M,LPDB,GENERIC; room: 202
J7J1 = HDR_2X14_K4_K21_K22: alternate symbols: (); part number: HDR_2X14_K4_K21_K22_SMT-H46981-001,HDR,HDR_2X14_K4_K21_K22,LPDB,GENERIC
J7J4 = HDR_1X5: alternate symbols: (); part number: HDR_1X5_THMT-C70742-003,EMPTY,HDR_1X5,LPDB,GENERIC
J7J6 = CONN_2DIN_12P_5M: alternate symbols: (); part number: CONN_2DIN_12P_5M_THMT-A92011-001,CONN,PS2_STACK,LPDB,GENERIC; room: SIO_PS2KEYMOUSE
J8B1 = PCIE_64: alternate symbols: (); part number: PCIE_64_THMT-C35285-018,IC,PCIE__64_X4,LPDB,GENERIC; room: 100
J8H1 = PCIEX4_2X37_2M: alternate symbols: (); part number: PCIEX4_2X37_2M_SM-H17033-001,SCONN,PCIEX4_2X37_2M,LPDB,GENERIC; room: 93
J8H2 = HDR_2X30_4M: alternate symbols: (); part number: HDR_2X30_4M_SM-E21540-001,CON,HDR_2X30_4M,LPDB,GENERIC
J8H5 = HDR_1X4: alternate symbols: (); part number: HDR_1X4_TH-A91829-005,HDR,HDR_1X4,LPDB,GENERIC; room: 91
J8H6 = HDR_1X4: alternate symbols: (); part number: HDR_1X4_TH-A91829-005,HDR,HDR_1X4,LPDB,GENERIC; room: 96
J8J2 = HDR_1X3_K2: alternate symbols: (); part number: HDR_1X3_K2_THMT-A91829-017,CONN,HDR_1X3_K2,LPDB,GENERIC; room: 138
J8J3 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC; room: 46
J8J5 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC; room: 204
J8J6 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC; room: 196
J8J7 J8J10 J8J11 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC; room: 201
J8J9 = HDR_1X3_2: alternate symbols: (); part number: HDR_1X3_2_THMT-C95678-006,CONN,HDR_1X3,TK0,GENERIC; room: NONE
J8J13 = HDR_2X20: alternate symbols: (); part number: HDR_2X20_TH-A80568-014,CONN,HDR_2X20,LPDB,GENERIC; room: 205
J9A4 = HDR_2X8_K12: alternate symbols: (); part number: HDR_2X8_K12_TH-A91836-050,HDR,HDR_2X8_K12,LPDB,GENERIC; room: 109
J9A5 = HDR_2X6: alternate symbols: (); part number: HDR_2X6_THMT-G19802-001,CONN,HDR_2X6,LPDB,GENERIC; room: 109
J9B1 = HDR_2X4A: alternate symbols: (); part number: HDR_2X4A_TH-A91836-070,CONN,HDR_2X4A,LPDB,GENERIC; room: 109
J9B2 J9B3 = HDR_1X4: alternate symbols: (); part number: HDR_1X4_TH-A91829-005,HDR,HDR_1X4,LPDB,GENERIC
J9B4 = HDR_2X3A: alternate symbols: (); part number: HDR_2X3A_THMT-G29882-002,HDR,HDR_2X3A,LPDB,GENERIC; room: 109
J9B5 J9B6 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC; room: 129
J9B7 = HDR_2X5_K10: alternate symbols: (); part number: HDR_2X5_K10_TH-A91836-073,CONN,HDR_2X5_K10,LPDB,GENERIC
J9D1 = MICROSD_10P_4M: alternate symbols: (); part number: MICROSD_10P_4M_PCCG-D68394-006,CON,MICROSD_10P_4M,LPDB,GENERIC; room: 99
J9D2 = HDR_1X10: alternate symbols: (); part number: HDR_1X10_SM-G70133-001,CONN,HDR_1X10,LPDB,GENERIC; room: 140
J9D3 J9J1 = HDR_2X3A: alternate symbols: (); part number: HDR_2X3A_THMT-G29882-002,HDR,HDR_2X3A,LPDB,GENERIC
J9D4 = CON_1X5_FPC: alternate symbols: (); part number: CON_1X5_FPC_SM-G96121-001,HDR,CON_1X5_FPC,LPDB,GENERIC; room: 108
J9D5 J9H2 = HDR_2X4A: alternate symbols: (); part number: HDR_2X4A_TH-A91836-070,CONN,HDR_2X4A,LPDB,GENERIC
J9E6 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC; room: 45
J9E9 = HDR_2X10_SPI_TPM: alternate symbols: (); part number: HDR_2X10_SPI_TPM_TH-G23263-001,CON,HDR_2X10_SPI_TPM,LPDB,GENERIC; room: 128
J9F5 = HDR_1X5: alternate symbols: (); part number: HDR_1X5_THMT-A91829-006,IC,HDR_1X5,LPDB,GENERIC; room: 130
J9F6 = HDR_1X3: alternate symbols: (); part number: HDR_1X3_THMT-A91829-001,IC,HDR_1X3,LPDB,GENERIC; room: 199
J9H1 = HDR_2X5_K10: alternate symbols: (); part number: HDR_2X5_K10_TH-A91836-073,CONN,HDR_2X5_K10,LPDB,GENERIC; room: 138
J9H3 = HDR_2X4_K7: alternate symbols: (); part number: HDR_2X4_K7_THMT-A91836-079,IO,HDR_2X4_K7,LPDB,GENERIC; room: 131
J9H4 = HDR_2X3A: alternate symbols: (); part number: HDR_2X3A_THMT-G29882-002,HDR,HDR_2X3A,LPDB,GENERIC; room: 112
J9J2 = HDR_2X4A: alternate symbols: (); part number: HDR_2X4A_TH-A91836-070,CONN,HDR_2X4A,LPDB,GENERIC; room: 112
L2A1-L2A4 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_0504-G54554-001,CHIP,90OHM,20%,150MA,LPDB,GENERIC; room: 61
L2B1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_4040-652666-107,IND,22UH,20%,0.72A,LPDB,GENERIC; room: 173
L2B2 L2B3 L2D1 L2D2 L3B3 L3B4 L4B3 L4B4 = INDUCTOR_POL: alternate symbols: (); part number: INDUCTOR_POL_TH-D86383-002,IND,0.220 UH,10%,40A,LPDB,GENERIC
L2G1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_SM-H38521-001,INDUCTOR,0.3UH,20%,21A,LPDB,GENERIC; signal model: DEFAULT_INDUCTOR_300.000000nH_1_2
L3A1 U1B3-U1B6 U3A1-U3A3 U6D6 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM3-J16541-001,CHOKE,90OHM,NA,100MA,LPDB,GENERIC
L3A2-L3A5 L6C3 L6C4 L6D1 LP4A1 LP4A2 LP7C1-LP7C3 = IND_4PIN: alternate symbols: (); part number: IND_4PIN_0805-752402-015,CHOKE,90OHM,NA,0.4A,LPDB,GENERIC; room: SB_USB
L3A6 L3A7 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM3-J16541-001,CHOKE,90OHM,NA,100MA,LPDB,GENERIC; room: 81
L3B1 L3B2 = INDUCTOR_POL: alternate symbols: (); part number: INDUCTOR_POL_TH-D86383-002,IND,0.220 UH,10%,40A,LPDB,GENERIC; room: 171
L4A1 L4A2 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM3-J16541-001,CHOKE,90OHM,NA,100MA,LPDB,GENERIC; room: 78
L4B1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_SM-652666-093,INDUCTOR,4.7UH,20%,0.8A,LPDB,GENERIC; room: 92
L4B2 = INDUCTOR_2: alternate symbols: (); part number: INDUCTOR_2_SM-E13358-034,IND,0.47UH,20%,26A,TK0,GENERIC; room: NONE
L4C1 L5D1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_SM-H49381-001,IND,0.60UH,20%,11.7A,LPDB,GENERIC
L5A1 = IND_4PIN: alternate symbols: (); part number: IND_4PIN_0805-752402-015,CHOKE,90OHM,NA,0.4A,LPDB,GENERIC
L5A2 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_SM-E85495-002,IND,0.6UH,20%,6.5A,LPDB,GENERIC
L5C1 L5F1 L8D1 L8E1-L8E3 L8F1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_2520-G83372-016,IND,1UH,20%,3.2A,LPDB,GENERIC
L5G1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_SM-H96486-002,IND,0.56UH,20%,22A,LPDB,GENERIC
L6A1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_SM-G72017-003,IND,2.2UH,20%,9.7A,LPDB,GENERIC
L6C1 = IND_4PIN: alternate symbols: (); part number: IND_4PIN_0805-752402-015,EMPTY,90OHM,NA,0.4A,LPDB,GENERIC; room: 87
L6C2 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM3-J16541-001,CHOKE,90OHM,NA,100MA,LPDB,GENERIC; room: 87
L6D2 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM3-J16541-001,CHOKE,90OHM,NA,100MA,LPDB,GENERIC; room: 85
L6D3 L6D4 L6F1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_0805-721891-049,EMPTY,2.2UH,20%,260MA,LPDB,GENERIC
L6G1-L6G3 U5W1 = CHOKE_4P: alternate symbols: (); part number: CHOKE_4P_SM2-H90672-001,EMPTY,80OHM,NA,50MA,LPDB,GENERIC
L7B1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_2016-H90826-001,INDUCTOR,1UH,20%,3.9A,LPDB,GENERIC
L8F2 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_SM-E76685-026,IND,1.5UH,20%,7.5A,LPDB,GENERIC
L8G1 = INDUCTOR: alternate symbols: (); part number: INDUCTOR_SM-E76684-007,INDUCTOR,2.2UH,20%,5.5A,LPDB,GENERIC
LB5G1 = LABEL_JEDEC_B4: alternate symbols: (); part number: LABEL_JEDEC_B4_SMT-NA_37329,EMPTY,LABEL_JEDEC_B4,LPDB,GENERIC; room: 147
LB5G2 = LABEL_JEDEC_E1: alternate symbols: (); part number: LABEL_JEDEC_E1_SMT-NA_37330,EMPTY,LABEL_JEDEC_E1,LPDB,GENERIC; room: 147
LB6H1 = LABEL_PBF_2LI: alternate symbols: (); part number: LABEL_PBF_2LI_SMT-NA_37328,EMPTY,LABEL_PBF_2LI,LPDB,GENERIC; room: 147
M7J1 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC; room: 195
MH1B1 MH1F1 MH1H1 MH5A1 MH5F1 MH5H1 MH7A1 MH9A1 MH9F1 MH9H1 = STD_MTG_HOLE_PCCG: alternate symbols: (); part number: STD_MTG_HOLE_PCCG_TH-G39082-001,EMPTY,STF_MTG_HOLE,LPDB,GENERIC
Q1A1 = FET: alternate symbols: (); part number: FET_SM-C81974-001,IC,LPDB,GENERIC; room: 62
Q1B1 = MOSFET_N_1D2S: alternate symbols: (); part number: MOSFET_N_1D2S_BGA-G65949-001,MOSFET_N_1D2S,,LPDB,GENERIC
Q1C1 Q4G4 Q7H2 Q7H3 Q8C14 Q8G1 Q8G4 Q8G7 = MOSFET_P: alternate symbols: (); part number: MOSFET_P_SOT23-D32396-001,FET,FDN306P,LPDB,GENERIC
Q1C2 Q1C3 Q2A1 Q8C15 Q8D7 Q8D8 = FET: alternate symbols: (); part number: FET_SM-C81974-001,IC,LPDB,GENERIC
Q2A2 = MOSFET_N_1D2S: alternate symbols: (); part number: MOSFET_N_1D2S_BGA-G65949-001,MOSFET_N_1D2S,,LPDB,GENERIC; room: 62
Q2A3-Q2A8 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT723-E19905-001,FET,2SK3541T2L,LPDB,GENERIC; room: 59
Q2G1 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT23-C52261-001,MOSFET,MGSF1N02LT1G,LPDB,GENERIC; room: 179
Q3G2 = MOSFET_N_DUAL: alternate symbols: (); part number: MOSFET_N_DUAL_SOT363-H10119-001,NFET,2N7002PS,LPDB,GENERIC; room: 160
Q3G3 Q5B1 Q5D2 Q5E3 Q6C1 Q6G1 Q6G2 Q6L1 Q6T1 Q6T2 Q7B2 Q7B3 Q7B5-Q7B10 Q8C1-Q8C6 Q8C8 Q8D5 Q8D6 Q8D9 Q8D11 Q8D12 Q8E1-Q8E5 Q8E8-Q8E10 Q8F1 Q8G2 Q8G3 Q8G8 Q9G4 = FET: alternate symbols: (); part number: FET_SM-C81974-001,IC,LPDB,GENERIC; room: ICH
Q4G1 Q8C7 Q8C13 = MOSFET_N_DUAL: alternate symbols: (); part number: MOSFET_N_DUAL_SOT363-H10119-001,NFET,2N7002PS,LPDB,GENERIC; room: 182
Q4G2 Q5C1 Q6A3 Q6A4 = MOSFET_P_3S: alternate symbols: (); part number: MOSFET_P_3S_LCC-J91596-001,FET,-20V,LPDB,GENERIC
Q4G3 = MOSFET_P: alternate symbols: (); part number: MOSFET_P_SOT23-D32396-001,FET,FDN306P,LPDB,GENERIC; room: 181
Q4H1 Q7G2 = NPN_DUAL: alternate symbols: (); part number: NPN_DUAL_SM-C52264-001,IC,MBT3904DW1T1,LPDB,GENERIC
Q4H2 = MOSFET_N_DUAL: alternate symbols: (); part number: MOSFET_N_DUAL_SOT363-H10119-001,NFET,2N7002PS,LPDB,GENERIC; room: 175
Q4H3 = NPN_DUAL: alternate symbols: (); part number: NPN_DUAL_SM-C52264-001,IC,MBT3904DW1T1,LPDB,GENERIC; room: 178
Q4H4 = PNP: alternate symbols: (); part number: PNP_SM-H95117-001,IC,MMBT3640,LPDB,GENERIC; room: 178
Q4H5 = NPN: alternate symbols: (); part number: NPN_SM-C52245-001,IC,MBT3904,LPDB,GENERIC; room: 178
Q4J1 = NPN: alternate symbols: (); part number: NPN_SM-C52245-001,IC,MBT3904,LPDB,GENERIC; room: 179
Q5C2-Q5C4 Q5D1 Q5E1 Q5E2 Q6A1 Q6A2 Q7A1 Q7B1 Q8C9 Q8D1 = MOSFET_N_DUAL: alternate symbols: (); part number: MOSFET_N_DUAL_SOT363-H10119-001,NFET,2N7002PS,LPDB,GENERIC
Q5M1-Q5M4 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_LCC-J45297-001,MOSFET,DMN62D0LFB,LPDB,GENERIC
Q7B4 = MOSFET_P_3S: alternate symbols: (); part number: MOSFET_P_3S_LCC-J91596-001,FET,-20V,LPDB,GENERIC; room: 182
Q7C1 Q8C10 = MOSFET_N_DUAL: alternate symbols: (); part number: MOSFET_N_DUAL_SOT363-H10119-001,NFET,2N7002PS,LPDB,GENERIC; room: 183
Q7F1 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT723-E19905-001,FET,2SK3541T2L,LPDB,GENERIC
Q7G1 = FET: alternate symbols: (); part number: FET_SM-C81974-001,IC,LPDB,GENERIC; room: 118
Q7H1 = NPN_DUAL: alternate symbols: (); part number: NPN_DUAL_SM-C52264-001,IC,MBT3904DW1T1,LPDB,GENERIC; room: DEBUG
Q8A1 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT723-E19905-001,FET,2SK3541T2L,LPDB,GENERIC; room: 103
Q8B1 Q8B2 = NPN: alternate symbols: (); part number: NPN_SM-C52245-001,IC,MBT3904,LPDB,GENERIC; room: 110
Q8C11 = MOSFET_N_DUAL: alternate symbols: (); part number: MOSFET_N_DUAL_SOT363-H10119-001,NFET,2N7002PS,LPDB,GENERIC; room: 180
Q8C12 = NPN_DUAL: alternate symbols: (); part number: NPN_DUAL_SOT363-C21741-001,IC,BFS483,LPDB,GENERIC; room: 183
Q8D2 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT723-E19905-001,EMPTY,2SK3541T2L,LPDB,GENERIC; room: 176
Q8D3 Q8D4 Q8D10 = STM1061: alternate symbols: (); part number: STM1061_SOT23-E85472-001,IC,STM1061N30WX6F,LPDB,GENERIC
Q8D13 Q8D14 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT23-C52261-001,MOSFET,MGSF1N02LT1G,LPDB,GENERIC; room: 178
Q8E6 Q8E7 = FET: alternate symbols: (); part number: FET_SM-C81974-001,EMPTY,LPDB,GENERIC; room: ICH
Q8G5 Q8G6 = FET: alternate symbols: (); part number: FET_SM-C81974-001,IC,LPDB,GENERIC; room: 137
Q8H1 Q8H5 = PNP_NPN: alternate symbols: (); part number: PNP_NPN_SM-C81528-001,IC,MBT3946DW1T1G,LPDB,GENERIC
Q8H2 = FET: alternate symbols: (); part number: FET_SM-C81974-001,IC,LPDB,GENERIC; room: 95
Q8H3 Q8H4 Q8H6 Q8H7 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT723-E19905-001,EMPTY,2SK3541T2L,LPDB,GENERIC
Q9C1 Q9C2 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT23-H55332-001,IC,PMV40UN2,LPDB,GENERIC; room: 139
Q9F1 = MOSFET_N: alternate symbols: (); part number: MOSFET_N_SOT723-E19905-001,FET,2SK3541T2L,LPDB,GENERIC; room: 124
Q9G1-Q9G3 = FET: alternate symbols: (); part number: FET_SM-C81974-001,IC,LPDB,GENERIC; room: EC
Q9G5 = NPN: alternate symbols: (); part number: NPN_SM-C52245-001,IC,MBT3904,LPDB,GENERIC; room: CORE_PCSPKR
Q9G6 = MOSFET_N_DUAL: alternate symbols: (); part number: MOSFET_N_DUAL_SOT363-H10119-001,NFET,2N7002PS,LPDB,GENERIC; room: 137
R1A1 = RES: alternate symbols: (); part number: RES_0402-A93548-023,CHIP,1K,1%,1/16W,LPDB,GENERIC; room: DCL_VREG_PWR_CONN
R1A2 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC; room: VREG_PWR_CONN
R1A3 R8D86 R8D87 R8E14 R8E15 R8E37 R8E38 R8E49 R8E50 R8F3 R8F4 = RES: alternate symbols: (); part number: RES_0603-D71825-003,CHIP,0.01,0.5%,1/10W,LPDB,GENERIC
R1A4 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_1_2
R1A5 R1B6 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC; signal model: DEFAULT_RESISTOR_0.001OHM_1_2
R1A6 = RES: alternate symbols: (); part number: RES_0402-A93549-028,EMPTY,1M,5%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH
R1B1 R3G41 R4G19 R4G20 = RES_4TERM: alternate symbols: (); part number: RES_4TERM_4PAD-E41880-003,CHIP,0.002,1%,2W,LPDB,GENERIC; room: 160
R1B2 R1B11 R1B39 R1C10 R1C13 R1C14 R1C22-R1C25 R1C27-R1C30 R1C32 R1C34-R1C36 R1C40 R1C41 R1C43 R1C97 R1C99 R1C101 R1C102 R1D1 R1D10-R1D13 R1E3 R1E5 R1E7 R1E9-R1E14 R1E20-R1E22 R1E26-R1E30 R1E34 R1E36 R1E37 R1E40-R1E42 R1E46 R1F4 R1F16 R1F17 R1F31 R1F42 R1F51 R1P1-R1P4 R2A51 R2A55 R2A71 R2B1 R2B12 R2B18 R2B24 R2B25 R2B27 R2B32 R2C6 R2C25 R2E2 R2E5-R2E7 R2G14 R2G18 R2G20 R2G22 R2G26 R2G28 R2G29 R2G35 R2G36 R2M3-R2M6 R2M8 R3B1-R3B7 R3B16 R3B39 R3B43 R3H10-R3H12 R3H20 R3H24 R3H26 R3H34 R3H38 R3H40 R3H44 R3H45 R3M14-R3M20 R3M23 R4A2 R4A5 R4A6 R4C7 R4C9 R4C15 R4G1 R4H13-R4H20 R4H24 R4H32 R4H33 R4H36 R4H37 R4H40-R4H46 R4J9 R4L1 R4M11-R4M14 R4M16 R5A6 R5A21 R5A29 R5A32 R5A37 R5A39 R5A43 R5A54 R5A58 R5B2 R5B9-R5B12 R5B24 R5B41 R5B43 R5B59 R5B80 R5B82 R5C10 R5C19 R5C23-R5C25 R5C39 R5C40 R5C45 R5C49 R5C50 R5C55-R5C57 R5C60 R5D3 R5D9 R5D20 R5D22 R5D33 R5E7 R5E11 R5E18 R5E22 R5E27 R5E32 R5E33 R5E36 R5E38 R5E40 R5E58 R5F19 R5F20 R5G7 R5G12 R5G17 R5G18 R5G25 R5G33 R5H4 R5H6 R5J3 R5J8-R5J12 R5J14-R5J23 R5L2 R5L4 R5L7 R5L12 R5L24 R5L25 R5M16 R6A2 R6A5 R6A6 R6A10 R6A14 R6A20 R6A23 R6A25 R6A41 R6A48 R6A53 R6A64 R6A68 R6A80 R6A84 R6B15-R6B18 R6D8 R6D38 R6D41 R6D52 R6E3 R6E4 R6E6 R6E9 R6E11 R6E12 R6E14 R6E16 R6F6 R6F14 R6F20 R6F23 R6F26 R6F28 R6F31 R6F32 R6F36 R6G5 R6G6 R6G9 R6G10 R6H2-R6H5 R6H8 R6H34-R6H36 R6H41 R6H42 R6H44 R6J5 R6J24-R6J27 R6T7 R6T21 R6U1 R6U2 R6W1 R6W3 R7A1 R7A3 R7A7 R7B11 R7B15 R7B22 R7B56 R7B63 R7B68 R7C4 R7C5 R7C47 R7C48 R7D50 R7E2 R7E17 R7E36 R7E47 R7E56 R7F7 R7F16 R7F27 R7F36 R7F44-R7F46 R7F50 R7G22 R7G27-R7G32 R7H4-R7H7 R7H9-R7H13 R7H18 R7H47 R7H51 R7H64 R7H65 R7M1 R7M2 R7P1 R7R19 R7R58 R7T12 R7T16 R7W3 R8A12 R8A13 R8B7 R8B18 R8B41 R8C2 R8C31 R8C43 R8C72 R8D22 R8D57 R8D65 R8D69 R8D93 R8D95 R8D97 R8E5 R8E8 R8E17 R8E26 R8E28 R8E43 R8E44 R8E51 R8E55 R8E58 R8E61 R8E66 R8E68 R8F1 R8F7 R8F16-R8F18 R8F48 R8G1 R8G3 R8G4 R8G9 R8G13 R8G33 R8G41-R8G44 R8G70 R8G72 R8G73 R8H38 R8H42 R8H46 R8H52 R8J12-R8J14 R8J16 R8J18 R8J21 R8N1 R8N2 R9A5 R9A8 R9A10 R9A11 R9A14 R9A17 R9A20 R9B7 R9B11 R9B12 R9B15 R9B20 R9B21 R9B24 R9B25 R9B29 R9D34 R9D37 R9F1 R9F10 R9F18 R9F22 R9G7 R9G16 R9G32 = RES: alternate symbols: (); part number: RES_0402-A93549-001,CHIP,0,5%,1/16W,LPDB,GENERIC
R1B3 R5G1 R7B69 R7C41 R7H55 R8B20 R8B42 R8G66 R9G20 = RES: alternate symbols: (); part number: RES_0402-A93548-186,CHIP,200K,1%,1/16W,LPDB,GENERIC
R1B4 R1B20 R1B31 R1B34 R1C55 R1C70 R1C80 R1C96 R1D3 R2B8 R2C17 R2D1 R2G33 R3B29 R3B30 R4B22 R4G5 R4G8 R4L2 R5A7 R5A28 R5A40 R5A57 R5B23 R5B71 R5C18 R5C33 R5C48 R5E3 R5E10 R5G2 R5J4 R5L13 R5L17 R5L18 R5L22 R5V1-R5V8 R6A33 R6A37 R6A39 R6A42 R6A44 R6A45 R6A57 R6A59 R6A66 R6A72 R6A74 R6A76 R6A78 R6A79 R6A85 R6A87 R6B2 R6B5 R6B9 R6B21-R6B23 R6B35 R6D53 R6F7 R6F18 R6F25 R6F38-R6F40 R6H1 R6H19 R6H37 R6R1 R6T13 R6T15 R6T20 R6T22 R6W2 R7A5 R7B2 R7B7 R7B9 R7B10 R7B21 R7B34 R7B39 R7B67 R7C3 R7C42 R7C46 R7D6 R7D7 R7D16 R7G36 R7H1 R7H68 R7T13 R8A4 R8A8 R8A14 R8A18 R8B40 R8C77 R8C81 R8D14 R8D67 R8E33 R8E65 R8F12 R8F24 R8F27 R8F34 R8G11 R8G16 R8G19 R8G21 R8G56 R8G68 R8G78 R8H64 R8H76 R9D8 R9F13 R9F26 R9G6 R9G10 R9G18 R9G24 = RES: alternate symbols: (); part number: RES_0402-A93548-034,CHIP,10K,1%,1/16W,LPDB,GENERIC
R1B5 R1B14 R1B21 R1B36 R1B40 R1C2 R1C5 R1C6 R1C37 R1C74 R1C79 R1F9 R1F33 R1G5 R1G6 R1H2 R2B14 R2B35 R2B39 R2C7 R2C15 R2G21 R2G31 R2M7 R2M10 R2M11 R3B37 R3B38 R3M21 R3M22 R3M26-R3M29 R4B27 R4G2 R4M15 R4M18 R4M19 R5A5 R5A30 R5A52 R5A63 R5B1 R5B19 R5B56 R5B60 R5B64 R5B85 R5C11 R5C22 R5C28 R5C42 R5C43 R5C53 R5C54 R5C61 R5C62 R5C70 R5C71 R5D8 R5D21 R5D28 R5D30 R5E4 R5E12 R5E13 R5E17 R5E21 R5E28 R5E31 R5E34 R5E35 R5E37 R5E39 R5E59 R5F22 R5G6 R5G21 R5G23 R5L1 R5L11 R5M14 R6A1 R6A7 R6A8 R6A11 R6A12 R6A15-R6A17 R6A21 R6A22 R6A26 R6A27 R6A32 R6A35 R6A40 R6A52 R6D7 R6D9 R6D22 R6D39 R6D42 R6D45 R6D55 R6D56 R6E2 R6E5 R6E7 R6E8 R6E10 R6E13 R6E15 R6E17 R6F22 R6F24 R6H10 R6H13 R6H24 R6H28-R6H31 R6J12 R6J20 R6T9 R7A10-R7A13 R7B24 R7B26 R7B27 R7B32 R7B60 R7B61 R7C39 R7C40 R7D8 R7D9 R7E1 R7E53 R7E58 R7F29 R7F48 R7G25 R7H3 R7H8 R7R56 R7U3 R7W4 R8B15 R8C27 R8C51 R8C58 R8D74 R8D96 R8D98 R8D99 R8E54 R8E59 R8E60 R8F2 R8F19 R8F39 R8F71 R8G36 R8G71 R8H50 R9A6 R9A7 R9A16 R9A18 R9B6 R9B13 R9B14 R9B26 R9F2 R9F16 R9G29 R9G37 = RES: alternate symbols: (); part number: RES_0402-A93549-001,EMPTY,0,5%,1/16W,LPDB,GENERIC
R1B7 R1B16 R5A48 R5A50 R5A55 R5A64 R5B38 R5C35 R5C36 R5C58 R5C64 R5D16 R5D17 R5D32 R5D34 R5D35 R5D37 R5D38 R5D40 R5E56 R5L14 R5L20 R5L23 R6A36 R6A54 R6A56 R6A60 R6A65 R6A69 R6A70 R6A73 R7F33 R7G15 R7P9 R8F13-R8F15 R9F3 R9F5 R9F21 R9G3 = RES: alternate symbols: (); part number: RES_0402-A93548-128,CHIP,100K,1%,1/16W,LPDB,GENERIC
R1B8 R1B18 = RES: alternate symbols: (); part number: RES_0603-H10619-001,CHIP,10MOHM,1%,1/10W,LPDB,GENERIC
R1B9 = RES: alternate symbols: (); part number: RES_0402-A93548-187,CHIP,24.9K,1%,1/16W,LPDB,GENERIC; room: 171
R1B10 = RES: alternate symbols: (); part number: RES_0402-A93548-227,CHIP,11K,1%,1/16W,LPDB,GENERIC
R1B12 = RES: alternate symbols: (); part number: RES_0603-H10619-001,CHIP,10MOHM,1%,1/10W,LPDB,GENERIC; room: 171
R1B13 = RES: alternate symbols: (); part number: RES_0603-H10619-001,EMPTY,10MOHM,1%,1/10W,LPDB,GENERIC
R1B15 R1B43 R1C50 R1C51 R1C54 R1C56 R1C58 R1C60 R1C62 R1C66 R1C72 R1C77 R1C85 R1C88 R1C92 R1C93 R1C95 R1C98 R1E45 R1E47 R2G37 R2G40 R3B31 R3B32 R5A26 R5A42 R5A44 R5A46 R5A49 R5F10 R5G13 R5G19 R5L15 R6A38 R6A46 R6A47 R6A49 R6A51 R6A55 R6A61-R6A63 R6A86 R6A88 R6B6 R6B19 R6D48 R6F35 R6V1 R7B12 R7B33 R7B55 R7B84 R7C45 R7E57 R7G2 R7H54 R7R53 R7T7 R7T19 R7U19 R8B39 R8C1 R8C60 R8F32 R8F35 R8G29 R8G30 R8G45 R8G67 R8H43 R8H47 R8H51 R8H77 R9F14 R9F29 R9G14 = RES: alternate symbols: (); part number: RES_0402-A93548-034,EMPTY,10K,1%,1/16W,LPDB,GENERIC
R1B17 = RES: alternate symbols: (); part number: RES_0402-A93548-224,CHIP,45.3K,1%,1/16W,LPDB,GENERIC
R1B19 = RES: alternate symbols: (); part number: RES_0402-A93548-245,CHIP,24.3K,1%,1/16W,LPDB,GENERIC
R1B22 R1B23 R1B42 = RES: alternate symbols: (); part number: RES_0402-A93549-027,EMPTY,100K,5%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH
R1B24-R1B26 R1B28 R1B46 R1C1 = RES: alternate symbols: (); part number: RES_0402-G64084-070,CHIP,680,1%,1/16W,LPDB,GENERIC
R1B27 R1B30 R1B32 R1B33 R1B35 R1B37 R1B38 R1B41 R3A33 R6D19-R6D21 = RES: alternate symbols: (); part number: RES_0201-C80792-009,EMPTY,0,5%,1/20W,LPDB,GENERIC
R1B29 = RES: alternate symbols: (); part number: RES_0805-A93556-271,CHIP,2.2,1%,1/8W,LPDB,GENERIC; room: 169
R1B44 R2B36 R2C3 R2C12 R2C14 = RES: alternate symbols: (); part number: RES_0402-C17927-001,CHIP,0,1%,1/16W,LPDB,GENERIC
R1B45 R1B47 = RES: alternate symbols: (); part number: RES_0402-A93548-348,EMPTY,10K,1%,1/16W,LPDB,GENERIC
R1B48 R1B49 = RES: alternate symbols: (); part number: RES_0402-A93548-226,CHIP,499K,1%,1/16W,LPDB,GENERIC
R1C3 R5C34 = RES: alternate symbols: (); part number: RES_0402-A93548-384,CHIP,59K,1%,1/16W,LPDB,GENERIC
R1C4 R1C9 R2B21 R2C30 R4C1 R5B58 R5C41 R5C44 R5D23 R6J30 R7D26 R7H57 = RES: alternate symbols: (SMR0402_OCTO_IA); part number: RES_0402-A93548-043,CHIP,100,1%,1/16W,LPDB,GENERIC
R1C7 R2B60 = RES: alternate symbols: (); part number: RES_0402-A93548-551,CHIP,21.5K,1%,1/16W,LPDB,GENERIC
R1C8 R1C11 R1C17 R1C20 = RES: alternate symbols: (); part number: RES_0603-A93550-089,CHIP,2.49K,1%,1/10W,LPDB,GENERIC
R1C12 R1C48 R1D6 R1D9 R2B16 R2B17 R2B19 R2G6 R2G7 R2G11 R2M20 R3B40-R3B42 R3R1 R4B28 R4B29 R4G21 R5A20 R5B73 R5B88 R5B90 R5C59 R5D31 R5G10 R5G11 R6D31 R6D50 R6D63 R6F10 R6G2 R6G7 R6G12 R6H33 R6T14 R7B17 R7C37 R7C49 R7H63 R7H70 R7H71 R7R28 R7R32 R7R46 R7T2 R7T23 R8B14 R8B25 R8B34 R8G27 R9A4 R9A25 R9F31 R9G4 = RES: alternate symbols: (); part number: RES_0603-A93552-004,CHIP,0,5%,1/10W,LPDB,GENERIC
R1C15 = RES: alternate symbols: (); part number: RES_0402-A93549-027,EMPTY,100K,5%,1/16W,LPDB,GENERIC; room: DCL_CORE_GMCH; signal model: DEFAULT_RESISTOR_100000OHM_2_1
R1C16 R1C39 R3L1 R3M45 R4C13 R4C14 R4C27-R4C30 R5A16 R5A27 R5F11 R5G5 R6A9 R6A28 R6D33 R6D54 R6D58 R6D64 R6F13 R6H6 R6T8 R6T10 R6T16 R7C50 R7C51 R7E59 R7F10 R7F12 R7P5 R7P8 R7P11 R7P12 R7R1 R7R25-R7R27 R7R29-R7R31 R7R43-R7R45 R7T1 R7T5 R7T20 R7T21 R7T24 R8A10 R8B26 R8B29 R8B33 R8F49 R9A9 R9A19 R9F33 R9G2 = RES: alternate symbols: (); part number: RES_0603-A93552-004,EMPTY,0,5%,1/10W,LPDB,GENERIC
