# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R9C12  49.9K  [SMR0402IA]  17.9 206.12 0 top
R9C13  49.9K  [SMR0402IA]  20.19 206.12 0 top
R9C14  49.9K  [SMR0402IA]  12.31 205.36 270 top
R9C15  49.9K  [SMR0402IA]  14.35 205.36 270 top
R9C16  0  [SMR0402IA]  15.36 205.36 270 top
R9C17  49.9K  [SMR0402IA]  17.9 205.36 0 top
R9C18  10K  [SMR0402IA]  23.11 204.72 270 top
R9C19  22  [SMR0402IA]  24.51 202.31 180 top
R9C20  22  [SMR0402IA]  24.51 201.17 180 top
R9C21  0  [SMR0402IA]  24.51 200.02 180 top
R9C22  49.9K  [SMR0402IA]  23.62 198.88 0 top
R9D1  22  [SMR0402IA]  24.51 193.29 180 top
R9D2  22  [SMR0402IA]  24.51 192.28 180 top
R9D3  22  [SMR0402IA]  24.51 191.26 180 top
R9D4  0  [SMR0402IA]  12.44 185.55 0 top
R9D5  10  [SMR0402IA]  12.44 185.55 180 top
R9D6  10  [SMR0402IA]  12.44 184.4 180 top
R9D7  0  [SMR0402IA]  12.44 184.4 0 top
R9D8  10K  [SMR0402IA]  23.24 182.88 180 top
R9D9  100K  [SMR0402IA]  13.33 182.12 180 top
R9D10  10K  [SMR0402IA]  14.85 182.12 0 top
R9D11  0  [SMR0402IA]  22.35 181.74 0 top
R9D12  0  [SMR0402IA]  20.7 181.1 180 top
R9D13  100K  [SMR0402IA]  12.44 180.97 0 top
R9D14  10K  [SMR0402IA]  15.74 180.97 180 top
R9D15  0  [SMR0402IA]  17.27 180.97 0 top
R9D16  0  [SMR0402IA]  20.7 180.21 180 top
R9D17  0  [SMR0402IA]  21.46 179.45 180 top
R9D18  0  [SMR0402IA]  22.22 179.45 0 top
R9D19  0  [SMR0402IA]  17.27 179.2 0 top
R9D20  10  [SMR0402IA]  17.27 179.2 180 top
R9D21  10K  [SMR0402IA]  17.27 178.18 0 top
R9D22  49.9K  [SMR0402IA]  14.6 176.91 180 top
R9D23  0  [SMR0402IA]  18.16 176.91 180 top
R9D25  0  [SMR0402IA]  12.82 175.89 0 top
R9D26  0  [SMR0402IA]  14.6 175.89 180 top
R9D27  49.9K  [SMR0402IA]  17.27 175.26 0 top
R9D28  10  [SMR0402IA]  13.71 174.88 0 top
R9D29  49.9K  [SMR0402IA]  17.27 174.37 0 top
R9D30  10  [SMR0402IA]  13.71 173.86 0 top
R9D32  10K  [SMR0402IA]  13.33 169.04 90 top
R9D33  0  [SMR0402IA]  14.47 169.04 90 top
R9D34  0  [SMR0402IA]  15.49 169.04 90 top
R9D35  200K  [SMR0402IA]  13.33 167.77 270 top
R9D36  0  [SMR0402IA]  15.62 166.88 180 top
R9D37  0  [SMR0402IA]  18.28 166.88 180 top
R9D38  0  [SMR0402IA]  15.62 165.61 180 top
R9D39  0  [SMR0402IA]  17.39 165.61 0 top
R9D40  0  [SMR0402IA]  15.62 164.21 180 top
R9D41  0  [SMR0402IA]  17.39 164.21 0 top
R9E1  1K  [SMR0402IA]  11.93 158.62 180 top
R9E2  10K  [SMR0402IA]  13.84 157.61 0 top
R9E3  10K  [SMR0402IA]  17.14 157.61 180 top
R9E4  10K  [SMR0402IA]  13.84 156.46 0 top
R9E5  10K  [SMR0402IA]  17.14 156.46 180 top
R9E6  10K  [SMR0402IA]  11.81 155.32 180 top
R9E7  10K  [SMR0402IA]  13.84 155.32 0 top
R9E8  10K  [SMR0402IA]  17.14 155.32 180 top
R9E9  10K  [SMR0402IA]  13.84 154.18 0 top
R9E10  10K  [SMR0402IA]  17.14 154.18 180 top
R9E11  301  [SMR0402IA]  10.92 152.4 0 top
R9E12  10K  [SMR0402IA]  13.84 153.03 0 top
R9E13  10K  [SMR0402IA]  17.14 153.03 180 top
R9E14  1K  [SMR0402IA]  10.92 153.92 0 top
R9E15  10K  [SMR0402IA]  13.84 151.89 0 top
R9E16  10K  [SMR0402IA]  17.14 151.89 180 top
R9E17  10K  [SMR0402IA]  13.84 150.75 0 top
R9E18  10K  [SMR0402IA]  17.14 150.75 180 top
R9E19  100K  [SMR0402IA]  11.81 149.6 180 top
R9E20  10K  [SMR0402IA]  13.84 149.6 0 top
R9E21  10K  [SMR0402IA]  17.14 149.6 180 top
R9E22  10K  [SMR0402IA]  13.84 148.46 0 top
R9E23  10K  [SMR0402IA]  17.14 148.46 180 top
R9E24  1K  [SMR0402IA]  15.62 145.67 180 top
R9E25  0.01  [SMR0603IA]  18.92 145.67 180 top
R9E26  20K  [SMR0402IA]  15.62 144.52 180 top
R9E27  4.7K  [SMR0402IA]  14.73 143.13 0 top
R9E28  10K  [SMR0402IA]  14.73 141.98 0 top
R9E29  10K  [SMR0402IA]  14.73 139.95 0 top
R9E30  10K  [SMR0402IA]  14.73 138.68 0 top
R9E31  10K  [SMR0402IA]  14.73 137.41 0 top
R9F1  0  [SMR0402IA]  21.59 120.52 180 top
R9F2  0  [SMR0402IA]  21.59 119.38 180 top
R9F3  100K  [SMR0402IA]  21.59 118.24 180 top
R9F4  0  [SMR0402IA]  11.04 117.98 0 top
R9F5  100K  [SMR0402IA]  20.7 117.09 0 top
R9F7  0  [SMR0402IA]  22.6 114.93 270 top
R9F8  1K  [SMR0402IA]  19.17 113.79 90 top
R9F9  0  [SMR0402IA]  22.6 112.27 90 top
R9F10  0  [SMR0402IA]  11.04 112.01 0 top
R9F11  0  [SMR0402IA]  18.03 111.38 90 top
R9F12  10K  [SMR0402IA]  22.6 111.38 90 top
R9F13  10K  [SMR0402IA]  11.04 110.74 0 top
R9F14  10K  [SMR0402IA]  19.17 109.85 270 top
R9F15  10K  [SMR0402IA]  20.32 109.83 270 top
R9F16  0  [SMR0402IA]  16.89 108.96 90 top
R9F17  0  [SMR0402IA]  18.03 108.96 90 top
R9F18  0  [SMR0402IA]  21.46 108.96 90 top
R9F19  0  [SMR0402IA]  16 108.08 0 top
R9F20  0  [SMR0402IA]  18.92 107.95 180 top
R9F21  100K  [SMR0402IA]  8.89 106.81 180 top
R9F22  0  [SMR0402IA]  14.47 106.81 0 top
R9F23  0  [SMR0402IA]  8 105.79 0 top
R9F24  0  [SMR0402IA]  10.41 105.79 0 top
R9F25  10K  [SMR0402IA]  15.36 105.79 180 top
R9F26  10K  [SMR0402IA]  15.36 104.9 180 top
R9F27  20K  [SMR0402IA]  8.89 104.77 180 top
R9F28  0  [SMR0402IA]  10.41 104.77 0 top
R9F29  10K  [SMR0402IA]  14.47 104.01 0 top
R9F30  20K  [SMR0402IA]  8.89 103.76 180 top
R9F31  0  [SMR0603IA]  11.3 102.61 0 top
R9F32  10K  [SMR0402IA]  14.47 102.49 0 top
R9F33  0  [SMR0603IA]  11.3 101.47 0 top
R9F34  0.01  [SMR4_0603ID_RVP]  15.62 101.22 180 top
R9F35  0  [SMR0402IA]  12.44 100.07 180 top
R9F36  10K  [SMR0402IA]  14.47 98.8 0 top
R9F37  0  [SMR0402IA]  14.47 97.79 0 top
R9G1  0  [SMR0402IA]  15.36 97.03 180 top
R9G2  0  [SMR0603IA]  15.24 96.01 180 top
R9G3  100K  [SMR0402IA]  12.19 95.88 180 top
R9G4  0  [SMR0603IA]  13.84 94.74 0 top
R9G5  1K  [SMR0402IA]  12.19 94.49 180 top
R9G6  10K  [SMR0402IA]  11.3 93.09 0 top
R9G7  0  [SMR0402IA]  15.36 93.09 180 top
R9G10  10K  [SMR0402IA]  18.16 88.01 270 top
R9G11  8.2K  [SMR0402IA]  20.82 88.01 270 top
R9G14  10K  [SMR0402IA]  17.27 87.12 90 top
R9G15  100K  [SMR0402IA]  19.05 87.12 90 top
R9G16  0  [SMR0402IA]  20.06 87.12 90 top
R9G17  0  [SMR0402IA]  21.59 87.12 90 top
R9G18  10K  [SMR0402IA]  24 87.12 90 top
R9G20  200K  [SMR0402IA]  22.88 85.5 0 top
R9G21  0  [SMR0402IA]  11.81 81.02 180 top
R9G22  1K  [SMR0402IA]  22.47 78.87 0 top
R9G23  10K  [SMR0402IA]  10.03 36.19 270 top
R9G24  10K  [SMR0402IA]  24.13 77.47 0 top
R9G25  0  [SMR0402IA]  34.67 38.23 0 top
R9G26  330  [SMR0402IA]  14.09 75.94 0 top
R9G27  330  [SMR0402IA]  17.9 75.94 180 top
R9G28  330  [SMR0402IA]  20.19 75.94 180 top
R9G29  0  [SMR0402IA]  24.13 75.56 0 top
R9G30  51  [SMR0805IA]  11.43 73.91 270 top
R9G31  4.7K  [SMR0402IA]  17.78 73.02 90 top
R9G32  0  [SMR0402IA]  18.92 73.02 90 top
R9G33  220  [SMR0402IA]  11.55 69.98 0 top
R9G34  5.1K  [SMR0402IA]  16.51 69.98 0 top
R9G35  0  [SMR0402IA]  18.28 69.98 0 top
R9G36  0  [SMR0402IA]  21.2 69.98 180 top
R9G37  0  [SMR0402IA]  24 69.98 90 top
R9G38  0  [SMR0402IA]  21.2 68.83 180 top
R9G39  10K  [SMR0402IA]  21.2 67.69 180 top
R9G40  100K  [SMR0402IA]  21.2 66.55 180 top
R9G41  0  [SMR0402IA]  14.98 65.4 0 top
R9H1  470  [SMR0402IA]  15.87 64.64 180 top
R9H2  330  [SMR0402IA]  15.87 63.88 180 top
R9H3  330  [SMR0402IA]  15.87 63.12 180 top
R9H4  470  [SMR0402IA]  6.85 50.54 0 top
R9H5  8.2K  [SMR0402IA]  22.35 49.27 0 top
R9H6  49.9K  [SMR0402IA]  10.92 49.15 180 top
R9H7  8.2K  [SMR0402IA]  22.35 48.13 0 top
R9H8  49.9K  [SMR0402IA]  10.92 48 180 top
R9H9  150K  [SMR0402IA]  10.92 45.72 180 top
R9H10  8.2K  [SMR0402IA]  23.24 45.08 180 top
R9H11  49.9K  [SMR0402IA]  10.92 44.58 180 top
R9H12  8.2K  [SMR0402IA]  23.24 43.94 180 top
R9H13  0  [SMR0402IA]  20.57 42.92 0 top
R9H14  49.9K  [SMR0402IA]  10.92 41.4 180 top
R9H15  0  [SMR0402IA]  21.46 40 180 top
R9H16  0  [SMR0402IA]  10.92 39.62 180 top
R9H17  0  [SMR0402IA]  10.92 38.61 180 top
R9H18  0  [SMR0402IA]  21.46 38.61 180 top
R9H19  0  [SMR0402IA]  20.57 37.46 0 top
R9H20  1K  [SMR0402IA]  24.38 35.05 270 top
R9H21  0  [SMR0402IA]  24.25 32.51 180 top
R9J1  0  [SMR0402IA]  24.25 31.24 180 top
R9J2  0  [SMR0402IA]  21.46 29.84 180 top
R9J3  49.9K  [SMR0402IA]  24.25 29.84 180 top
R9J4  0  [SMR0402IA]  21.46 28.57 180 top
R9J5  49.9K  [SMR0402IA]  24.25 28.57 180 top
R9J6  0  [SMR0402IA]  10.92 27.56 180 top
R9J7  0  [SMR0402IA]  21.46 27.3 180 top
R9J8  49.9K  [SMR0402IA]  24.25 27.3 180 top
R9J9  0  [SMR0402IA]  10.92 26.29 180 top
R9J10  0  [SMR0402IA]  21.46 26.03 180 top
R9J11  49.9K  [SMR0402IA]  24.25 26.03 180 top
R9J12  49.9K  [SMR0402IA]  10.92 25.02 180 top
R9J13  49.9K  [SMR0402IA]  10.92 22.73 180 top
R9J14  619  [SMR0402IA]  24.13 22.6 90 top
R9J15  49.9K  [SMR0402IA]  10.92 21.59 180 top
R9J17  150K  [SMR0402IA]  10.92 19.28 180 top
R9J19  49.9K  [SMR0402IA]  10.92 18.13 180 top
R9U1  0  [SMR0402IA]  19.32 83.13 270 bottom
R9U2  0  [SMR0402IA]  19.32 83.13 90 bottom
R9U3  0  [SMR0402IA]  18.18 83.13 270 bottom
R9U4  0  [SMR0402IA]  18.18 83.13 90 bottom
R9U5  0  [SMR0402IA]  15.64 83.13 90 bottom
R9U6  0  [SMR0402IA]  15.64 83.13 270 bottom
R9U7  0  [SMR0402IA]  23.39 81.25 270 bottom
R9U8  0  [SMR0402IA]  23.39 81.25 90 bottom
R9U9  0  [SMR0402IA]  22.25 81.25 270 bottom
R9U10  0  [SMR0402IA]  22.25 81.25 90 bottom
R9U11  0  [SMR0402IA]  21.1 81.25 90 bottom
R9U12  0  [SMR0402IA]  21.1 81.25 270 bottom
R9U13  0  [SMR0402IA]  19.93 76.45 180 bottom
R9U14  0  [SMR0402IA]  18.16 76.45 0 bottom
R9U15  0  [SMR0402IA]  19.93 74.8 180 bottom
R9U16  0  [SMR0402IA]  18.16 74.8 0 bottom
R9U17  0  [SMR0402IA]  19.93 73.28 180 bottom
R9U18  0  [SMR0402IA]  18.16 73.28 0 bottom
R9U19  0  [SMR0402IA]  19.93 71.5 180 bottom
R9U20  0  [SMR0402IA]  18.16 71.5 0 bottom
RM8E1  -  [INS_7000_4320_MA]  33.27 139.42 0 top
RM8F1  -  [INS_7000_4320_MA]  33.27 119.42 0 top
RT2A1  50mOHM  [SMR0603IC]  279.27 286.26 270 top
RT2A2  -  [SFU1812MA]  279.01 281.68 180 top
RT2B1  100KOHM  [STR0402MA]  247.77 234.19 270 top
RT2D1  100KOHM  [STR0402MA]  270.25 190.37 0 top
RT2D2  100KOHM  [STR0402MA]  279.9 189.1 270 top
RT3A1  -  [SFU1206IE]  231.77 276.99 270 top
RT3B1  100KOHM  [STR0402MA]  240.66 239.77 90 top
RT4A1  -  [SFU1206IE]  200.27 274.45 90 top
RT5B1  4.7K  [SMRT0402IA]  170.94 239.14 270 top
RT6B1  -  [SFU1206IE]  109.85 240.54 270 top
RT7C1  -  [SFU1206IA]  88.9 208.79 180 top
RT7J1  -  [SFU1206IA]  82.93 21.33 90 top
RT8G1  47KOHM  [STR0402MA]  226.69 238.89 180 top
SW5H1  -  [SSW4VPS244_157IA]  137.66 42.54 180 top
SW5H2  -  [SSW4VPS244_157IA]  148.59 42.54 180 top
SW7C1  -  [SSW8_VD63X45_127MA]  63.62 201.42 180 top
SW8A1  -  [SSW8_VD63X45_127MA]  53.84 283.84 270 top
SW8A2  -  [SSW8_VD63X45_127MA]  60.83 283.84 270 top
SW8A3  -  [SSW8_VD63X45_127MA]  35.81 277.75 90 top
SW8A4  -  [SSW8_VD63X45_127MA]  42.92 277.75 90 top
SW8F1  -  [SSW4_VP37X31_145MA]  41.56 107.67 90 top
TP1A1  -  [FIDUCIAL_40]  311.8 278.59 0 top
TP1C1  -  [TPS16]  283.08 221.49 180 top
TP1D1  -  [TPS16]  280.92 180.59 270 top
TP1D2  -  [TPS16]  280.94 167.13 270 top
TP1J1  -  [FIDUCIAL_40]  311.8 9.5 0 top
TP1L1  -  [FIDUCIAL_40]  311.8 278.59 180 bottom
TP1W1  -  [FIDUCIAL_40]  311.8 9.5 180 bottom
TP2B1  -  [TPS16]  277.49 242.44 180 top
TP2B2  -  [TPS16]  248.15 241.81 0 top
TP2B3  -  [TPS16]  258.06 241.81 0 top
TP2B4  -  [TPS16]  271.39 241.81 0 top
TP2B5  -  [TPS16]  278.13 240.03 180 top
TP2C1  -  [TPS16]  280.16 219.96 180 top
TP3B1  -  [TPS16]  211.45 241.81 0 top
TP3B2  -  [TPS16]  224.79 241.81 0 top
TP3B3  -  [TPS16]  234.82 241.81 0 top
TP3B4  -  [FIDUCIAL_40]  233.55 254.51 0 top
TP3L1  -  [TP_C25]  237.23 270.64 0 bottom
TP3L2  -  [TP_C25]  237.99 269.87 0 bottom
TP3L3  -  [TP_C25]  243.33 269.37 0 bottom
TP3L4  -  [TP_C25]  237.23 268.98 0 bottom
TP3L5  -  [TP_C25]  237.23 267.97 0 bottom
TP3M1  -  [FIDUCIAL_40]  233.55 254.51 180 bottom
TP4B1  -  [TPS16]  188.46 241.81 0 top
TP4B2  -  [TPS16]  201.8 241.81 0 top
TP4J1  -  [FIDUCIAL_40]  200.83 27.19 90 top
TP4L1  -  [TP_C25]  171.7 264.03 180 bottom
TP4L2  -  [TP_C25]  170.68 263.5 180 bottom
TP4W1  -  [FIDUCIAL_40]  200.83 27.19 270 bottom
TP5E1  -  [FIDUCIAL_40]  149.6 142.11 0 top
TP5H1  -  [FIDUCIAL_40]  197.35 45.97 180 bottom
TP5J1  -  [TPS16]  135.63 22.48 0 top
TP5J2  -  [TPS16]  144.14 9.52 0 top
TP5J3  -  [TPS16]  134.23 9.02 0 top
TP5J4  -  [TPS16]  74.93 203.2 0 top
TP5J5  -  [TPS16]  74.93 202.06 0 top
TP5J6  -  [TPS16]  118.26 231.52 0 top
TP5J7  -  [TPS16]  136.06 224.41 0 top
TP5J8  -  [TPS16]  136.09 231.39 0 top
TP5L1  -  [TP_C25]  167.76 262.63 180 bottom
TP5L2  -  [TP_C25]  168.65 262.53 180 bottom
TP5T1  -  [FIDUCIAL_40]  145.79 116.84 180 bottom
TP6D1  -  [TP_C29P14A51_IA]  102.87 167 0 top
TP6D2  -  [TP_C29P14A51_IA]  102.87 165.61 0 top
TP6J1  -  [TPS16]  124.96 23.87 0 top
TP6J2  -  [TPS16]  124.96 22.86 0 top
TP6J3  -  [TPS16]  133.09 22.48 0 top
TP6T1  -  [TP_C29P14A51_IA]  99.06 112.39 90 bottom
TP6T2  -  [TP_C29P14A51_IA]  100.2 111.5 90 bottom
TP6T3  -  [TP_C29P14A51_IA]  99.06 110.74 180 bottom
TP7E1  -  [TP_C29P14A51_IA]  80.39 138.43 90 top
TP7F1  -  [TPS16]  67.94 124.2 0 top
TP7G1  -  [TP_C29P14A51_IA]  88.77 75.44 0 top
TP7R1  -  [TPS16]  85.47 133.86 90 bottom
TP7R2  -  [TPS16]  90.17 130.81 180 bottom
TP8A1  -  [FIDUCIAL_40]  26.79 281.3 0 top
TP8D1  -  [TPS16]  31.36 177.04 90 top
TP8D2  -  [TPS16]  31.87 173.23 0 top
TP8G1  -  [TP_C29P14A51_IA]  56.26 66.93 90 top
TP8J1  -  [TPS16]  33.65 12.57 0 top
TP8J2  -  [TPS16]  54.99 12.57 0 top
TP8L1  -  [FIDUCIAL_40]  26.67 281.3 180 bottom
TP9A1  -  [FIDUCIAL_40]  -7 282.59 0 top
TP9F1  -  [TPS16]  13.33 117.98 0 top
TP9F2  -  [TPS16]  17.01 113.79 0 top
TP9F3  -  [TPS16]  20.32 111.38 0 top
TP9F4  -  [TPS16]  12.19 97.41 0 top
TP9G1  -  [TPS16]  21.59 85.72 0 top
TP9J1  -  [FIDUCIAL_40]  -7 9.5 0 top
TP9J2  -  [FIDUCIAL_40]  10.91 12.53 0 top
TP9L1  -  [FIDUCIAL_40]  -7 282.59 180 bottom
TP9W1  -  [FIDUCIAL_40]  10.73 12.43 180 bottom
TP9W2  -  [FIDUCIAL_40]  -7 9.5 180 bottom
TP4811  -  [FIDUCIAL_40]  197.35 45.97 0 top
U1B1  -  [SOT23_6MI]  290.83 256.79 180 top
U1B2  -  [TSSOP5_21X13_65MA]  289.3 246.89 90 top
U1B3  90OHM  [SMI4_50X65MA]  294.61 237.87 0 top
U1B4  90OHM  [SMI4_50X65MA]  294.61 236.09 0 top
U1B5  90OHM  [SMI4_50X65MA]  294.61 234.31 0 top
U1B6  90OHM  [SMI4_50X65MA]  294.61 232.54 0 top
U1E1  -  [BGA16_1_50MF]  290.57 161.29 0 top
U1E2  -  [BGA16_1_50MF]  283.33 155.07 0 top
U1E3  -  [BGA16_1_50MF]  283.84 145.41 0 top
U2A1  90OHM  [SMI4_50X65MA]  260.09 271.63 90 top
U2A2  90OHM  [SMI4_50X65MA]  262.25 271.63 90 top
U2A3  90OHM  [SMI4_50X65MA]  263.77 271.63 90 top
U2A4  90OHM  [SMI4_50X65MA]  265.93 271.63 90 top
U2B1  -  [SOI8_49X39_127MA]  251.33 256.28 180 top
U2G1  MOSFET_N_DUAL_2G3D3S  [LCC9_6100X5100_127_MA]  270.38 89.66 90 top
U2G2  -  [LCC12_S16_40MB]  250.06 77.47 90 top
U2G3  -  [TSOT23_8_29X16_65MB]  266.82 72.77 180 top
U3A1  90OHM  [SMI4_50X65MA]  239.52 276.45 90 top
U3A2  90OHM  [SMI4_50X65MA]  241.04 276.45 90 top
U3A3  90OHM  [SMI4_50X65MA]  242.57 276.45 90 top
U3A4  -  [SOT23_5ME]  233.93 274.57 90 top
U3A5  -  [BGA64_1_80MA]  240.41 267.59 180 top
U3A6  -  [LCC10_25X10_50MB]  219.96 266.83 90 top
U3A7  -  [LCC10_25X10_50MB]  216.15 266.7 90 top
U3H1  -  [BGA16_1_50MF]  218.56 54.1 0 top
U3H2  -  [BGA16_1_50MF]  229.23 54.1 0 top
U4A1  -  [LCC10_25X10_50MB]  201.22 267.46 270 top
U4A2  -  [LCC10_25X10_50MB]  203.07 266.7 90 top
U4C1  -  [LCC8_16X10_40MA]  177.92 211.96 270 top
U4C2  -  [LCC7_2050X1550_MA]  180.59 202.31 270 top
U4C3  -  [LCC7_2050X1550_MA]  185.92 202.31 270 top
U4H1  -  [BGA16_1_50MF]  189.08 54.1 0 top
U4H2  -  [BGA16_1_50MF]  202.56 53.21 0 top
U5A2  -  [TK0_BGA337_TITAN_RIDGE_MA]  166.37 267.08 0 top
U5B1  -  [SOI8_49X39_127MA]  136.65 254.28 180 top
U5C1  -  [SOT23_5ME]  166.49 235.2 90 top
U5C2  -  [LCC6_S10_35MA]  155.06 200.4 90 top
U5D1  -  [LCC6_S10_35MC]  152.14 193.04 0 top
U5E1  -  [SC70_5_20X13MA]  156.33 157.22 0 top
U5G2  -  [SOT23_5ME]  163.44 82.29 0 top
U5W1  80OHM  [SMI4_0605MA]  145.66 5.97 270 bottom
U6A1  -  [LCC8_79X59_20IA]  106.8 285.62 90 top
U6A2  -  [LCC8_79X59_20IA]  110.99 282.19 0 top
U6A3  -  [LCC8_79X59_20IA]  106.8 277.11 180 top
U6A4  -  [SOT23_5MG]  113.53 268.6 180 top
U6B1  -  [SOI8_S52_127MB]  101.54 241.57 180 top
U6B2  -  [XSOI8_S41_05IA]  101.51 241.59 180 top
U6C1  -  [LCC10_25X10_50MB]  117.72 220.22 0 bottom
U6D1  -  [LCC10_25X10_50MB]  121.28 194.05 270 top
U6D2  -  [LCC10_25X10_50MB]  124.33 193.29 90 top
U6D3  -  [LCC10_25X10_50MB]  104.01 197.05 0 top
U6D4  90OHM  [SMI4_50X65MA]  107.01 196.77 180 top
U6D5  90OHM  [SMI4_50X65MA]  108.73 184.08 180 top
U6D6  90OHM  [SMI4_50X65MA]  123.95 190.85 90 top
U6D7  -  [LCC10_25X10_50MB]  106.29 184.28 0 top
U6E1  -  [BGA874_CNP_H_5_MA]  102.64 146.69 270 top
U6J1  -  [LCC8_16X10_40MA]  103.88 6.09 90 top
U7B2  -  [SOT23_5ME]  91.69 238.38 0 top
U7B3  -  [SOT23_5ME]  89.4 235.71 180 top
U7C1  -  [SSOP8_290X315_65MA]  91.31 223.52 180 top
U7D1  -  [TSSOP8_S30_65MA]  89.4 189.36 90 top
U7F1  -  [SSOP6_20X13_65MA]  72 113.66 180 top
U7G1  -  [SSOP14_4P4_65MA]  74.67 88.77 0 top
U7G2  -  [SSOP14_4P4_65MA]  74.67 82.17 0 top
U7G4  -  [SOI16_40X30_05IA]  86.25 79.5 90 top
U7G5  -  [LCC6_S10_35MC]  66.42 78.99 0 top
U7H1  -  [TSSOP5_21X13_65MA]  96.9 48.13 90 top
U7H2  -  [TSSOP8_S30_65MA]  70.48 42.04 90 top
U7H3  -  [SOI8_49X39_127MA]  64.77 41.65 90 top
U7H4  -  [TSSOP24_78X44_65MA]  68.32 32.89 90 top
U7U1  -  [SSOP14_4P4_65MA]  80.51 88.77 180 bottom
U7U2  -  [SSOP14_4P4_65MA]  80.51 82.17 180 bottom
U8A1  -  [LCC8_79X59_20IA]  32.38 281.94 270 top
U8B1  -  [LCC8_79X59_20IA]  28.7 230.25 90 top
U8B2  -  [LCC8_79X59_20IA]  51.18 230.25 90 top
U8B3  -  [LCC8_79X59_20IA]  33.78 227.71 90 top
U8C1  -  [LCC6_S10_35MA]  32.63 212.6 270 top
U8C2  -  [SOT23_5MB]  41.52 204.09 90 top
U8C3  -  [LCC6_S10_35MA]  32.76 202.69 0 top
U8C4  -  [SOT23_5MB]  30.98 197.74 0 top
U8C5  -  [BGA6_1_50MC]  60.83 196.72 0 top
U8C6  -  [LCC8_16X10_40MA]  28.32 195.45 180 top
U8D1  -  [SOT23_5MB]  51.3 189.61 180 top
U8D2  -  [LCC8_79X59_20IA]  27.94 183.51 270 top
U8D5  -  [LCC6_S10_35MC]  42.41 172.08 180 top
U8D6  -  [SSOP8_23X20_50MA]  40.64 171.96 270 top
U8D7  -  [TSSOP5_21X13_65MA]  43.81 171.96 90 top
U8D8  -  [LCC6_S10_35MA]  37.59 171.45 270 top
U8D9  -  [LCC6_S10_35MA]  28.06 170.81 90 top
U8D10  -  [LCC6_S10_35MA]  32.89 170.81 90 top
U8D11  -  [LCC6_S10_35MA]  35.05 170.81 90 top
U8D12  -  [SOT23_5MG]  44.64 168.96 0 top
U8D13  -  [SOT23_5ME]  29.33 166.24 270 top
U8D14  -  [SOT23_5ME]  38.98 164.34 90 top
U8E1  -  [SOT563MB]  48.1 162.25 270 top
U8E2  -  [SOT563MB]  48.05 153.11 270 top
U8E3  -  [TSSOP24_78X44_65MA]  25.78 148.59 180 top
U8E4  -  [SOT563MB]  48.07 143.96 270 top
U8E5  -  [SOT563MB]  48.05 134.67 270 top
U8F1  -  [SOT23_5ME]  26.54 129.16 90 top
U8F2  -  [SOT23_5ME]  30.09 129.16 90 top
U8F3  -  [TSSOP5_21X13_65MA]  33.65 129.16 90 top
U8F4  -  [SOT563MB]  48.02 125.78 270 top
U8F5  -  [SOT23_5ME]  26.54 124.71 90 top
U8F6  -  [VQFP128_S1420_40MA]  25.42 98.49 270 top
U8G1  -  [SOT23_5ME]  35.63 80.14 180 top
U8G2  -  [TSSOP8_S30_65MA]  50.92 68.96 90 top
U8G3  -  [LCC8_79X59_20IA]  48.76 67.44 270 top
U8H1  90OHM  [SMI4_50X65MA]  29.59 54.08 90 top
U8H2  90OHM  [SMI4_50X65MA]  33.14 54.08 90 top
U8H3  90OHM  [SMI4_50X65MA]  36.57 54.08 90 top
U8H4  90OHM  [SMI4_50X65MA]  40 54.08 90 top
U8H5  -  [TK0_LCC8_1050X1250_400_MA_VR]  36.32 44.83 180 top
U8H6  -  [SOI8_49X39_127MB]  56.51 37.59 0 top
U8J1  -  [SOI8_49X39_127MB]  56.51 32 0 top
U8J2  -  [SOI8_49X39_127MA]  56.51 26.54 0 top
U8L1  -  [SSOP16_199X157_25IA]  47.11 268.35 180 bottom
U8L2  -  [SOI8_19X15_50IA]  53.34 264.54 0 bottom
U8N1  -  [LCC6_S10_35MA]  32 208.79 180 bottom
U9A1  -  [SSOP6_20X13_65MA]  14.73 266.06 270 top
U9C1  -  [TSSOP16_50X44_65MA]  12.06 223.65 90 top
U9C2  -  [SOT23_5ME]  24.51 204.09 90 top
XJ3D2  -  [LPDB_XLGA1200_CML_S_LP6930_MA_KOZ]  222.42 180.72 0 top
XY7F1  -  [HDR_TPV_1X2MB]  80.67 110.49 270 top
Y3A1  27MHz  [TK0_SMY4_2600X3300_MF]  231.39 267.59 180 top
Y4A1  25Mhz  [SMY4_32X25MA]  172.84 276.48 90 top
Y4A2  25MHZ  [SMY4_32X25MA]  196.97 263.14 270 top
Y6A1  -  [TK0_SOS4_2600X3300_MA]  114.17 275.59 0 top
Y6D1  24MHZ  [SMY4_25X20MA]  109.6 177.93 270 top
Y7A1  25MHZ  [SMY4_32X25MA]  92.2 269.75 270 top
Y7F1  32.7680KHZ  [Y82X31MA_PHG1]  78.64 117.99 270 top
Y8F1  32.768KHZ  [SMY32X15MA]  42.29 103.25 90 top

## Library data of the parts
BH9C1 = BATT_HLDR_2PIN: alternate symbols: (); part number: BATT_HLDR_2PIN_THMT-C68619-001,IC,BATT_HLDR_2PIN,LPDB,GENERIC; room: 160
C1A1 C1A2 = CAP: alternate symbols: (); part number: CAP_0603-602431-005,EMPTY,470PF,50V,10%,LPDB,GENERIC; room: 160
C1A3 C3A4 C6A39 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,X5R,4.7UF,16V,10%,LPDB,GENERIC
C1B1 C1B2 C1D1 C1D2 C1D7 C1D8 C1P1 C1P3 C2A33 C2B12 C2B15 C2B17 C2B18 C2G12 C2G13 C2M2 C2M3 C3B25 C3B27 C3B28 C3B30 C3B31 C3M10 C3M12-C3M16 C4B23 C4B25-C4B27 C4B29 C4C12 C4C14 C4C15 C4C17 C4C18 C4M9-C4M11 C4M13 C4M14 C5B34 C5C19 C5C33 C5D19 C5D20 C5D23 C5D24 C5F10 C5G10-C5G13 C6A16 C6A19-C6A21 C6C4 C8B33 C8B36 C8D12 C8D32 C8E2 C8E6 C8E11 C8F3 C8G1 C8G9 C8G15 R4B30 R5B17 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC
C1B3 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; signal model: DEFAULT_CAPACITOR_100000pF_2_1; room: 171
C1B4 C1B5 C1C9 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; signal model: DEFAULT_CAPACITOR_100000pF_2_1
C1B6 = CAP: alternate symbols: (); part number: CAP_0402-A36095-052,C0G,82PF,50V,5%,LPDB,GENERIC
C1B7 C1C8 = CAP: alternate symbols: (); part number: CAP_0603-602433-081,X5R,22UF,6.3V,20%,LPDB,GENERIC; signal model: DEFAULT_CAPACITOR_2.2e+07pF_2_1
C1B8 = CAP: alternate symbols: (); part number: CAP_0603-602433-081,EMPTY,22UF,6.3V,20%,LPDB,GENERIC; signal model: DEFAULT_CAPACITOR_2.2e+07pF_2_1
C1B9 C1C7 = CAP: alternate symbols: (); part number: CAP_0402-G92172-016,EMPTY,82PF,50V,5%,LPDB,GENERIC
C1B10 C2A22 C2A23 C2B20 C5H1 = CAP: alternate symbols: (); part number: CAP_0402-A36095-026,C0G,100PF,50V,5%,LPDB,GENERIC
C1B11-C1B15 C1B17-C1B21 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: DCL_PCIX; signal model: DEFAULT_CAPACITOR_100000pF_2_1
C1B16 = CAP: alternate symbols: (); part number: CAP_0402-A36096-104,X7R,0.22UF,16V,10%,LPDB,GENERIC; room: 169
C1B22 C1C2 C1C4 C1C5 C1D12 C1D13 C1E3 C1E8 C2A1 C2A2 C2A9 C2E1 C2G1 C2G15 C2M5 C2M6 C2M8 C2M9 C3A1 C3A2 C3A6-C3A8 C3G11 C3G17 C3H1 C3H2 C3M19 C3M20 C3M22 C3M25 C3M26 C3M29 C3M30 C4A3 C4A4 C4C7 C4C11 C4C13 C4G10 C4G12 C4H4-C4H7 C4H9 C4L1 C4L2 C4M16 C4M17 C4M19 C4M20 C5A1 C5C24 C5C34 C5D1 C5D8 C5D13 C5F12 C5G9 C5G15 C5J1 C5L1 C5L2 C5M1 C6A11 C6A23 C6A28 C6A34 C6A36 C6A40 C6A49 C6B1 C6B9 C6D11-C6D13 C6D16-C6D20 C6L3-C6L5 C6M1 C7B3 C7B14 C7B15 C7C2 C7C5 C7F2 C7G6 C7G9-C7G13 C7H1 C7H2 C7H9 C7H10 C7L1 C7L3 C7L6-C7L8 C7M2 C7M4 C7M6 C7M8 C7W1 C7W2 C8A4 C8A5 C8B4 C8B6 C8B11 C8B25 C8B34 C8D9 C8D22 C8D28 C8E1 C8E5 C8E9 C8E14 C8F6 C8F7 C8G11 C8G12 C8G14 C8H2 C8H3 C8H7 C8H8 C8N1 C9A1-C9A3 C9B1 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC
C1C1 = CAP: alternate symbols: (); part number: CAP_0402-C94208-001,C0G,56PF,50V,5%,LPDB,GENERIC
C1C3 C5G5 C5G14 = CAPP: alternate symbols: (); part number: CAPP_RDL-628955-097,ALUM,470UF,6.3V,20%,LPDB,GENERIC
C1C6 = CAP: alternate symbols: (); part number: CAP_0402-G65738-001,C0G,120PF,50V,5%,LPDB,GENERIC
C1C10 = CAP: alternate symbols: (); part number: CAP_0402-A36096-048,X5R,0.047UF,10V,10%,LPDB,GENERIC; room: 171
C1C11 C9F1 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,EMPTY,0.1UF,10V,10%,LPDB,GENERIC
C1C12 C1C15 C6A38 C6A41 C6A42 C6A47 C6W2 C6W3 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,X5R,0.1UF,10V,10%,LPDB,GENERIC
C1C13 C1C14 = CAP: alternate symbols: (); part number: CAP_0402-A36096-110,X5R,0.1UF,16V,10%,LPDB,GENERIC
C1D3 C1D9 C2B7 C2B9 C2B10 C3B20 C3B21 C3B23 C4B20 C4B21 C5C38 C5D22 C5M3 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,X7R,0.1UF,50V,10%,LPDB,GENERIC
C1D4 C1D5 C1D10 C1D11 C2B8 C2B11 C2B13 C2B14 C2B16 C2M4 C3B22 C3B24 C3B29 C3B32 C3B33 C3M17 C3M18 C4B22 C4B24 C4B28 C4B30 C4M15 R2B9 R3B36 = CAP: alternate symbols: (); part number: CAP_0402-A36096-099,X5R,1UF,10V,10%,LPDB,GENERIC
C1D6 C2B6 = CAPP: alternate symbols: (); part number: CAPP_TH-628955-077,OSCON,470UF,16V,20%,LPDB,GENERIC; room: DCL_CORE_CPU_VREG
C1D14 CR5A7 CR6H1 CR6H2 CR7F1 CR7T1 CR8H3 CR9D4 CR9D5 = DIODE_SHOTTKY: alternate symbols: (); part number: DIODE_SHOTTKY_SM-C81938-001,IC,30V,0.5A,LPDB,GENERIC; room: LPSS
C1E1 C1E2 C1E4 C1E6 C1E9 C1E10 C2G10 C2G22 C3H6 C3H9 C4G6 C4G25 C4H8 C4H11 C4H13 C4H14 C5A2 C5A30 C5B17 C5B36 C5B38 C5B39 C5G8 C6F2 C7F9 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,EMPTY,0.1UF,25V,10%,LPDB,GENERIC
C1E5 C9C6 = CAP: alternate symbols: (); part number: CAP_0603-602431-033,EMPTY,0.01UF,50V,20%,LPDB,GENERIC; room: FAN_CNTL
C1E7 C9C5 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,EMPTY,0.1UF,50V,10%,LPDB,GENERIC; room: FAN_CNTL
C1E11 C2G26 C2G27 C4C6 C4C20 C6E3 C6E7 C6F1 C7D4 C7E3 C7E15 C7E16 C7R10 C8B2 C8B32 C8F14 C8F21 C8G8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC
C1E13 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 25
C1E14 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,EMPTY,2.2UF,10V,10%,LPDB,GENERIC; room: 25
C1F1 C1F4 C1F7 C1F12 = CAP: alternate symbols: (); part number: CAP_0402-A36096-073,X7R,0.022UF,16V,10%,LPDB,GENERIC; room: DCL_CORE_GMCH
C1F2 C2G24 C5C23 C5W1-C5W4 C6A48 C6G1 C6G2 C6R1 C7H11 C7J1 C8H25 C8J1 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC
C1F3 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,EMPTY,2.2UF,10V,10%,LPDB,GENERIC; room: 23
C1F8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 29
C1F9 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,EMPTY,2.2UF,10V,10%,LPDB,GENERIC; room: 29
C1G1 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,EMPTY,2.2UF,10V,10%,LPDB,GENERIC; room: 27
C1G2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 27
C1P2 C2B19 C2G2 C2M10 C2M11 C2P1 C3M27 C3M28 C4M21-C4M23 C5C16 C5C41 C5D28 C5F7 C5M2 C5U1 = CAP: alternate symbols: (); part number: CAP_0402-A36096-015,EMPTY,680PF,50V,10%,LPDB,GENERIC
C2A3-C2A6 = CAP: alternate symbols: (); part number: CAP_0805-644066-120,X5R,22UF,25V,20%,LPDB,GENERIC; room: DP_HDMI_COMBO_CONNECTOR
C2A7 C2A8 = CAP: alternate symbols: (); part number: CAP_0805-644066-120,X5R,22UF,25V,20%,LPDB,GENERIC; room: 62
C2A10 = CAP: alternate symbols: (); part number: CAP_0603-603269-063,EMPTY,100PF,50V,10%,LPDB,GENERIC; room: DP_HDMI_COMBO_CONNECTOR
C2A11 C2A12 = CAP: alternate symbols: (); part number: CAP_0402-A36096-110,X5R,0.1UF,16V,10%,LPDB,GENERIC; room: DDI2
C2A13-C2A21 C2A24 C2A29-C2A32 C2B2-C2B5 C3L2-C3L7 C3L11-C3L14 C5E17 C6D23 C6D26 C6D27 C6E1 C6E2 C6E5 C6E6 C6E8 C7D5 C7E8 C7E10 C7E12 C7F4 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: LSPCON_CHIP
C2A25 C2F5 C3D6 C3D7 C3D13 C3D14 C3D20 C3D22 C3D27 C3D33 C3E14 C3F7 C3G13 C3P1 C3P20-C3P24 C4C21 C4C22 C4D1 C4D4 C4D8 C5D29 C5E1 C5E6 C5E9 C5E11 C5E12 = CAP: alternate symbols: (); part number: CAP_0603-602433-081,X5R,22UF,6.3V,20%,LPDB,GENERIC; room: DCL_CORE_CPU_VREG
C2A26 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 60
C2A27 C2L3 C2L4 C2L7 C2L10 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 60
C2A28 C6A50 = CAP: alternate symbols: (); part number: CAP_0402-A36096-052,X7R,4700PF,16V,10%,LPDB,GENERIC
C2B1 C3A20 C3A21 C3B1-C3B7 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,EMPTY,0.1UF,25V,10%,LPDB,GENERIC; room: 53
C2B21 C4D2 C5B35 C5C31 C5C32 C5D16 C5D17 C5D25 C5E3 = CAP: alternate symbols: (); part number: CAP_0402-H29050-001,X5R,1UF,25V,10%,LPDB,GENERIC
C2B22 C2M7 C3M23 C3M24 C4M18 C5B37 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-G23339-001,X7R,0.47UF,16V,10%,LPDB,GENERIC
C2B23 = CAP: alternate symbols: (); part number: CAP_0402-A36096-107,X5R,4.7UF,6.3V,20%,LPDB,GENERIC; room: 169
C2C1 C9D3-C9D5 C9D8 C9D9 = CAP: alternate symbols: (); part number: CAP_0402-A36095-025,EMPTY,47PF,50V,5%,LPDB,GENERIC
C2C2 C3C1-C3C4 C4C2 = CAPP: alternate symbols: (); part number: CAPP_TH-A31228-057,TANT,470UF,4V,20%,LPDB,GENERIC; room: 153
C2C3 C2D1 C2D3 C2D5 C2D7 C3C5-C3C9 C4B34 C4C1 C4D3 C4D10-C4D12 = CAPP: alternate symbols: (); part number: CAPP_TH-A31228-057,TANT,470UF,4V,20%,LPDB,GENERIC
C2D2 C2D4 C2D6 C3D1-C3D5 C3D8-C3D12 C3D15-C3D19 C3D21 C3D23-C3D26 C3D28-C3D32 C3P4-C3P9 C3P12-C3P17 C3P19 C4B31-C4B33 C4D7 C4M24-C4M26 C5E8 C5E10 = CAP: alternate symbols: (); part number: CAP_0805-E36851-001,X5R,47UF,6.3V,20%,LPDB,GENERIC; room: DCL_CORE_CPU_VREG
C2F1 C3E7-C3E9 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 26
C2F2 C2F4 C3F6 C3F19 = CAP: alternate symbols: (); part number: CAP_0402-A36096-125,X5R,10UF,10V,20%,LPDB,GENERIC; room: 30
C2F3 C3F15 C4F6 C4F7 = CAP: alternate symbols: (); part number: CAP_0402-A36096-125,X5R,10UF,10V,20%,LPDB,GENERIC; room: 24
C2F6 C2G8 C3F10 C3F11 C3G12 C3G16 C4F8 C4F9 C4G4 C4G5 = CAP: alternate symbols: (); part number: CAP_0805-644066-120,X5R,22UF,25V,20%,LPDB,GENERIC; room: DCL_CORE_CPU_VREG
C2G3 C7F10 C8G10 = CAP: alternate symbols: (); part number: CAP_1206-108426-196,EMPTY,100UF,6.3V,20%,LPDB,GENERIC
C2G4-C2G7 C4D5 C5E2 C5E4 C6W1 = CAP: alternate symbols: (); part number: CAP_1206-108426-196,X5R,100UF,6.3V,20%,LPDB,GENERIC
C2G9 C2G11 C4G23 C5A29 C5G6 C6F5 C7E1 C7J8 = CAP: alternate symbols: (); part number: CAP_0603-603269-067,X7R,1UF,16V,10%,LPDB,GENERIC
C2G14 C2G18 C2G19 C3A23 C4B5 C5A22 C5L26 C6A35 C6A37 C6A43-C6A46 C6J2 C7G3 C7G4 C8F12 C8F13 = CAP: alternate symbols: (); part number: CAP_0805-644066-120,X5R,22UF,25V,20%,LPDB,GENERIC
C2G16 = CAP: alternate symbols: (); part number: CAP_0603-H93459-001,X5R,10UF,6.3V,20%,LPDB,GENERIC
C2G17 = CAP: alternate symbols: (); part number: CAP_0603-H93459-001,EMPTY,10UF,6.3V,20%,LPDB,GENERIC
C2G20 = CAP: alternate symbols: (); part number: CAP_0402-A36096-019,X7R,0.033UF,16V,10%,LPDB,GENERIC
C2G21 C5B41 C6A6 C6A8 C6A9 C6A14 C6A15 C7B13 C8F22 C9G4 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC
C2G23 = CAP: alternate symbols: (); part number: CAP_0402-A36096-075,EMPTY,2200PF,50V,10%,LPDB,GENERIC
C2G25 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,EMPTY,0.1UF,25V,10%,LPDB,GENERIC; room: DCL_CORE_FSB
C2L1 C2L2 C2L5 C2L6 C2L8 C2L9 C2L12 = CAP: alternate symbols: (); part number: CAP_0402-A36096-110,X5R,0.1UF,16V,10%,LPDB,GENERIC; room: 60
C2L11 = CAP: alternate symbols: (); part number: CAP_0402-A36096-107,X5R,4.7UF,6.3V,20%,LPDB,GENERIC; room: 60
C2M1 C3M8 C3M9 C4M8 C5B45 = CAP: alternate symbols: (); part number: CAP_0402-A36096-107,X5R,4.7UF,6.3V,20%,LPDB,GENERIC
C3A3 C3A10 C4A2 C7C10 = CAP: alternate symbols: (); part number: CAP_0402-A36096-049,X7R,470PF,50V,10%,LPDB,GENERIC; room: SB_USB
C3A5 C3A9 C4A5 C6C9 C7C8 = CAPP: alternate symbols: (); part number: CAPP_RDL-628955-097,ALUM,470UF,6.3V,20%,LPDB,GENERIC; room: USB_OUT
C3A11 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,X5R,4.7UF,16V,10%,LPDB,GENERIC; room: 79
C3A12-C3A15 = CAP: alternate symbols: (); part number: CAP_0402-A36094-063,CHIP,0.20PF,25V,0.05PF,LPDB,GENERIC; room: DP_HDMI_COMBO_CONNECTOR
C3A16 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC; room: 68
C3A17 = CAP: alternate symbols: (); part number: CAP_0402-A36095-030,C0G,22PF,50V,5%,LPDB,GENERIC; room: 173
C3A18 = CAP: alternate symbols: (); part number: CAP_0402-A36095-030,C0G,22PF,50V,5%,LPDB,GENERIC; room: 69
C3A19 C3A22 C4A10-C4A18 C4A23 C4A28 C4A32 C4A33 C4A35 C4B1 C5A12 C5A13 C5A16 C5A17 C5B1-C5B8 C5B40 = CAP: alternate symbols: (); part number: CAP_0402-A36096-187,X7R,0.22UF,25V,10%,LPDB,GENERIC
C3A24 = CAP: alternate symbols: (); part number: CAP_0805-644066-120,X5R,22UF,25V,20%,LPDB,GENERIC; room: 77
C3A25 C3A26 C4A39 C4A40 = CAP: alternate symbols: (); part number: CAP_0402-A36096-135,CAPACITOR,0.33UF,25V,+/-10%,LPDB,GENERIC; room: 77
C3A27 C3A28 C3A31 C3A32 C3B8 C3B12-C3B19 C4M1-C4M7 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 80
C3A29 C3A30 C3A33 C3A34 = CAP: alternate symbols: (); part number: CAP_0402-A36096-135,CAPACITOR,0.33UF,25V,+/-10%,LPDB,GENERIC; room: 80
C3B9-C3B11 C3M1-C3M7 C4A37 C4A38 C4A41 C4A42 C4B13-C4B18 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 77
C3B26 C3M11 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 170
C3C10-C3C14 = CAP: alternate symbols: (); part number: CAP_0805-E36851-001,EMPTY,47UF,6.3V,20%,LPDB,GENERIC; room: DCL_CORE_CPU_VREG
C3E1-C3E4 = CAP: alternate symbols: (); part number: CAP_0402-A36096-125,X5R,10UF,10V,20%,LPDB,GENERIC; room: 26
C3E5 C3E6 = CAPP: alternate symbols: (); part number: CAPP_TH-A31228-057,EMPTY,470UF,4V,20%,LPDB,GENERIC
C3E10 C3F12 C3G1 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,X5R,4.7UF,16V,10%,LPDB,GENERIC; room: DCL_CORE_DDR
C3E11 C3F22 C4E1-C4E3 C4F4 C4F5 C4F11 C4G1 C5F5 = CAP: alternate symbols: (); part number: CAP_0402-H48128-001,COG,12PF,16V,5%,LPDB,GENERIC
C3E12 C3F5 C3F8 C3F9 C3F21 C3G9 C4F1-C4F3 C5F6 = CAP: alternate symbols: (); part number: CAP_0402-A64927-026,C0G,2.2PF,25V,0.1PF,LPDB,GENERIC
C3E13 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,EMPTY,0.1UF,10V,10%,LPDB,GENERIC; room: 25
C3E15 C3F2 C3F18 C3G4 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: DCL_CORE_DDR
C3F1 C3F4 C3F13 C3F14 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 24
C3F3 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,EMPTY,0.1UF,10V,10%,LPDB,GENERIC; room: 23
C3F16 = CAP: alternate symbols: (); part number: CAP_0402-A36096-107,X5R,4.7UF,6.3V,20%,LPDB,GENERIC; room: DCL_CORE_DDR
C3F17 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,EMPTY,0.1UF,10V,10%,LPDB,GENERIC; room: 29
C3F20 C3F23 C3F24 C4F10 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 30
C3G2 C3G3 C4G2 C4G3 = CAP: alternate symbols: (); part number: CAP_0402-A36096-125,X5R,10UF,10V,20%,LPDB,GENERIC; room: 28
C3G5-C3G8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 28
C3G10 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,EMPTY,0.1UF,10V,10%,LPDB,GENERIC; room: 27
C3G14 C4G7 = CAPP: alternate symbols: (); part number: CAPP_RDL-628955-093,ALUM,1000UF,2V,20%,LPDB,GENERIC; room: DCL_CORE_DDR
C3G15 = CAPP: alternate symbols: (); part number: CAPP_RDL-628955-087,EMPTY,560UF,2.5V,20%,LPDB,GENERIC; room: 153
C3G24 C4B19 = CAPP: alternate symbols: (); part number: CAPP_RDL-A93544-017,ALUM,22UF,25V,20%,LPDB,GENERIC
C3G25 C3G26 C4G21 C4G22 = CAPP: alternate symbols: (); part number: CAPP_RDL-A93544-018,ALUM,100UF,25V,20%,LPDB,GENERIC; room: 160
C3G27 C3G28 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: DCL_VREG_PWR_CONN
C3G29 C4G17 C4G19 C4H1 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: VREG_PWR_CONN
C3H3 C3H4 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 217
C3H5 C3H8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,EMPTY,0.1UF,25V,10%,LPDB,GENERIC; room: 217
C3L1 C3L8 C3L10 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: LSPCON_CHIP
C3L9 = CAP: alternate symbols: (); part number: CAP_0603-602433-075,EMPTY,10UF,6.3V,20%,LPDB,GENERIC; room: LSPCON_CHIP
C3M21 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 171
C3P2 C3P3 C3P10 C3P11 C3P18 = CAPP_2: alternate symbols: (); part number: CAPP_2_7343-G22717-001,ALUM,330UF,2.5V,20%,TK0,GENERIC; room: NONE
C4A1 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,X5R,4.7UF,16V,10%,LPDB,GENERIC; room: 82
C4A6 C4A25 C4A29 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: LAN
C4A7 C4A8 = CAP: alternate symbols: (); part number: CAP_0402-A36095-030,C0G,22PF,50V,5%,LPDB,GENERIC
C4A9 = CAP: alternate symbols: (); part number: CAP_0402-A36096-187,X7R,0.22UF,25V,10%,LPDB,GENERIC; room: 106
C4A19-C4A21 C4A27 = CAP: alternate symbols: (); part number: CAP_0402-A36096-049,X7R,470PF,50V,10%,LPDB,GENERIC; room: LAN
C4A22 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 82
C4A24 C4A26 C4B7 C4B8 = CAP: alternate symbols: (); part number: CAP_0402-A36096-043,EMPTY,0.1UF,10V,10%,LPDB,GENERIC; room: LAN
C4A30 C4A31 = CAP: alternate symbols: (); part number: CAP_0402-A36095-030,C0G,22PF,50V,5%,LPDB,GENERIC; room: LAN
C4A34 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: LAN
C4A36 C4B2 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 92
C4B3 C6B8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 175
C4B4 C6B5 = CAP: alternate symbols: (); part number: CAP_0402-A36096-075,X7R,2200PF,50V,10%,LPDB,GENERIC; room: 175
C4B6 C6B7 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 175
C4B9-C4B12 C7G8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: ICH
C4B35 C4B36 C4C5 C6R2-C6R4 C7D2 C7F3 C7R2 C7R6 C9G3 = CAP: alternate symbols: (); part number: CAP_0402-A36096-046,EMPTY,1000PF,50V,10%,LPDB,GENERIC
C4C3 C4C4 C5C13 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 51
C4C8 = CAP: alternate symbols: (); part number: CAP_0402-A36097-004,X7R,1800PF,50V,10%,LPDB,GENERIC
C4C9 C5F9 C8D33 C8E3 C8E7 C8E12 C8F4 = CAP: alternate symbols: (); part number: CAP_0805-644066-070,X5R,22UF,6.3V,20%,LPDB,GENERIC
C4C10 C4C19 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 154
C4C16 C5F18 C5F19 C6E4 C6F6 = CAP: alternate symbols: (); part number: CAP_0805-644066-070,X5R,22UF,6.3V,20%,LPDB,GENERIC; room: DP_CONNECTOR
C4D6 C4D9 = CAP: alternate symbols: (); part number: CAP_0603-602433-109,X5R,47UF,6.3V,20%,LPDB,GENERIC; room: DCL_CORE_CPU_VREG
C4G8 = CAPP: alternate symbols: (); part number: CAPP_RDL-628955-093,ALUM,1000UF,2V,20%,LPDB,GENERIC; room: DCL_CORE_CPU_VREG
C4G9 = CAPP: alternate symbols: (); part number: CAPP_RDL-628955-087,EMPTY,560UF,2.5V,20%,LPDB,GENERIC; room: DCL_CORE_DDR
C4G13 C5C21 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: VREG
C4G14 = CAPP: alternate symbols: (); part number: CAPP_RDL-628955-090,OSCON,100UF,16V,20%,LPDB,GENERIC; room: VREG
C4G16 C4G20 C7H6 C7H7 = CAP: alternate symbols: (); part number: CAP_0402-A36096-099,EMPTY,1UF,10V,10%,LPDB,GENERIC
C4G18 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 160
C4G24 C4H2 = CAP: alternate symbols: (); part number: CAP_0402-A36096-049,X7R,470PF,50V,10%,LPDB,GENERIC; room: DCL_VREG_PWR_CONN
C4H3 C5C42 C7A11 C7B1 C8C9 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: DCPL_BULK_MISC
C4H10 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 178
C4H12 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,EMPTY,4.7UF,16V,10%,LPDB,GENERIC; room: 178
C4H15 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC; room: 178
C4L3 C5L3-C5L8 C5L12-C5L25 C5L27-C5L34 C5L36 = CAP: alternate symbols: (); part number: CAP_0201-C83410-015,X5R,1UF,6.3V,10%,LPDB,GENERIC
C4M12 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 171
C5A3-C5A7 = CAP: alternate symbols: (); part number: CAP_0402-A36095-026,C0G,100PF,50V,5%,LPDB,GENERIC; room: COMBO_JACK
C5A8 C5A11 = CAP: alternate symbols: (); part number: CAP_0402-A36096-110,EMPTY,0.1UF,16V,10%,LPDB,GENERIC; room: COMBO_JACK
C5A9 C5A10 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,X5R,4.7UF,16V,10%,LPDB,GENERIC; room: COMBO_JACK
C5A14 C5A21 C5A24 = CAP: alternate symbols: (); part number: CAP_0603-602433-109,X5R,47UF,6.3V,20%,LPDB,GENERIC
C5A15 C5A18 C5A23 C5A25 C5L9 C5L10 C6A22 = CAP: alternate symbols: (SMC0402_OCTO_IA,SMC0402_OCTO_IA_PHED); part number: CAP_0402-A36096-114,X5R,10UF,6.3V,20%,LPDB,GENERIC
C5A19 C5A20 C5B9 C5B10 C5B42 C5B43 = CAP: alternate symbols: (); part number: CAP_0402-A36096-002,X7R,220PF,50V,10%,LPDB,GENERIC
C5A26 C5A28 C5L35 = CAP: alternate symbols: (); part number: CAP_0402-A36096-125,X5R,10UF,10V,20%,LPDB,GENERIC; room: 190
C5A27 = CAP: alternate symbols: (); part number: CAP_0603-602433-099,X5R,4.7UF,16V,10%,LPDB,GENERIC; room: 190
C5B12 C5B15 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,X7R,0.1UF,50V,10%,LPDB,GENERIC; room: 49
C5B16 = CAP: alternate symbols: (); part number: CAP_0603-602433-061,X7R,0.1UF,50V,10%,LPDB,GENERIC; room: DCPL_BULK_MISC
C5B19 C5B20 C5B23 C8B15-C8B18 C8B21 C8B24 C8D1 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: DCL_PCIX
C5B22 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 49
C5B32 C5B33 C5C1-C5C4 C5C14 C5C15 C5C18 C5C22 C5C26 C5C28-C5C30 C5C35 C5C36 C5C39 C5C40 C5D2 C5D3 C5D6 C5D7 C5D9-C5D12 C5D14 C5D15 C5D18 C5D21 C5D26 C5D27 C5G16-C5G23 C8B28-C8B31 C8B37 C8B38 C8C1 C8C2 C8C7 C8C8 C8C10-C8C15 = CAP: alternate symbols: (); part number: CAP_0402-A36096-104,X7R,0.22UF,16V,10%,LPDB,GENERIC; room: DCL_PCIX
C5B44 RT2B1 RT2D1 RT2D2 RT3B1 = THERM_NTC: alternate symbols: (); part number: THERM_NTC_SM-C98257-005,IC,100KOHM,1%,NULL,LPDB,GENERIC
C5C5 C5C7 C5C8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 51
C5C6 C5C9-C5C12 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 51
C5C17 C5F11 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,EMPTY,10UF,25V,20%,LPDB,GENERIC
C5C20 C8C28 = CAP: alternate symbols: (); part number: CAP_0402-A36096-002,EMPTY,220PF,50V,10%,LPDB,GENERIC; room: DCPL_BULK_MISC
C5C25 C5F8 C8D34 C8E4 C8E8 C8E13 C8F5 = CAP: alternate symbols: (); part number: CAP_0805-644066-070,EMPTY,22UF,6.3V,20%,LPDB,GENERIC
C5C27 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,EMPTY,0.01UF,25V,10%,LPDB,GENERIC
C5C37 C5E5 C5E7 = CAP: alternate symbols: (); part number: CAP_0402-H29050-001,EMPTY,1UF,25V,10%,LPDB,GENERIC
C5E13 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 25
C5E14 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC; room: 25
C5E15 C5E16 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 26
C5F1 C5F2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 30
C5F3 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 23
C5F4 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC; room: 23
C5F13 C5F14 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 24
C5F15 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC; room: 29
C5F16 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 29
C5F17 C5F22 = CAP: alternate symbols: (); part number: CAP_0805-644066-070,EMPTY,22UF,6.3V,20%,LPDB,GENERIC; room: DP_CONNECTOR
C5F20 C5F21 = CAP: alternate symbols: (); part number: CAP_0805-E36851-001,EMPTY,47UF,6.3V,20%,LPDB,GENERIC
C5G1 = CAP: alternate symbols: (); part number: CAP_0402-A36096-121,X5R,2.2UF,10V,10%,LPDB,GENERIC; room: 27
C5G2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 27
C5G3 C5G4 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 28
C5G7 = CAP: alternate symbols: (); part number: CAP_0402-A36096-052,EMPTY,4700PF,16V,10%,LPDB,GENERIC
C5L11 C6A2 = CAP: alternate symbols: (); part number: CAP_0402-A36096-125,X5R,10UF,10V,20%,LPDB,GENERIC
C6A1 C6A10 C8A3 = CAP: alternate symbols: (); part number: CAP_0402-A36096-075,X7R,2200PF,50V,10%,LPDB,GENERIC; room: 174
C6A3 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: AUDIO_CODEC
C6A4 C6A7 C8A2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 174
C6A5 C6A12 C8A1 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 174
C6A13 C6A17 C6A30 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 105
C6A18 C6A25 C6A29 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 105
C6A24 C8B26 C8B27 C8D16 C8G21 = CAP: alternate symbols: (); part number: CAP_0402-A36096-075,X7R,2200PF,50V,10%,LPDB,GENERIC
C6A26 C6C6 C6C10 C8G4 = CAP: alternate symbols: (); part number: CAP_0402-A36095-026,EMPTY,100PF,50V,5%,LPDB,GENERIC
C6A27 C6A31 = CAP: alternate symbols: (); part number: CAP_0402-A36096-125,X5R,10UF,10V,20%,LPDB,GENERIC; room: 105
C6A32 = CAP: alternate symbols: (); part number: CAP_0603-603275-162,EMPTY,22PF,50V,5%,LPDB,GENERIC
C6A33 = CAP: alternate symbols: (); part number: CAP_0603-603269-067,X7R,1UF,16V,10%,LPDB,GENERIC; room: 190
C6B2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 192
C6B3 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 175
C6B4 C8B9 C8B10 = CAPP: alternate symbols: (); part number: CAPP_RDL-202008-264,ALUM,470UF,16V,20%,LPDB,GENERIC; room: DCL_PCIX
C6B6 C8B19 C8B20 = CAPP: alternate symbols: (); part number: CAPP_RDL-A93544-018,ALUM,100UF,25V,20%,LPDB,GENERIC; room: DCL_PCIX
C6B10 = CAPP: alternate symbols: (); part number: CAPP_7343-724613-024,TANT,220UF,10V,20%,LPDB,GENERIC; room: USB_OUT
C6C1 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 92
C6C2 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 87
C6C3 C6C5 C6C11 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 86
C6C7 C6C12 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 84
C6C8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-027,X5R,1UF,6.3V,10%,LPDB,GENERIC; room: 84
C6D1-C6D4 = CAP: alternate symbols: (); part number: CAP_0402-A36096-135,CAPACITOR,0.33UF,25V,+/-10%,LPDB,GENERIC
C6D5-C6D8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 83
C6D9 C6D10 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 85
C6D14 C6D15 C6D24 C6D25 C6F3 C6F4 = CAP: alternate symbols: (); part number: CAP_0603-602433-081,EMPTY,22UF,6.3V,20%,LPDB,GENERIC; room: DCL_CORE_CPU_VREG
C6D21 C6D22 C7F5 C7F6 = CAP: alternate symbols: (); part number: CAP_0402-A36095-042,C0G,18PF,50V,5%,LPDB,GENERIC; room: 42
C6G3 C6G4 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: SATA_HDR
C6G5-C6G8 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,X7R,0.01UF,25V,10%,LPDB,GENERIC; room: 96
C6G9-C6G12 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-045,EMPTY,0.01UF,25V,10%,LPDB,GENERIC; room: 96
C6J1 = CAP: alternate symbols: (); part number: CAP_0402-A36096-075,X7R,2200PF,50V,10%,LPDB,GENERIC; room: 103
C6J3 = CAP: alternate symbols: (); part number: CAP_0603-G33975-001,X5R,10UF,25V,20%,LPDB,GENERIC; room: 103
C6J4 = CAP: alternate symbols: (SMC0402_OCTO_IA); part number: CAP_0402-A36096-112,X7R,0.1UF,25V,10%,LPDB,GENERIC; room: 106
C6L1 C6L2 = CAP: alternate symbols: (); part number: CAP_0402-A36094-025,C0G,10PF,50V,0.5PF,LPDB,GENERIC
C6M2 C7B4 C7B5 C7L4 C7L5 C7M1 = CAP: alternate symbols: (); part number: CAP_0603-602433-081,X5R,22UF,6.3V,20%,LPDB,GENERIC
C7A1-C7A4 = CAP: alternate symbols: (); part number: CAP_0402-A36095-053,EMPTY,470PF,50V,5%,LPDB,GENERIC
