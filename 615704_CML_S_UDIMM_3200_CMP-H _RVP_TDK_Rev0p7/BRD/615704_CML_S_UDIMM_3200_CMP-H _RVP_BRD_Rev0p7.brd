# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_SRC5_SLOT2_DP: length 106.3
  TOP w0.088: v1(102.77,162.5) 103,162.73 103.1,162.73 103.59,162.24 103.59,159.11 103.44,158.96 103.44,157.79 103.84,157.4 U6E1.AB3
  LAY6 w0.115: v1(102.77,162.5) 103.04,162.77 103.3,162.77 103.56,163.03 103.56,164.27 103.02,164.82 102.03,164.82 87.02,179.83 87.02,194.48 84.25,197.25 76.87,197.25 76.74,197.12 75.23,197.12 69.72,202.63 69.72,215.64 68.19,217.17 68.19,220.72 67.56,221.36 67.56,234 66.51,235.05 64.23,235.05 63.27,234.08 63.27,232.94 62.97,232.65 J7B1.A13
CLK_SRC6_TR_DN: length 143.8
  TOP w0.1: 169.62,265.13 U5A2.T19 v2(169.94,264.8) ; R6D41.1 v1(109.47,179.7)
  BOTTOM w0.1: v1(109.47,179.7) 110.28,180.52 110.28,181.33 109.67,181.95 109.67,185.76 107.59,187.84 107.59,189.99 109.03,191.43 109.03,193.6 107.89,194.74 107.89,200.46 106.83,201.52 106.83,219.48 109.42,222.07 109.42,227.78 110.23,228.6 111.76,228.6 112.26,229.11 112.26,230.47 115,233.21 115,239.56 120.85,245.41 120.85,247.98 127.81,254.94 128.45,254.94 131.24,257.73 134.28,257.73 135.12,258.57 136.14,258.57 136.39,258.32 146.82,258.32 147.64,259.13 148.89,259.13 150.36,260.6 153.64,260.6 154.8,259.43 161.42,259.43 162.64,260.66 171.84,260.66 172.94,261.76 172.94,264.09 172.22,264.8 v2(169.94,264.8)
CLK_SRC6_TR_DP: length 143.8
  TOP w0.1: U5A2.V19 169.65,264.48 169.94,264.19 v2(169.94,264.18) ; R6D38.1 v1(109.47,180.97)
  BOTTOM w0.1: v1(109.47,180.97) 109.47,180.41 109.6,180.28 109.77,180.28 110.08,180.6 110.08,181.25 109.47,181.86 109.47,185.67 107.39,187.75 107.39,190.07 108.83,191.51 108.83,193.52 107.69,194.66 107.69,200.38 106.63,201.44 106.63,219.56 109.22,222.15 109.22,227.87 109.68,228.33 110.15,228.8 111.67,228.8 112.06,229.19 112.06,230.56 114.8,233.3 114.8,239.65 120.65,245.49 120.65,248.06 127.73,255.14 128.36,255.14 131.15,257.93 134.2,257.93 135.04,258.77 136.22,258.77 136.48,258.52 146.74,258.52 147.56,259.33 148.81,259.33 150.28,260.8 153.72,260.8 154.89,259.63 161.33,259.63 162.56,260.86 171.75,260.86 172.74,261.84 172.74,264.01 172.14,264.6 170.29,264.6 169.94,264.25 v2(169.94,264.18)
CLK_SRC6_TR_U2_DN: length 34.5
  TOP w0.089: 105.25,157.53 105.25,157.12 U6E1.W4
  TOP w0.1: R6D41.2 111.12,180.14 111.02,180.24 108.14,180.24 107.41,180.98 103.5,180.98 102.87,180.34 102.87,178.94 103.37,178.43 103.37,171.86 105.15,170.08 105.15,165.1 104.51,164.46 104.51,163.35 105.02,162.84 105.02,157.76 105.25,157.53
CLK_SRC6_TR_U2_DP: length 34.5
  TOP w0.1: U6E1.W3 105.04,157.34 105.04,157.46 104.82,157.68 104.82,162.76 104.31,163.27 104.31,164.55 104.95,165.19 104.95,170 103.17,171.78 103.17,178.35 102.67,178.86 102.67,180.42 103.42,181.18 107.49,181.18 108.23,180.44 111.24,180.44 111.34,180.54 111.34,180.75 R6D39.2
CLK_SRC6_U2_DN: length 170.6
  TOP w0.1: v1(148.81,60.69) 149.12,60.37 149.12,60.12 149.34,59.9 150.02,59.9 R5H5.1 ; v1(128.14,123.69) 128.44,123.39 129.24,123.39 129.56,123.06 131.57,123.06 135.38,126.87 135.38,129.82 143.12,137.57 143.12,147.47 147.39,151.74 147.39,155.77 146.66,156.51 139.49,156.51 137.91,158.09 134.22,158.09 123.87,168.44 123.87,170.71 123.37,171.74 116.69,178.42 116.06,178.42 115.22,179.26 112.81,180.24 112.11,180.24 112.01,180.13 R6D42.1
  BOTTOM w0.1: v1(128.14,123.69) 127.84,123.39 127.36,123.39 126.74,122.77 126.74,118.41 125.15,116.82 125.15,85.64 126.54,84.25 126.54,79.7 135.94,70.3 135.94,69 137,67.94 138.17,67.94 140.46,65.66 143.25,65.66 146.88,62.03 148.76,62.03 149.09,61.69 149.09,60.97 v1(148.81,60.69)
CLK_SRC6_U2_DP: length 170.6
  TOP w0.1: v1(149.63,60.69) 149.32,60.37 149.32,60.2 149.42,60.1 150.02,60.1 R5H4.1 ; R6D39.1 112.01,180.6 112.17,180.44 112.85,180.44 115.33,179.43 116.14,178.62 116.78,178.62 123.54,171.86 124.07,170.75 124.07,168.52 134.3,158.29 137.99,158.29 139.57,156.71 146.74,156.71 147.59,155.86 147.59,151.66 143.32,147.39 143.32,137.49 135.58,129.74 135.58,126.79 131.65,122.86 129.48,122.86 129.15,123.19 128.44,123.19 v1(128.14,122.89)
  BOTTOM w0.1: v1(149.63,60.69) 149.29,61.02 149.29,61.77 148.84,62.23 146.96,62.23 143.33,65.86 140.54,65.86 138.25,68.14 137.08,68.14 136.14,69.09 136.14,70.39 126.74,79.78 126.74,84.33 125.35,85.72 125.35,116.74 126.94,118.33 126.94,122.69 127.44,123.19 127.84,123.19 v1(128.14,122.89)
CLK_SRC6_U2_R_DN: length 8.6
  TOP w0.1: R5H5.2 151.86,59.92 152.04,59.92 154.27,62.15 155.74,62.15 156.1,61.8 157.92,61.8 J5H1.A2
CLK_SRC6_U2_R_DP: length 8.6
  TOP w0.1: J5H1.A1 157.98,62.38 157.98,62.1 157.88,62 156.18,62 155.83,62.35 154.19,62.35 151.96,60.12 151.81,60.12 151.38,60.55 R5H4.2
CLK_SRC7_X16PORT_DN: length 110.5
  TOP w0.1: v1(106.3,226.24) 106.56,226.5 106.74,226.5 107.95,227.71 107.95,230.5 108.63,231.19 116.38,231.19 117.6,232.41 119.28,232.41 121.74,234.88 133.9,234.88 134.21,234.57 135.03,234.57 R5B43.2 ; U6E1.W7 v1(105.59,155.35)
  BOTTOM w0.1: v1(105.59,155.35) 105.59,155.52 105.01,156.1 105.01,157.62 104.34,158.29 104.34,177.34 102.74,178.94 102.74,180.47 103.25,180.97 103.25,182.65 105.46,184.86 105.46,185.55 105.33,185.67 105.33,194.35 104.54,195.14 104.54,220.5 106.86,222.81 106.86,226.41 106.76,226.5 106.56,226.5 v1(106.3,226.24)
CLK_SRC7_X16PORT_DN_R: length 12.4
  TOP w0.1: J5B2.A14 145.37,232.07 144.9,232.07 144.35,231.52 140.81,231.52 140.26,232.07 140.26,233.98 139.69,234.55 136.6,234.55 R5B43.1
CLK_SRC7_X16PORT_DP: length 110.5
  TOP w0.1: R5B41.2 135.07,234.77 134.29,234.77 133.98,235.08 121.66,235.08 119.19,232.61 117.51,232.61 116.3,231.39 108.55,231.39 107.75,230.59 107.75,227.79 106.73,226.78 106.59,226.78 v1(106.3,227.07) ; U6E1.W6 v1(105.78,156.09)
  BOTTOM w0.1: v1(105.78,156.09) 105.68,155.99 105.4,155.99 105.21,156.18 105.21,157.71 104.54,158.37 104.54,177.43 102.94,179.03 102.94,180.38 103.45,180.89 103.45,182.57 105.66,184.78 105.66,185.63 105.53,185.75 105.53,194.44 104.74,195.22 104.74,220.42 107.06,222.73 107.06,226.49 106.84,226.7 106.66,226.7 v1(106.3,227.07)
CLK_SRC7_X16PORT_DP_R: length 12.4
  TOP w0.1: R5B41.1 136.6,234.75 139.77,234.75 140.46,234.06 140.46,232.15 140.89,231.72 144.26,231.72 144.7,232.15 144.7,232.46 144.5,232.65 J5B2.A13
CLK_SRC8_LAN_FOX_DN: length 120.5
  TOP w0.1: v1(102.89,260.76) 102.86,260.73 R6A80.1 ; U6E1.AC14 v1(103.77,152.25)
  BOTTOM w0.1: v1(103.77,152.25) 103.51,152 103.34,152 102.87,152.48 102.87,157.25 101.98,158.14 101.98,161.92 102.28,162.22 102.28,165.05 100.71,166.62 100.71,173.23 100.02,173.92 100.02,179.52 100.91,180.41 100.91,182.44 103.24,184.78 103.24,188.5 102.94,188.8 102.94,194.49 101.98,195.45 101.98,210.95 103.63,212.6 103.63,220.47 104.64,221.49 104.64,226.87 106.04,228.27 106.04,230.5 109.6,234.06 109.6,239.39 108.83,240.16 108.83,248.57 105.8,251.6 105.8,252.11 105.53,252.38 105.53,258.95 104.09,260.39 103.25,260.39 v1(102.89,260.76)
CLK_SRC8_LAN_FOX_DP: length 120.6
  TOP w0.1: v1(102.89,259.93) 102.8,259.84 R6A84.1 ; U6E1.AC15 v1(103.77,151.49)
  BOTTOM w0.1: v1(102.89,259.93) 103.15,260.19 104.01,260.19 105.33,258.87 105.33,252.29 105.6,252.03 105.6,251.52 108.63,248.48 108.63,240.07 108.69,240.01 109.4,239.31 109.4,234.14 105.84,230.59 105.84,228.35 104.44,226.95 104.44,221.57 103.43,220.55 103.43,212.68 101.78,211.03 101.78,195.37 102.74,194.41 102.74,188.72 103.04,188.42 103.04,184.86 100.71,182.53 100.71,180.49 99.82,179.61 99.82,173.83 100.51,173.14 100.51,166.54 102.08,164.97 102.08,162.31 101.78,162.01 101.78,158.06 102.67,157.17 102.67,152.39 103.26,151.8 103.46,151.8 v1(103.77,151.49)
CLK_SRC9_PEGX16_DN: length 127.1
  TOP w0.088: U6E1.U2 106.03,158.25 105.39,158.89 105.39,162.94 105.6,163.14 105.6,164.17 105.39,164.38 105.19,164.38 v1(105.08,164.27)
  TOP w0.1: J5B2.A8 145.53,239.65 145.18,240.01 145.18,240.8 144.27,241.7 140.79,241.7 139.95,240.87 133.75,240.87 131.67,242.95 115.86,242.95 v1(115.57,243.25)
  BOTTOM w0.1: v1(115.57,243.25) 115.57,243.2 115.14,242.77 114.47,242.77 114.1,242.4 114.1,241.51 112.57,239.98 112.57,233.13 111.55,232.1 108.37,232.1 107.19,230.92 107.19,228.09 107.82,227.46 107.82,222.79 105.23,220.19 105.23,200.71 106.02,199.92 106.02,185.95 106.14,185.82 106.14,179.17 105.08,178.11 105.08,165.04 105.16,164.96 105.16,164.34 v1(105.08,164.27)
CLK_SRC9_PEGX16_DP: length 127.1
  TOP w0.088: v1(105.61,164.79) 105.61,164.42 105.79,164.25 105.79,163.07 105.58,162.86 105.58,158.96 106.22,158.33 106.22,158.09 106.29,158.01 106.29,157.64 U6E1.U3
  TOP w0.1: v1(115.57,242.45) 115.86,242.75 131.58,242.75 133.67,240.67 140.04,240.67 140.87,241.5 144.19,241.5 144.98,240.71 144.98,240.16 144.85,240.03 144.41,240.03 J5B2.A7
  BOTTOM w0.1: v1(115.57,242.45) 115.45,242.57 114.55,242.57 114.3,242.31 114.3,241.43 112.77,239.9 112.77,233.04 111.63,231.9 108.45,231.9 107.39,230.83 107.39,228.17 108.02,227.54 108.02,222.7 105.43,220.11 105.43,200.79 106.22,200 106.22,186.03 106.34,185.91 106.34,179.09 105.28,178.02 105.28,165.13 v1(105.61,164.79)
CLK_SRC10_PEGX16_DN: length 94.9
  TOP w0.1: U6E1.AC9 v1(103.77,154.54) ; R5C28.2 135.25,209.05 135.12,209.17 134.82,209.17 134.43,208.79 126.49,208.79 125.34,209.93 121.03,209.93 120.52,209.42 119.22,209.42 118.33,210.31 105.15,210.31 104.34,209.5 102.67,209.5 102.48,209.32 v1(102.48,209.12)
  BOTTOM w0.1: v1(102.48,209.12) 102.48,209.27 102.76,209.55 102.96,209.55 103.17,209.34 103.17,197.02 103.76,196.43 103.76,195.78 103.45,195.47 103.45,189.28 103.75,188.97 103.75,184.53 102.48,183.26 102.48,181.26 101.9,180.68 101.9,178.64 102.87,177.67 102.87,167.99 103.55,167.3 103.55,165.51 103.2,165.15 103.2,164.48 103.55,164.13 103.55,157.81 104.24,157.12 104.24,155.45 104.37,155.32 104.37,154.38 104.22,154.23 103.95,154.23 103.77,154.42 v1(103.77,154.54)
CLK_SRC10_PEGX16_DN_R: length 12.9
  TOP w0.1: J5B2.A33 144.24,212.65 144.55,212.97 144.55,213.38 144.44,213.49 140.71,213.49 139.82,212.6 138.81,212.6 138.43,212.22 138.43,210.18 137.37,209.12 136.49,209.12 R5C28.1
CLK_SRC10_PEGX16_DP: length 94.9
  TOP w0.1: R5C22.2 134.94,209.37 134.73,209.37 134.35,208.99 126.57,208.99 125.43,210.13 120.94,210.13 120.88,210.07 120.44,209.62 119.3,209.62 118.41,210.51 105.07,210.51 104.26,209.7 102.7,209.7 v1(102.48,209.92) ; U6E1.AC11 v1(103.77,153.78)
  BOTTOM w0.1: v1(102.48,209.92) 102.66,209.75 103.05,209.75 103.37,209.42 103.37,197.1 103.96,196.52 103.96,195.7 103.65,195.39 103.65,189.36 103.95,189.06 103.95,184.45 102.68,183.18 102.68,181.17 102.1,180.59 102.1,178.72 103.07,177.76 103.07,168.07 103.75,167.38 103.75,165.43 103.4,165.07 103.4,164.57 103.75,164.21 103.75,157.89 104.44,157.2 104.44,155.53 104.57,155.4 104.57,154.3 104.3,154.03 104.02,154.03 v1(103.77,153.78)
CLK_SRC10_PEGX16_DP_R: length 12.9
  TOP w0.1: J5B2.A32 145.64,213.51 144.7,213.51 144.53,213.69 140.63,213.69 139.74,212.8 138.72,212.8 138.23,212.3 138.23,210.27 137.28,209.32 136.49,209.32 R5C23.1
CLK_SRC11_DN: length 103.5
  TOP w0.1: U6E1.AE9 v1(101.52,154.54)
  LAY3 w0.1: v1(101.52,154.54) 101.81,154.25 102,154.25 102.13,154.38 102.13,157.24 97.68,161.68 97.68,164.47 92.31,169.85 92,169.85 90.97,168.81 90.54,168.81 90.21,169.15 90.21,169.6 91.54,170.94 91.54,171.12 91.2,171.46 91.02,171.46 89.85,170.29 89.52,170.29 89.07,170.74 89.07,171.07 90.24,172.24 90.24,172.42 89.9,172.76 89.72,172.76 88.55,171.59 88.21,171.59 87.77,172.04 87.77,172.37 88.94,173.54 88.94,173.73 88.6,174.07 88.41,174.07 87.25,172.9 86.91,172.9 86.47,173.34 86.47,173.67 87.64,174.84 87.64,175.03 87.3,175.37 87.11,175.37 85.94,174.2 85.61,174.2 85.17,174.64 85.17,174.97 86.34,176.14 86.34,176.33 86,176.67 85.81,176.67 84.64,175.5 84.31,175.5 83.87,175.94 83.87,176.28 85.03,177.45 85.03,177.63 84.63,178.04 84.63,180.29 84.5,180.42 79.56,180.42 79.33,180.65 79.33,181.28 79.56,181.52 84.5,181.52 84.63,181.65 84.63,182.13 84.5,182.26 79.56,182.26 79.33,182.49 79.33,183.12 79.56,183.36 84.5,183.36 84.63,183.49 84.63,183.97 84.5,184.1 79.56,184.1 79.33,184.33 79.33,184.96 79.56,185.2 84.5,185.2 84.63,185.33 84.63,191.56 82.22,193.97 82.22,194.38 81.99,194.61 81.86,194.61 81.15,195.32 J7C9.3
CLK_SRC11_DP: length 103.5
  TOP w0.1: U6E1.AE11 v1(101.52,153.78)
  LAY3 w0.1: v1(101.52,153.78) 101.79,154.04 102.08,154.04 102.33,154.29 102.33,157.32 97.89,161.76 97.89,164.56 92.39,170.05 91.92,170.05 90.89,169.02 90.62,169.02 90.41,169.23 90.41,169.52 91.75,170.85 91.75,171.21 91.29,171.67 90.93,171.67 89.76,170.5 89.6,170.5 89.28,170.82 89.28,170.99 90.44,172.16 90.44,172.51 89.98,172.97 89.63,172.97 88.46,171.8 88.3,171.8 87.97,172.13 87.97,172.29 89.14,173.46 89.14,173.81 88.68,174.27 88.33,174.27 87.16,173.1 87,173.1 86.67,173.43 86.67,173.59 87.84,174.76 87.84,175.11 87.38,175.57 87.03,175.57 85.86,174.4 85.7,174.4 85.37,174.73 85.37,174.89 86.54,176.06 86.54,176.41 86.08,176.87 85.73,176.87 84.56,175.7 84.4,175.7 84.07,176.03 84.07,176.19 85.24,177.36 85.24,177.71 84.83,178.12 84.83,180.37 84.58,180.62 79.65,180.62 79.53,180.74 79.53,181.2 79.65,181.31 84.58,181.31 84.83,181.56 84.83,182.21 84.58,182.46 79.65,182.46 79.53,182.58 79.53,183.04 79.65,183.15 84.58,183.15 84.83,183.4 84.83,184.05 84.58,184.3 79.65,184.3 79.53,184.42 79.53,184.88 79.65,184.99 84.58,184.99 84.83,185.24 84.83,191.64 82.42,194.05 82.42,194.34 83.41,195.32 J7C9.1
CLK_SRC_LAN_FOX_DN: length 3.9
  TOP w0.1: EU7A3.22 98.3,260.29 98.68,259.91 99.73,259.91 100.29,260.47 100.95,260.47 R6A80.2
CLK_SRC_LAN_FOX_DP: length 3.9
  TOP w0.1: EU7A3.21 98.42,259.89 98.6,259.71 99.82,259.71 100.37,260.27 100.79,260.27 R6A84.2
CLN_RST_FET_GATE1_LED: length 2
  TOP w0.1: 97.55,43.68 97.55,44.84 R6H19.2
CLN_RST_FET_GATE2_LED: length 3.8
  TOP w0.1: 98.42,40.13 98.42,40.77 98.2,40.99 Q7H1.3 98.2,42.39 98.04,42.54 97.66,42.54 97.55,42.43 97.55,41.78
CLN_RST_FET_SOURCE_LED: length 1.5
  TOP w0.38: CR7H1.2 95.38,43.68 Q7H1.6
CLN_RST_FET_SOURCE_LED_R: length 1.2
  TOP w0.38: CR7H1.1 95.37,41.15 95.12,40.89 R7H67.2
CML_CFG_STRAP_3: length 164.4
  TOP w0.1: J1E1.1 273.75,73.85 276.74,73.85 281.02,69.57 288.64,69.57 v1(288.92,69.85) ; R1D1.1 298.83,194.31 299.33,194.82 v1(299.33,195.96)
  LAY5 w0.125: v1(288.92,69.85) 288.92,70.29 295.4,76.77 295.4,81.46 297.54,83.6 297.54,119.06 v1(296.97,119.63) ; v1(299.33,195.96) 299.08,196.21 299.08,201.04 v1(298.57,201.55)
  BOTTOM w0.1: v1(296.97,119.63) 296.6,119.63 291.37,124.86 291.37,134.02 294.25,136.9 294.25,163.45 296.03,165.23 296.03,192.66 297.68,194.31 298.57,194.31 299.33,195.07 v1(299.33,195.96)
CNV_BRI_DT: length 32.2
  TOP w0.089: U6E1.AV4 95.65,157.11 95.65,157.13 95.65,157.13 95.65,157.51 95.76,157.62 95.76,158.09 95.71,158.13 95.71,160.02 93.91,161.83 92.39,161.83 89.89,164.34
  TOP w0.1: R7D31.2 R7D35.1 R7D32.2 79.88,175.89 81.86,173.91 86.89,173.91 89.37,171.42 89.37,164.85 89.89,164.34
CNV_BRI_DT_PU: length 12.7
  TOP w0.1: v1(80.89,177.04) 80.39,177.54 R7D32.1
  BOTTOM w0.1: v1(80.89,177.04) 80.89,177.54 81.4,178.05 81.4,185.55 83.18,187.32 J7D3.1
CNV_BRI_DT_R: length 66.4
  TOP w0.1: v1(74.67,235.58) 75.18,235.07 J7C1.36 ; R7D31.1 77.47,177.54 v1(77.21,177.29)
  BOTTOM w0.1: v1(74.67,235.58) 75.13,235.12 75.13,233.25 74.9,233.02 74.9,231.69 73.53,230.32 73.53,225.3 77.47,221.36 77.47,205.11 76.58,204.21 76.58,198.5 77.09,197.99 77.09,193.99 76.42,193.33 76.42,187.33 77.47,186.28 77.47,182.37 76.58,181.47 76.58,179.7 77.72,178.56 77.72,177.8 v1(77.21,177.29)
CNV_BRI_RSP: length 96.3
  TOP w0.089: 88.92,164.51 88.92,163.14 91,161.06 93.6,161.06 94.95,159.71 94.95,158.17 94.86,158.08 U6E1.AY2
  TOP w0.1: R7B75.2 79.62,231.14 78.8,231.14 78.04,231.9 v1(75.43,231.9) ; 88.92,164.51 88.92,171.23 86.7,173.45 81.68,173.45 79.74,175.39 78.03,175.39 76.7,176.72 76.7,179.32 R7D20.1 77.21,180.26 v1(77.47,180.52)
  BOTTOM w0.1: v1(75.43,231.9) 73.76,230.22 73.76,225.39 77.7,221.45 77.7,194.28 76.65,193.23 76.65,187.42 77.69,186.38 77.69,182.27 76.96,181.53 76.96,181.02 v1(77.47,180.52)
CNV_BRI_RSP_R: length 2.9
  TOP w0.1: J7C1.22 78.05,231.57 78.99,230.63 R7B75.1
CNV_GNSS_PA_BLANKING: length 93.6
  TOP w0.089: U6E1.AV6 v1(95,155.98)
  TOP w0.1: R7B58.2 83.05,237.62 v1(83.43,237.23)
  BOTTOM w0.089: 94.38,159.33 95.35,158.36 95.35,156.57 95,156.23 v1(95,155.98)
  BOTTOM w0.1: 94.38,159.33 94.38,160.12 88.75,165.75 88.75,169.56 83.18,175.13 81.28,175.13 79.55,176.85 79.55,179.07 79.12,179.51 79.12,199.01 78.6,199.53 78.6,217.28 82.49,221.17 82.49,222.76 83.18,223.44 83.18,232.15 82.55,232.79 82.55,236.35 v1(83.43,237.23)
CNV_GNSS_PA_BLANKING_R: length 5.1
  TOP w0.1: R7B58.1 81.11,237.07 J7C1.44
CNV_MFUART2_RXD: length 96.8
  TOP w0.089: 89.15,164.7 92.21,161.63 93.83,161.63 95.52,159.94 95.52,157.94 95.52,157.93 U6E1.AW2
  TOP w0.1: 89.15,164.7 89.15,171.33 86.79,173.68 81.77,173.68 79.56,175.89 v1(78.99,175.89) ; v1(81.99,238.3) 81.91,238.3 81.86,238.25 81.23,238.25 80.72,238.76 R7B52.2
  BOTTOM w0.1: v1(81.99,238.3) 81.81,238.13 81.81,233.2 82.95,232.06 82.95,223.54 82.26,222.85 82.26,221.27 78.38,217.38 78.38,199.43 78.86,198.95 78.86,180.91 78.33,180.37 78.33,176.56 v1(78.99,175.89)
CNV_MFUART2_RXD_R: length 2.7
  TOP w0.1: R7B52.1 78.56,238.07 J7C1.48
CNV_MFUART2_TXD: length 98.3
  TOP w0.089: v1(95.68,154.6) U6E1.AU9
  TOP w0.1: v1(80.89,237.89) 80.62,237.62 R7B57.2
  BOTTOM w0.089: v1(95.68,154.6) 95.39,154.6 94.88,155.12 94.88,155.48 94.5,155.86 94.5,156.65 94.5,156.65 94.5,158.91 94.16,159.25
  BOTTOM w0.1: v1(80.89,237.89) 80.89,236.53 81.58,235.84 81.58,233.11 82.73,231.97 82.73,223.63 82.04,222.94 82.04,221.36 78.15,217.47 78.15,199.34 78.61,198.88 78.61,180.97 78.1,180.47 R7P4.2 79.62,173.1 84.83,173.1 88.52,169.41 88.52,165.66 94.16,160.02 94.16,159.25
CNV_MFUART2_TXD_R: length 2.5
  TOP w0.1: R7B57.1 79.2,237.57 J7C1.46
CNV_RGI_DT: length 35.4
  TOP w0.089: 88.69,164.79 88.69,163.09 90.91,160.87 93.52,160.87 94.57,159.82 94.57,158.33 94.43,158.19 94.43,157.25 U6E1.BA4
  TOP w0.1: 88.69,164.79 88.69,171.14 86.61,173.23 79.5,173.23 R7D41.1 76.2,176.53 R7D19.2
CNV_RGI_DT_R: length 61.6
  TOP w0.1: R7D19.1 76.2,180.21 v1(75.81,180.59) ; J7C1.32 75.42,234.07 v1(74.67,234.82)
  BOTTOM w0.1: v1(74.67,234.82) 74.67,231.78 73.3,230.41 73.3,225.2 77.24,221.26 77.24,205.2 76.35,204.31 76.35,198.41 76.86,197.9 76.86,194.08 76.2,193.42 76.2,187.23 77.24,186.19 77.24,182.46 75.81,181.03 v1(75.81,180.59)
CNV_RGI_RSP: length 95.6
  TOP w0.089: 90.24,164.34 92.55,162.03 93.97,162.03 95.91,160.1 95.91,158.21 95.95,158.17 95.95,157.54 95.88,157.48 U6E1.AV3
  TOP w0.1: v1(78.1,235.96) 78.86,236.73 79.88,236.73 80.13,236.47 R7B62.2 ; 90.24,164.34 89.6,164.98 89.6,171.52 86.98,174.13 82.27,174.13 81.35,175.05 81.35,179.14 80.67,179.83 R7D21.1 78.1,180.62 v1(77.47,181.25)
  BOTTOM w0.1: v1(78.1,235.96) 78.1,232.45 79.14,231.41 79.14,228.36 77.47,226.69 77.47,222.76 77.92,222.3 77.92,181.71 v1(77.47,181.25)
CNV_RGI_RSP_R: length 3.2
  TOP w0.1: J7C1.34 77.72,234.57 78.86,235.71 78.86,235.84 R7B62.1
CNV_WR_0_DN: length 95.8
  TOP w0.089: U6E1.BB3 93.42,158.1 93.42,158.27 93.48,158.33 93.48,158.72 92.97,159.24 92.96,159.24 92.92,159.28 92.91,159.28 92.9,159.29
  TOP w0.1: v1(65.98,229.65) 65.98,229.9 66.08,230 66.95,230 67.05,229.9 67.05,229.61 R7B78.1 ; 92.9,159.29 92.45,159.74 90.16,159.74 86.71,163.19 86.71,163.86 85.54,165.03 83.28,165.03 80.44,167.87 80.44,169.23 74.73,174.95 74.73,178.89 72.2,181.41 71.3,181.41 69.59,179.7 68.8,179.7 68.58,179.48 v1(68.58,179.3)
  BOTTOM w0.1: v1(68.58,179.3) 68.58,179.48 68.8,179.7 69.07,179.7 69.28,179.91 69.28,180.39 68.83,180.85 68.1,180.85 67.81,181.13 67.81,190.12 65.98,191.95 65.98,198.71 65.22,199.47 65.22,202.89 65.98,203.65 65.98,225.73 65.42,226.29 65.42,229.86 65.52,229.96 65.66,229.96 v1(65.98,229.65)
CNV_WR_0_DP: length 95.8
  TOP w0.089: U6E1.BB4 93.62,157.62 93.62,158.19 93.67,158.24 93.67,158.8 93.04,159.43
  TOP w0.1: R7B74.1 66.92,230.34 66.78,230.2 66.25,230.2 v1(65.98,230.47) ; v1(68.58,180.1) 68.77,179.9 69.51,179.9 71.21,181.61 72.29,181.61 74.93,178.97 74.93,175.03 80.64,169.32 80.64,167.95 83.37,165.23 85.63,165.23 86.91,163.94 86.91,163.27 90.24,159.94 92.53,159.94 93.04,159.43
  BOTTOM w0.1: v1(68.58,180.1) 68.77,179.9 68.99,179.9 69.08,180 69.08,180.31 68.75,180.65 68.01,180.65 67.61,181.05 67.61,190.03 65.78,191.87 65.78,198.63 65.02,199.39 65.02,202.97 65.78,203.74 65.78,225.65 65.22,226.21 65.22,229.94 65.44,230.16 65.66,230.16 v1(65.98,230.47)
CNV_WR_1_DN: length 95.6
  TOP w0.089: U6E1.BA3 93.82,157.72 93.82,158.09 93.87,158.13 93.87,159.09 93.47,159.49 93.47,159.49 93.42,159.53 93.42,159.53 93.41,159.54
  TOP w0.1: 93.41,159.54 92.78,160.17 90.51,160.17 87.4,163.29 87.4,164.16 85.82,165.74 83.53,165.74 81.2,168.06 81.2,169.44 75.49,175.15 75.49,179.14 72.39,182.24 70.99,182.24 70.64,181.89 69.38,181.89 v1(69.08,181.59) ; R7B83.1 66.92,227.46 66.74,227.64 66.25,227.64 v1(65.98,227.36)
  BOTTOM w0.1: v1(69.08,181.59) 68.78,181.89 68.55,181.89 68.32,182.12 68.32,190.34 67.94,190.72 67.94,196.18 67.84,196.28 66.77,196.28 66.56,196.5 66.56,196.86 66.77,197.08 67.84,197.08 67.94,197.18 67.94,201.78 67.84,201.88 66,201.88 65.78,202.1 65.78,202.46 66,202.68 67.84,202.68 67.94,202.78 67.94,219.43 66.6,220.77 66.6,227.5 66.44,227.66 66.28,227.66 v1(65.98,227.36)
CNV_WR_1_DP: length 95.6
  TOP w0.089: U6E1.BA2 94.06,158.06 94.06,159.17 93.55,159.69
  TOP w0.1: v1(65.98,228.19) 65.98,227.97 66.11,227.84 66.79,227.84 66.92,227.97 R7B80.1 ; v1(69.08,182.39) 69.38,182.09 70.55,182.09 70.91,182.44 72.47,182.44 75.69,179.22 75.69,175.23 81.4,169.52 81.4,168.15 83.61,165.94 85.9,165.94 87.6,164.24 87.6,163.37 90.6,160.37 92.86,160.37 93.55,159.69
  BOTTOM w0.1: v1(69.08,182.39) 68.78,182.09 68.63,182.09 68.52,182.2 68.52,190.43 68.14,190.81 68.14,196.26 67.92,196.48 66.86,196.48 66.76,196.58 66.76,196.78 66.86,196.88 67.92,196.88 68.14,197.1 68.14,201.86 67.92,202.08 66.08,202.08 65.98,202.18 65.98,202.38 66.08,202.48 67.92,202.48 68.14,202.7 68.14,219.51 66.8,220.85 66.8,227.58 66.52,227.86 66.3,227.86 v1(65.98,228.19)
CNV_WR_CLK_DN: length 95.1
  TOP w0.1: R7B72.1 66.92,232.14 66.82,232.24 66.29,232.24 v1(65.98,231.93) ; v1(93.19,156.97) 93,157.16 U6E1.BD4
  BOTTOM w0.1: v1(93.19,156.97) 93.11,157.04 92.37,157.04 92.07,157.34 92.07,158.14 92.45,158.52 92.45,159.51 90.66,161.3 89.26,161.3 84.88,165.68 83.89,165.68 77.94,171.63 75.86,171.63 69.77,177.72 69.77,191.05 69.54,191.28 69.54,198.17 69.44,198.27 68.93,198.27 68.72,198.49 68.72,198.86 68.93,199.07 69.44,199.07 69.54,199.17 69.54,199.37 69.44,199.47 68.98,199.47 68.77,199.69 68.77,200.06 68.98,200.27 69.44,200.27 69.54,200.37 69.54,219.86 68.87,220.52 68.65,220.52 67.31,221.87 67.31,231.49 66.55,232.25 66.29,232.25 66.29,232.24 v1(65.98,231.93)
CNV_WR_CLK_DP: length 95.1
  TOP w0.1: v1(92.87,157.69) 92.47,157.69 U6E1.BE3 ; R7B71.1 66.92,232.59 66.77,232.44 66.29,232.44 v1(65.98,232.76)
  BOTTOM w0.1: v1(65.98,232.76) 66.29,232.45 66.63,232.45 67.51,231.57 67.51,221.95 68.73,220.72 68.96,220.72 69.74,219.94 69.74,200.29 69.52,200.07 69.07,200.07 68.97,199.97 68.97,199.77 69.07,199.67 69.52,199.67 69.74,199.46 69.74,199.09 69.52,198.87 69.02,198.87 68.92,198.77 68.92,198.57 69.02,198.47 69.52,198.47 69.74,198.26 69.74,191.37 69.97,191.13 69.97,177.8 75.94,171.83 78.03,171.83 83.97,165.88 84.96,165.88 89.35,161.5 90.74,161.5 92.65,159.59 92.65,158.44 92.27,158.06 92.27,157.42 92.45,157.24 92.77,157.24 92.87,157.34 v1(92.87,157.69)
CNV_WR_R_0_DN: length 2.8
  TOP w0.1: J7C1.15 69.4,229.82 69.26,229.96 68.29,229.96 R7B78.2
CNV_WR_R_0_DP: length 2.8
  TOP w0.1: J7C1.17 69.4,230.32 69.24,230.16 68.28,230.16 R7B74.2
CNV_WR_R_1_DN: length 3.3
  TOP w0.1: R7B83.2 68.29,227.68 68.67,227.68 68.96,227.96 68.96,228.34 69.09,228.47 69.25,228.47 69.4,228.32 J7C1.9
CNV_WR_R_1_DP: length 3.3
  TOP w0.1: J7C1.11 69.4,228.82 69.25,228.67 69.01,228.67 68.76,228.42 68.76,228.05 68.59,227.88 68.28,227.88 R7B80.2
CNV_WR_R_CLK_DN: length 3.3
  TOP w0.1: R7B72.2 67.81,232.13 67.94,232.26 68.22,232.26 69.01,231.47 69.25,231.47 69.4,231.32 J7C1.21
CNV_WR_R_CLK_DP: length 3.3
  TOP w0.1: R7B71.2 67.81,232.56 67.92,232.46 68.3,232.46 69.09,231.67 69.25,231.67 69.4,231.82 J7C1.23
CNV_WT_0_DN: length 105.8
  TOP w0.089: 89.8,156.45 90.62,155.62 92.21,155.62 92.29,155.7 U6E1.BE6
  TOP w0.1: R7B43.1 67.16,242.05 67.16,242.21 67.01,242.37 66.17,242.37 65.98,242.18 v1(65.98,241.96) ; v1(71.78,178.86) 71.78,178.73 72.12,178.38 72.82,178.38 73.53,177.67 73.53,174.5 79.19,168.83 79.19,167.49 82.83,163.85 83.82,163.85 85.52,162.16 85.52,159.36 86.64,158.24 88.01,158.24 89.8,156.45
  BOTTOM w0.1: v1(71.78,178.86) 72.07,178.56 72.86,178.56 73.2,178.9 73.2,186.22 72.44,186.99 72.44,195.02 73.27,195.86 73.27,221.46 69.46,225.27 69.46,234.06 67.18,236.34 67.18,241.55 66.44,242.29 66.3,242.29 v1(65.98,241.96)
CNV_WT_0_DP: length 105.8
  TOP w0.089: U6E1.BD7 92.6,155.43 90.55,155.43 89.73,156.25 89.72,156.25 89.68,156.29 89.67,156.29 89.66,156.31
  TOP w0.1: v1(65.98,242.79) 66.2,242.57 66.54,242.57 R7B40.1 ; v1(71.78,178.06) 71.89,178.18 72.74,178.18 73.33,177.59 73.33,174.41 78.99,168.75 78.99,167.41 82.75,163.65 83.74,163.65 85.32,162.08 85.32,159.28 86.56,158.04 87.92,158.04 89.66,156.31
  BOTTOM w0.1: v1(65.98,242.79) 66.28,242.49 66.53,242.49 67.38,241.63 67.38,236.43 69.66,234.14 69.66,225.35 73.47,221.54 73.47,195.78 72.64,194.94 72.64,187.07 73.4,186.3 73.4,178.81 72.95,178.36 72.07,178.36 v1(71.78,178.06)
CNV_WT_1_DN: length 105.8
  TOP w0.089: 90.26,156.78 91.02,156.02 91.26,156.02 U6E1.BG6
  TOP w0.1: R7B51.1 67.11,239.71 67.11,239.9 66.93,240.08 66.17,240.08 65.98,239.89 v1(65.98,239.68) ; 90.26,156.78 87.91,159.13 86.87,159.13 86.23,159.77 86.23,163.32 85.01,164.54 83.1,164.54 79.95,167.69 79.95,169.04 74.24,174.75 74.24,178.61 72.71,180.14 72.23,180.14 71.78,180.59 v1(71.78,180.74)
  BOTTOM w0.1: v1(71.78,180.74) 71.78,180.52 71.9,180.39 72.14,180.39 72.31,180.57 72.31,181.88 72.21,181.98 71.6,181.98 71.38,182.19 71.38,182.56 71.6,182.78 72.21,182.78 72.31,182.88 72.31,183.08 72.21,183.18 71.6,183.18 71.38,183.39 71.38,183.76 71.6,183.98 72.21,183.98 72.31,184.08 72.31,184.28 72.21,184.38 71.35,184.38 71.13,184.59 71.13,184.96 71.35,185.18 72.21,185.18 72.31,185.28 72.31,186.1 71.75,186.66 71.75,195.35 72.41,196.02 72.41,196.44 71.75,197.1 71.75,221.97 68.75,224.96 68.75,233.6 66.47,235.88 66.47,239.83 66.35,239.96 66.25,239.96 v1(65.98,239.68)
CNV_WT_1_DP: length 105.8
  TOP w0.089: U6E1.BF6 91.58,155.83 90.94,155.83 90.19,156.58 90.18,156.58 90.14,156.63 90.13,156.63 90.12,156.64
  TOP w0.1: 90.12,156.64 87.83,158.93 86.79,158.93 86.03,159.69 86.03,163.24 84.93,164.34 83.02,164.34 79.75,167.6 79.75,168.96 74.04,174.67 74.04,178.53 72.63,179.94 v1(71.78,179.94) ; R7B47.1 66.54,240.28 66.2,240.28 v1(65.98,240.51)
  BOTTOM w0.1: v1(65.98,240.51) 66.33,240.16 66.43,240.16 66.67,239.91 66.67,235.96 68.95,233.68 68.95,225.05 71.95,222.05 71.95,197.19 72.61,196.52 72.61,195.93 71.95,195.27 71.95,186.74 72.51,186.18 72.51,185.19 72.3,184.98 71.43,184.98 71.33,184.88 71.33,184.68 71.43,184.58 72.3,184.58 72.51,184.36 72.51,183.99 72.3,183.78 71.68,183.78 71.58,183.68 71.58,183.48 71.68,183.38 72.3,183.38 72.51,183.16 72.51,182.79 72.3,182.58 71.68,182.58 71.58,182.48 71.58,182.28 71.68,182.18 72.3,182.18 72.51,181.96 72.51,180.48 72.22,180.19 72.02,180.19 v1(71.78,179.94)
CNV_WT_CLK_DN: length 106.5
  TOP w0.1: v1(65.98,244.25) 65.98,244.47 66.17,244.65 67.01,244.65 67.14,244.52 67.14,244.31 R7B37.1 ; U6E1.BC5 v1(93.94,156.32)
  BOTTOM w0.1: v1(93.94,156.32) 93.94,156.65 93.94,157.09 93.94,158.32 93.59,158.67 93.59,159.67 91.05,162.21 89.6,162.21 85.06,166.75 84.1,166.75 78.23,172.62 76.17,172.62 70.65,178.13 70.65,190.52 71.19,191.05 71.19,221.82 68.27,224.74 68.27,233.35 65.42,236.19 65.42,244.51 65.56,244.65 65.79,244.65 65.98,244.46 v1(65.98,244.25)
CNV_WT_CLK_DP: length 106.5
  TOP w0.1: v1(65.98,245.08) 66.2,244.85 66.54,244.85 R7B35.1 ; U6E1.BB6 v1(93.39,155.78)
  BOTTOM w0.1: v1(65.98,245.08) 65.75,244.85 65.48,244.85 65.22,244.6 65.22,236.11 68.07,233.27 68.07,224.66 70.99,221.74 70.99,191.13 70.45,190.6 70.45,178.05 76.09,172.42 78.15,172.42 84.01,166.55 84.98,166.55 89.52,162.01 90.97,162.01 93.39,159.58 93.39,158.58 93.74,158.24 93.74,157.09 93.74,156.76 93.39,156.41 93.39,156.26 v1(93.39,155.78)
CNV_WT_R_0_DN: length 3
  TOP w0.1: J7C1.65 69.4,242.32 69.25,242.47 68.73,242.47 68.54,242.28 68.04,242.28 67.81,242.06 R7B43.2
CNV_WT_R_0_DP: length 3
  TOP w0.1: J7C1.67 69.4,242.82 69.25,242.67 68.65,242.67 68.46,242.48 68.02,242.48 67.81,242.7 R7B40.2
CNV_WT_R_1_DN: length 3.6
  TOP w0.1: R7B51.2 67.81,239.77 68.03,239.99 68.63,239.99 68.9,240.26 68.9,240.79 69.08,240.97 69.25,240.97 69.4,240.82 J7C1.59
CNV_WT_R_1_DP: length 3.6
  TOP w0.1: J7C1.61 69.4,241.32 69.25,241.17 69,241.17 68.7,240.87 68.7,240.34 68.55,240.19 68.03,240.19 67.81,240.41 R7B47.2
CNV_WT_R_CLK_DN: length 3.2
  TOP w0.1: R7B37.2 67.81,244.36 68.03,244.57 68.32,244.57 68.92,243.97 69.25,243.97 69.4,243.82 J7C1.71
CNV_WT_R_CLK_DP: length 3.2
  TOP w0.1: R7B35.2 67.81,244.96 68,244.77 68.4,244.77 69.01,244.17 69.25,244.17 69.4,244.32 J7C1.73
CNV_WT_RCOMP: length 8.9
  TOP w0.089: 91.05,160.62 93.25,160.62 94.32,159.54 U6E1.BA1
  TOP w0.1: 91.05,160.62 90.78,160.62 88.26,163.14 R7D51.1
CNVI_EN: length 8.2
  TOP w0.1: R7B6.2 68.19,259.46 v1(67.51,260.14) 67.04,260.62 Q7A1.2 Q7A1.5
  BOTTOM w0.1: v1(67.51,260.14) 67.51,259.76 69.72,257.55 Q7B2.3
CNVI_EN_N: length 103
  BOTTOM w0.1: R7A9.2 R7A8.1 72.57,261.36 73.1,260.83 73.1,259.12 79.22,253.01 79.54,253.01 84.87,247.68 84.87,242.23 84.58,241.93 84.58,224.08 85.29,223.36 85.29,198.97 83.55,197.23 81.15,197.23 80.01,196.09 80.01,193.67 81.07,192.61 84.32,192.61 85,191.93 85,177 85.59,176.4 R7P1.1
CNVI_EN_PCH_N: length 28.5
  TOP w0.089: U6E1.AR13 v1(96.65,152.37)
  BOTTOM w0.089: 95.12,159.72 95.94,158.9 95.94,156.35 95.82,156.24 95.82,155.73 96.2,155.35 96.2,155.02 96.57,154.66 96.57,154.52 96.9,154.19 96.9,153.76 97.09,153.57 97.09,152.8 v1(96.65,152.37)
  BOTTOM w0.1: R7P1.2 85.59,174.54 89.79,170.34 89.79,166.29 93.09,162.99 93.09,162.81 95.12,160.78 95.12,159.72
CODEC_1P8PWR_EN: length 9.1
  TOP w0.1: R6A25.2 R6A26.2 R6A27.2 104.26,280.29 R6A85.2 104.77,280.92 104.77,282.83 105.15,283.21 106.55,283.21 106.93,282.83 107.69,282.83 R6A19.1
CODEC_5V_3P3_PWR_EN: length 82.8
  TOP w0.1: v1(102.74,283.97) 101.98,283.21 R6A20.2 R6A21.2 R6A22.2 R6A87.2 105.15,283.59 R6A13.1 ; R8A9.1 v1(32.25,286)
  LAY5 w0.125: v1(102.74,283.97) 102.74,286.38 98.67,290.45 62.1,290.45 57.78,286.13 34.41,286.13 34.03,286.51 32.76,286.51 v1(32.25,286)
CODEC_CBN: length 8.6
  TOP w0.2: EU6A1.24 127.05,280.84 127.25,281.04 127.25,281.68 R6A17.1 129.55,283.99 130.28,283.99 130.42,283.84 130.42,281.3 C6A14.2
CODEC_CBN2: length 3
  TOP w0.2: EU6A1.22 127.38,280.04 128.39,281.05 128.39,281.25 128.83,281.68 R6A23.1
CODEC_CBP: length 2.7
  TOP w0.2: EU6A1.21 127.44,279.64 127.86,280.06 128.29,280.06 C6A14.1
CODEC_CBP2: length 3.3
  TOP w0.2: EU6A1.23 127.27,280.44 127.63,280.8 127.63,281.18 C6A9.1
CODEC_CBP_ES1_ES2: length 1.8
  TOP w0.2: R6A23.2 C6A9.2 R6A17.2
CODEC_CC1: length 5.2
  TOP w0.1: R6A49.1 R6A42.2 120.04,275.11 121.82,275.11 122.15,275.44 EU6A1.2
CODEC_CC2: length 4.1
  TOP w0.1: EU6A1.1 121.75,275.55 121.53,275.33 R6A37.2 R6A38.1
CODEC_DMIC0_CLK_R: length 111.4
  TOP w0.1: R8B4.1 28.06,257.68 v1(28.57,257.17)
  LAY8 w0.1: v1(127.76,268.73) 126.71,269.78 116.78,269.78 115.38,268.38 94.03,268.38 92.64,269.78 88.84,269.78 86.81,267.75 71.06,267.75 65.22,261.91 42.99,261.91 41.21,260.13 37.14,260.13 35.99,261.27 33.85,261.27 32.32,259.75 30.16,259.75 28.57,258.15 v1(28.57,257.17)
  BOTTOM w0.1: v1(127.76,268.73) 127.5,268.98 C6L2.1 126.36,269.49
CODEC_DMIC1_CLK_R: length 126.7
  TOP w0.1: R8B16.1 v1(23.74,242.7)
  LAY8 w0.1: v1(23.74,242.7) 23.74,254 29.97,260.22 32.13,260.22 33.65,261.75 36.19,261.75 37.33,260.6 41.02,260.6 42.79,262.38 65.02,262.38 70.86,268.22 86.61,268.22 88.64,270.25 92.83,270.25 94.23,268.86 115.18,268.86 116.58,270.25 125.73,270.25 v1(126.61,271.14)
  BOTTOM w0.1: 126.36,270.38 C6L1.1 126.74,271.14 v1(126.61,271.14)
CODEC_DMIC2_DATA: length 130.1
  TOP w0.1: R8B13.1 25.27,246.76 v1(27.17,248.66) ; R6A48.2 v1(129.41,271.91)
  LAY5 w0.125: v1(129.41,271.91) 128.65,272.67 124.84,272.67 124.83,272.68 123.07,272.68 121.02,270.63 115.98,270.63 115.19,271.41 111.14,271.41 108.46,268.74 94.98,268.74 93.98,269.75 93.98,270.09 93.15,270.91 88.93,270.91 88.37,270.34 88.37,269.58 87.02,268.24 85.37,268.24 84.22,269.39 68.31,269.39 66.52,271.18 47.12,271.18 v1(47.11,271.2)
  LAY6 w0.125: v1(47.11,271.2) 47.62,270.69 47.62,268.22 45.1,265.71 44.75,265.71 43.58,264.54 39.24,264.54 38.6,263.9 38.6,263.27 36.58,261.25 30.49,261.25 29.65,260.41 29.65,254.83 27.17,252.35 v1(27.17,248.66)
CODEC_DMIC_CLK: length 8.3
  TOP w0.1: EU6A1.7 124.15,274.63 124.58,274.19 124.71,274.19 R6A45.1 125.09,273.56 124.84,273.3 124.84,271.4 v1(125.09,271.14) 125.34,270.89 R6A62.2
  BOTTOM w0.1: R6L2.1 R6L1.1 125.47,270.76 v1(125.09,271.14)
CODEC_DMIC_DATA: length 122.9
  TOP w0.1: v1(27.05,252.98) 26.79,252.73 R8B11.1 ; EU6A1.6 123.75,274.14 R6A44.1 124.2,273.56 123.82,273.18 123.82,271.65 v1(124.33,271.14) R6A61.2
  LAY5 w0.125: v1(47.11,270.51) 47.32,270.71 62.73,270.71 63.53,269.91 67.43,269.91 68.21,269.14 81.26,269.14 82.41,267.99 87.13,267.99 88.62,269.48 88.62,270.24 89.04,270.66 93.05,270.66 93.72,269.98 93.72,269.64 94.88,268.49 108.57,268.49 111.24,271.16 115.09,271.16 115.87,270.38 121.13,270.38 122.28,271.54 123.93,271.54 v1(124.33,271.14)
  LAY6 w0.125: v1(27.05,252.98) 28.44,254.38 28.44,255.27 29.15,255.97 29.15,260.62 30.28,261.75 36.37,261.75 38.1,263.48 38.1,264.11 39.03,265.04 43.37,265.04 44.54,266.21 44.89,266.21 45.59,266.9 45.59,270 46.1,270.51 v1(47.11,270.51)
CODEC_ES1_MIC2_VREFO_L: length 2.9
  TOP w0.2: EU6A1.28 124.95,282.66 125.27,282.98 125.88,282.98 R6A16.1
CODEC_ES1_MIC2_VREFO_R: length 2.3
  TOP w0.2: EU6A1.29 124.55,282.74 125.27,283.46 R6A15.1
CODEC_GPIO2_DMIC_DATA2: length 6
  TOP w0.2: R6A51.2 R6A48.1 129.41,274.06 R6A39.1 128.77,274.45 127.76,275.46 127.76,276.73 127.25,277.24 EU6A1.15
CODEC_HD_SDW_SEL: length 6.5
  TOP w0.1: R6A54.2 122.17,271.27 121.41,271.27 121.08,271.6 121.08,273.1 R6A43.1 121.53,273.94 122.95,275.35 EU6A1.4
CODEC_HPOUT-L: length 33.3
  TOP w0.2: EU6A1.27 125.35,282.32 v1(125.47,282.45) ; R5A8.1 v1(148.46,280.67) 148.46,279.91 C5A10.2
  BOTTOM w0.2: v1(148.46,280.67) 147.32,281.81 147.32,284.48 147.06,284.73 147.06,285.49 144.27,288.29 133.47,288.29 128.14,282.95 125.98,282.95 v1(125.47,282.45)
CODEC_HPOUT-R: length 44
  TOP w0.2: R5A14.1 C5A9.2 157.09,278.81 157.68,279.4 v1(157.68,279.42) ; v1(129.54,286) 128.39,286 127.12,284.73 127.12,283.34 125.75,281.96 EU6A1.26
  BOTTOM w0.2: v1(129.54,286) 132.84,289.3 146.64,289.3 148.59,287.36 148.59,285.75 149.73,284.61 149.73,283.84 154.15,279.42 v1(157.68,279.42)
CODEC_INT_N: length 327.4
  TOP w0.1: R7F27.2 94.23,116.46 94.74,115.95 94.74,114.39 92.2,111.85 92.2,110.36 92.41,110.14 92.41,108.55 92.17,108.3 92.17,107.72 92.58,107.31 92.58,104.77 v1(91.31,103.5) ; v1(17.9,263.37) 23.4,263.37 24.91,264.88 Q8A1.2
  LAY5 w0.125: v1(17.9,263.37) 18.54,262.73 18.54,253.49 17.01,251.96 17.01,218.7 18.54,217.17 18.54,209.17 17.84,208.47 17.84,205.8 18.16,205.48 18.16,180.08 19.33,178.91 19.33,171.57 19.78,171.12 19.78,169.11 18.15,167.49 18.15,160.4 25.5,153.05 25.5,135.37 26.74,134.14 26.74,130.61 29.46,127.89 29.46,127.1 28.95,126.59 28.95,125.12 29.71,124.36 29.71,123.24 29.04,122.56 28.65,122.56 27.8,121.71 27.8,116.8 29.71,114.89 29.71,112.27 29.96,112.02 29.96,109.98 30.68,109.26 30.68,99.24 30.22,98.78 30.22,92.13 28.08,89.99 28.08,88.82 27.41,88.15 27.41,82.89 28.19,82.11 28.19,80.88 28.84,80.23 28.84,75.54 28.47,75.17 28.47,73.3 26.31,71.14 26.31,66.71 28.82,64.19 33.66,64.19 34.1,63.76 36.2,63.76 36.96,64.52 36.96,65.26 38.99,67.3 38.99,69.63 40.89,71.53 40.89,72.4 44.3,75.81 45.29,75.81 45.67,75.43 50.57,75.43 51.57,76.43 52.48,76.43 54.17,78.12 55.24,78.12 55.78,78.66 59.48,78.66 60.7,79.88 64.59,79.88 65.22,80.52 65.98,80.52 66.49,80.01 69.75,80.01 70.51,80.77 73.4,80.77 75.7,83.07 80.07,83.07 81.22,84.21 82.14,84.21 82.64,84.71 84.94,84.71 90.8,90.58 90.8,91.64 90.85,91.69 90.85,103.05 v1(91.31,103.5)
CODEC_IRQ_HDR: length 2
  TOP w0.1: Q8A1.3 26.63,264.12 R8A29.1
CODEC_IRQ_HDR_R: length 6.1
  TOP w0.1: J9A5.7 20.95,263.14 23.49,263.14 23.87,263.52 R8A29.2
CODEC_JD1: length 63.6
  TOP w0.2: EU6A1.48 120.99,276.44 120.77,276.22 v1(120.77,275.84) ; v1(162.43,281.43) 162.56,281.56 R5A7.2 162.56,282.45 162.17,282.83 R5A6.1 R5A5.1
  BOTTOM w0.2: v1(162.43,281.43) 160.9,281.43 160.02,280.54 160.02,280.16 158.49,278.64 152.27,278.64 152.01,278.38 147.32,278.38 146.43,279.27 146.43,283.46 146.17,283.72 146.17,284.73 143.63,287.27 134.49,287.27 128.65,281.43 124.46,281.43 123.69,282.19 120.65,282.19 119.63,281.18 119.63,277.49 120.77,276.35 v1(120.77,275.84)
CODEC_JD1_R: length 3.8
  TOP w0.2: R5A3.2 R5A5.2 162.3,285.11 R5A2.1 162.17,286.13 C5A1.1 C5A2.1
CODEC_JD2: length 3
  TOP w0.1: EU6A1.47 120.75,276.84 120.26,276.35 120.26,276.1 120.01,275.84 118.99,275.84 R6A36.2
CODEC_MIC2-VREFO-L: length 6.2
  TOP w0.2: EU6A1.30 124.15,282.82 124.84,283.51 124.84,285.37 R6A8.1 125.47,285.88 R6A2.1
CODEC_MIC2_VREFO_R: length 4.9
  TOP w0.2: EU6A1.31 123.75,283.26 R6A14.1 124.46,283.97 124.46,285.37 R6A7.1
CODEC_MIC_CAP: length 2.8
  TOP w0.2: EU6A1.34 122.55,282.58 122.17,282.95 121.66,282.95 R6A10.2
CODEC_MIC_CAP_R: length 5.4
  TOP w0.2: C6A2.2 120.78,285.11 v1(121.15,285.11) R6A10.1 ; R6A12.1 v1(123.19,285.11)
  BOTTOM w0.2: v1(123.19,285.11) 122.68,285.62 121.66,285.62 v1(121.15,285.11)
CODEC_RTC_CLK: length 2.2
  TOP w0.1: R6A53.1 115.82,273.71 Y6A1.3
CODEC_RTC_CLK_EN: length 3.6
  TOP w0.1: R6A33.2 R6A32.1 113.91,277.42 Y6A1.1
CODEC_RTC_CLK_SUS_CLK: length 11.8
  TOP w0.1: EU6A1.3 122.55,275.33 121.15,273.94 120.5,273.94 120.07,273.51 120.07,272.22 119.38,271.53 116.58,271.53 116.07,272.03 115.44,272.03 R6A53.2 R6A52.2
CORE_SPKR_R: length 2.7
  TOP w0.38: R9G31.2 C9G5.1 Q9G5.1
CPU_2_PCH_TRIGGER: length 186.1
  TOP w0.089: U6E1.AK2 99.91,157.92 99.96,157.96 99.96,159.81 99.96,159.99 99.87,160.08 99.87,161.83 99.87,162.53 98.67,163.74 98.67,164.46
  TOP w0.1: R4C12.2 176.49,214.6 174.3,214.6 173.17,215.73 173.17,225.52 172.18,226.5 172.18,229.39 171.57,230 170.04,230 169.54,230.5 v1(169.54,231.65) ; v1(134.62,215.01) 130.04,215.01 128.79,213.76 126.65,213.76 125.41,214.99 124.4,214.99 124.12,214.71 122.33,214.71 121.97,214.34 118.49,214.34 117.97,213.83 101.82,213.83 94.78,206.79 94.78,192.31 94.11,191.64 94.11,187.36 94.66,186.82 94.66,185.85 91.23,182.42 91.23,176.77 98.06,169.94 98.06,165.46 98.67,164.85 98.67,164.46
  BOTTOM w0.1: v1(169.54,231.65) 168.76,232.43 168.76,233.46 166.44,235.78 161.85,235.78 161.16,236.47 157.98,236.47 155.7,238.75 155.7,239.53 155.35,239.88 154.48,239.88 152.7,241.66 147.93,241.66 146.93,240.66 145.41,240.66 144.39,241.68 140.84,241.68 139.82,240.66 138.81,240.66 137.6,239.46 137.6,235.66 135.45,233.51 135.45,215.84 v1(134.62,215.01)
CPU_2_PCH_TRIGGER_R: length 48.2
  TOP w0.089: J3D1.D12 213.91,196.62 213.91,199.2 213.61,199.5 213.61,203.2
  TOP w0.1: 213.61,203.2 213.61,203.73 207.84,209.51 194.7,209.51 193.22,210.99 182.65,210.99 178.63,215.01 R4C12.1
CPU_24MHZ_R_DN: length 106.1
  TOP w0.089: J3D1.U7 v1(208.52,184.83)
  TOP w0.1: v1(144.67,153.24) 144.67,153.06 144.57,152.96 142.06,152.96 R5E15.2
  BOTTOM w0.089: v1(208.52,184.83) 208.89,184.83 209.04,184.99 209.04,185.16 208.91,185.29 208.03,185.29 207.85,185.48 205.29,185.48 204.85,185.93 202.31,185.93 201.88,185.5 201.27,185.5
  BOTTOM w0.1: 201.27,185.5 191.46,185.5 189.66,187.3 184.5,187.3 183.2,186 181.43,186 180.67,186.76 177.12,186.76 174.75,189.13 174.75,190.68 174.09,191.33 172.47,191.33 171.74,192.06 169.56,192.06 168.02,190.52 168.02,189.61 166.16,187.75 159.45,187.75 157.16,185.46 157.16,181.77 158.11,180.82 158.11,178.81 156.51,177.22 156.51,173.44 155.37,172.29 155.37,169.25 154.88,168.75 154.19,168.75 153.02,167.58 152.06,167.58 149.35,164.88 148.87,164.88 147.37,163.38 147.37,162.03 144.65,159.31 144.65,154.02 145.28,153.39 145.28,153.06 145.11,152.88 144.82,152.88 144.67,153.03 v1(144.67,153.24)
CPU_24MHZ_R_DP: length 106.1
  TOP w0.089: J3D1.U8 v1(209.44,184.83)
  TOP w0.1: v1(144.67,152.42) 144.33,152.76 142.09,152.76 R5E19.2
  BOTTOM w0.089: v1(209.44,184.83) 209.01,184.4 208.35,184.4 208.07,184.68 208.07,184.99 207.77,185.29 205.21,185.29 204.77,185.74 202.38,185.74 201.95,185.31 201.42,185.31 201.41,185.3 201.29,185.3
  BOTTOM w0.1: 201.29,185.3 191.38,185.3 189.58,187.1 184.58,187.1 183.28,185.8 181.35,185.8 180.59,186.56 177.03,186.56 174.55,189.05 174.55,190.6 174.01,191.13 172.38,191.13 171.65,191.86 169.64,191.86 168.22,190.44 168.22,189.53 166.24,187.55 159.53,187.55 157.36,185.38 157.36,181.85 158.31,180.9 158.31,178.73 156.71,177.13 156.71,173.35 155.57,172.21 155.57,169.16 154.96,168.55 154.27,168.55 153.11,167.38 152.14,167.38 149.44,164.68 148.95,164.68 147.57,163.29 147.57,161.95 144.85,159.23 144.85,154.1 145.48,153.47 145.48,152.97 145.19,152.68 144.94,152.68 v1(144.67,152.42)
CPU_C10_GATE_N: length 68.7
  TOP w0.089: v1(89.97,162.75) 91.47,161.25 93.68,161.25 95.14,159.79 95.14,158.09 95.09,158.05 95.09,157.7 95.03,157.64 95.03,157.58 94.86,157.4 U6E1.AY3
  TOP w0.1: v1(45.08,169.92) 45.08,170.18 44.46,170.8 U8D7.2 ; v1(56.89,167.13) 57.91,168.15 61.52,168.15 65.63,172.26 67.66,172.26 v1(72.64,177.24)
  BOTTOM w0.1: v1(45.08,169.92) 45.33,169.92 46.48,168.78 53.21,168.78 53.67,168.32 53.67,167.69 53.84,167.51 54.35,167.51 54.61,167.77 55.38,167.77 55.86,167.29 56.73,167.29 v1(56.89,167.13) ; v1(89.97,162.75) 89.74,162.75 88.48,164.01 88.48,165.06 86.23,167.31 84.22,167.31 78.05,173.48 76.4,173.48 v1(72.64,177.24)
CPU_FAN_CTRL_OUT: length 8.9
  TOP w0.1: R9C10.1 16.12,210.44 16.89,211.2 16.89,211.83 16.45,212.27 16.45,214.55 15.88,215.13 Q9C1.2
CPU_FAN_DRIVER: length 4.8
  TOP w0.2: R1E33.1 299.21,145.79 J1E3.1
CPU_FAN_DRIVER_GATE: length 3.6
  TOP w0.1: R9C1.1 Q9C1.1
CPU_FAN_OUT: length 527.8
  TOP w0.1: v1(17.65,215.39) 16,215.39 Q9C1.3
  LAY5 w0.125: v1(302.76,217.93) 303.4,218.57 303.4,268.55 300.81,271.14 294.56,271.14 294.05,270.63 290.29,270.63 289.78,271.14 282.12,271.14 281.44,271.82 278.31,271.82 275.86,274.27 274.12,274.27 273.86,274.01 268.22,274.01 267.77,274.47 266.16,274.47 264.06,276.58 257.44,276.58 256.92,277.1 256.92,277.62 256.28,278.26 253.49,278.26 252.72,277.49 250.31,277.49 249.8,276.98 239.75,276.98 239.49,277.24 231.37,277.24 231.12,277.49 229.48,277.49 229.23,277.24 225.84,277.24 224.59,275.98 222.59,275.98 219.34,272.74 210.42,272.74 205.1,278.05 205.1,284.83 203.05,286.89 199.11,286.89 197.71,288.29 177.82,288.29 176.6,287.07 176.6,285.44 178.56,283.49 178.56,281.3 176.4,279.15 172.42,279.15 171.15,277.88 168.47,277.88 166.83,279.52 163.36,279.52 162.68,278.83 162.68,277.18 161.59,276.1 147.39,276.1 143.71,279.77 143.71,283.58 142.61,284.69 136.91,284.69 135.88,283.66 135.88,280.23 133.59,277.94 133.59,275.28 133.21,274.89 133.21,272.78 132.16,271.72 131.18,271.72 130.16,270.7 130.16,268.08 129.03,266.95 122.8,266.95 122.29,267.46 117.47,267.46 117,267 115.44,267 114.75,266.31 111.98,266.31 110.53,264.87 109.01,264.87 107.41,263.27 105.68,263.27 105.15,263.8 105.15,265.07 104.19,266.03 102.84,266.03 102.36,265.56 102.36,264.16 101.6,263.4 98.8,263.4 98.66,263.54 90.08,263.54 89.94,263.4 89.15,263.4 86.86,265.68 81.6,265.68 79.65,267.63 68.49,267.63 67.94,267.08 66.29,267.08 64.73,268.63 50.19,268.63 49.27,267.71 45.21,267.71 44.25,268.67 42.22,268.67 41.78,269.11 41.78,269.62 40,271.4 v1(38.73,271.4)
  LAY6 w0.125: v1(17.65,215.39) 16.63,216.41 16.63,223.39 18.66,225.42 18.66,232.15 16.63,234.19 16.63,244.4 17.27,245.04 17.27,245.86 18.41,247.01 18.41,257.04 17.5,257.96 17.5,259.05 18.66,260.22 18.66,269.87 19.3,270.51 20.3,270.51 21.3,271.51 22.46,271.51 23.36,272.41 23.36,273.56 24.23,274.42 25.93,274.42 29.59,270.76 38.1,270.76 v1(38.73,271.4) ; v1(302.76,217.93) 303.4,217.3 303.4,157.6 J1E3.4
CPU_FAN_TACH: length 677.7
  TOP w0.1: R1E18.2 R1E17.1 295.14,154.68 C1E5.1 v1(298.45,155.19) ; U8F6.40 19.55,101.89 19.97,101.47 24.89,101.47 v1(25.14,101.22) ; J6J2.48 v1(117.93,10.54)
  LAY3 w0.1: v1(25.14,101.22) 25.01,101.22 22.98,99.19 22.98,98.04 18.66,93.72 18.66,88.52 16.98,86.83 16.98,83.97 14.83,81.82 14.83,73.76 12.57,71.5 12.57,64.77 10.51,62.71 10.51,51.26 12.44,49.33 12.44,38.79 18.35,32.89 19.55,32.89 21.97,30.48 22.35,30.48 26.22,26.6 26.22,24.68 28.46,22.44 28.46,21.18 31.1,18.54 53.81,18.54 54.44,17.91 55.9,17.91 56.66,18.67 57.65,18.67 58.41,17.91 60.25,17.91 60.8,18.46 63.22,18.46 65,16.68 68.99,16.68 69.29,16.99 72.36,16.99 73.3,17.93 83.93,17.93 86.08,15.78 107.04,15.78 109.06,13.77 109.06,13.47 112.27,10.26 113.26,10.26 113.74,9.78 117.47,9.78 117.93,10.24 v1(117.93,10.54)
  LAY5 w0.125: v1(25.65,24.76) 38.6,24.76 39.77,23.59 46.77,23.59 47.24,23.12 49.95,23.12 50.98,24.15 50.98,24.36 52.39,25.78 60.93,25.78 62.17,24.54 66.27,24.54 67,25.27 84.82,25.27 87.23,22.86 87.98,22.86 88.87,21.97 98.82,21.97 99.59,22.73 101.32,22.73 101.57,22.48 106.17,22.48 107.56,23.87 109.34,23.87 110.86,25.39 121.77,25.39 122.78,24.38 124.86,24.38 125.88,25.39 129.37,25.39 131.22,27.24 132.95,27.24 136.83,31.11 149.24,31.11 163.15,45.02 165.89,45.02 168.17,47.31 182.08,47.31 185.29,50.52 192.63,50.52 193.23,51.11 194.8,51.11 197.07,53.39 197.07,54.21 198,55.14 198,57.98 198.83,58.81 200.86,58.81 201.33,59.28 211.1,59.28 213.77,56.6 216.7,56.6 218.3,55 218.3,54.01 223.15,49.16 231.54,49.16 233.27,50.89 234.91,50.89 237.09,53.08 249.97,53.08 252.03,55.13 261.96,55.13 263.97,57.15 268.73,57.15 270.28,58.7 273.38,58.7 279.87,65.2 281.3,65.2 284.11,68.01 287.76,68.01 289.58,69.82 289.58,70.59 295.66,76.67 295.66,81.36 297.79,83.5 297.79,121.15 294.95,123.99 294.95,128.86 296.03,129.94 296.03,131.82 296.31,132.1 296.31,151.79 298.45,153.92 v1(298.45,155.19)
  LAY6 w0.125: v1(25.65,24.76) 26.28,25.4 26.28,33.4 25.01,34.67 25.01,43.34 26.16,44.48 26.16,53.06 26.31,53.22 26.31,54.84 27.18,55.71 27.18,64.91 25.88,66.21 25.88,70.97 26.32,71.41 26.32,81.11 24.76,82.67 24.76,83.98 25.14,84.36 25.14,90.3 26.31,91.47 26.31,94.96 24.63,96.64 24.63,100.71 v1(25.14,101.22)
CPU_ID: length 439.9
  TOP w0.089: J3D1.AB39 v3(240.9,179.3)
  TOP w0.1: v1(265.93,166.37) 266.06,166.49 R2D1.1 ; U5E1.1 156.02,157.53 151.38,157.53 v1(151.15,157.3) 150.69,157.3 150.36,156.97 150.36,156.46 150.87,155.95 150.87,153.54 Q5E3.1
  LAY2 w0.089: v3(240.9,179.3) 241.18,179.3 241.59,179.7 241.99,179.7 242.58,179.12 253.94,179.12 264.62,168.44
  LAY2 w0.1: v1(265.93,166.37) 265.93,167.12 264.62,168.44
  LAY5 w0.125: v1(129.03,95.76) 129.66,95.76 133.22,99.31 144.52,99.31 145.63,100.42 146.73,100.42 149.23,97.92 172.59,97.92 173.22,97.28 v1(173.22,96.65) ; v1(147.19,160.91) 147.82,160.91 151.15,157.58 v1(151.15,157.3)
  LAY6 w0.125: v1(173.22,96.65) 173.99,96.65 175.26,97.92 282.32,97.92 283.62,99.22 283.62,134.01 283.26,134.38 283.26,139.83 282.88,140.21 282.57,140.21 281.49,141.29 280.51,141.29 278.8,143 278.8,146.77 277.69,147.89 277.69,149.49 274.26,152.93 274.26,156.4 265.93,164.72 v1(265.93,166.37) ; v1(129.03,95.76) 126.56,98.22 126.56,114.09 131.15,118.67 131.15,120.23 135.26,124.33 135.26,130.97 140.38,136.1 140.38,138.19 141.5,139.31 141.5,144.55 147.72,150.77 147.72,154.06 147.96,154.3 147.96,156.54 147.72,156.78 147.72,160.37 v1(147.19,160.91) 146.93,161.16 146.93,165.61 148.18,166.85 148.18,186.54 148.33,186.69 148.33,189.2 147.82,189.71 147.82,191.04 148.18,191.39 148.18,196.22 148.33,196.37 148.33,197.2 147.95,197.58 147.95,198.25 148.39,198.69 148.39,227.77 150.39,229.77 150.39,232.99 v1(150.64,233.25)
  BOTTOM w0.1: v1(150.64,233.25) 151.46,234.06 R5M16.1 151.99,234.28 153.51,235.8 155.15,235.8 155.57,236.22 R5M14.2
CPU_ID_N: length 19.1
  TOP w0.1: R5E56.2 149.47,154.3 150.18,153.6 150.18,152.97 150.37,152.78 151.76,152.78 151.94,152.96 152.66,152.96 Q5E3.3 153.28,151.99 v1(153.77,151.51) ; Q5E2.5 154.82,161.4 155.13,161.1 v1(155.13,160.97) 154.82,160.67 Q5E2.2
  LAY6 w0.125: v1(155.13,160.97) 155.58,160.52 155.58,156.21 155.13,155.76 155.13,152.98 153.79,151.64 153.79,151.53 v1(153.77,151.51)
CPU_ID_SA: length 25.4
  TOP w0.1: v1(160.9,235.33) Q5M4.1
  LAY6 w0.125: v1(160.9,235.33) 158.49,235.33 157.6,236.22 154.3,236.22 152.4,238.12 150.87,238.12 149.6,239.39 v1(148.46,239.39)
  BOTTOM w0.1: R5M6.1 148.71,239.14 v1(148.46,239.39) 148.46,239.27 147.95,238.76 147.95,238.25 148.33,237.87 Q5M2.1 148.84,237.74 148.08,236.98 148.08,235.1 148.61,234.57 Q5M3.1 149.22,234.44 149.47,234.19 150.47,234.19 R5M16.2 150.57,234.62 150.62,234.67 R5M15.2
CPU_ID_SA_1: length 3.7
  BOTTOM w0.1: R5M13.2 R5M14.1 155.19,236.85 R5M10.1 155.19,237.36 154.17,238.38 Q5M1.1
CPU_PWM_FAN: length 336.6
  TOP w0.1: 16.89,213.74 R9C4.1 v1(17.65,212.72) ; J6J2.40 v1(116.15,10.87) ; U8F6.44 16.46,100.29 15.65,99.48 13.42,99.48 13.08,99.82 13.08,100.46 12.89,100.65 v1(10.75,100.65)
  LAY3 w0.1: v1(107.18,11.56) 106.67,11.04 101.84,11.04 98.18,7.38 82.93,7.38 82.01,6.46 72.16,6.46 71.62,7 70.13,7 66.24,10.89 41.5,10.89 41.12,11.27 21.68,11.27 18.38,14.58 14.52,14.58 13.13,15.97 13.13,17.55 10.23,20.45 10.23,32.83 7.99,35.07 4.31,35.07 3.06,36.32 3.06,92.85 3.81,93.6 8.73,93.6 11.02,95.88 11.02,100.38 v1(10.75,100.65)
  LAY6 w0.125: v1(116.15,10.87) 115.97,11.05 113.66,11.05 113.28,11.43 111.12,11.43 110.74,11.05 107.69,11.05 v1(107.18,11.56) ; v1(10.75,100.65) 10.92,100.81 10.92,103.5 10.53,103.89 10.53,119.58 9.57,120.54 9.57,133.1 10.91,134.43 10.91,137.15 13.2,139.44 13.2,145.47 12.57,146.11 12.57,157.46 10.91,159.11 10.91,172.73 9.77,173.86 9.77,189.72 16,195.94 16,207.52 17.65,209.17 v1(17.65,212.72)
CPU_RTCCLK: length 212.6
  TOP w0.089: 216.6,201.55 216.6,199.31 216.64,199.27 216.64,198.44 J3D1.B15
  TOP w0.1: v1(187.96,217.42) 193.01,217.42 196.95,213.48 207.48,213.48 216.6,204.36 216.6,201.55 ; U7F1.3 73.43,114.96 v1(74.04,115.57)
  LAY3 w0.1: v1(74.04,115.57) 74.04,115.95 77.85,119.76 84.07,119.76 99.44,135.13 112.9,135.13 116.45,138.68 116.45,142.11 126.49,152.14 130.17,152.14 139.44,161.42 139.44,162.43 140.58,163.57 144.27,163.57 145.16,164.46 145.92,164.46 147.82,166.37 148.84,166.37 150.49,168.02 150.49,183.26 161.79,194.56 161.79,195.58 166.37,200.15 166.37,202.56 178.94,215.14 185.67,215.14 v1(187.96,217.42)
