# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BH_C68619001MA
  rect 1.397x1.397 hole 1.016: 1(0,0)
  round 1.397 hole 1.016: 2(0,-10) 3(-3.6,-5)
CON_SJR_1X2_2EM_MB
  rect 1.5x0.6 smd: 1(0,0) 2(0,-1)
  rect 1.8x1.2 smd: MH1(-3.9,1.3) MH2(-3.9,-2.3)
CON_SJV_2X5_2EM_05IA_CCG1
  rect 2.794x0.737 smd: 1(0,0) 2(-3.302,0) 3(0,-1.27) 4(-3.302,-1.27) 5(0,-2.54) 6(-3.302,-2.54) 7(0,-3.81) 8(-3.302,-3.81) 9(0,-5.08) 10(-3.302,-5.08)
  round 1.803 hole 1.422: MH1(-1.651,1.524) MH2(-1.651,-6.604)
CON_SPR_1X10_2M_20IA
  rect 1.803x1.753 smd: (-1.801,-2.134) (6.304,-2.134)
  rect 0.305x0.991 smd: 1(0,0) 2(0.5,0) 3(1.001,0) 4(1.501,0) 5(2.002,0) 6(2.502,0) 7(3.002,0) 8(3.503,0) 9(4.003,0) 10(4.503,0)
CPR60X63_25PMA
  rect 1.245x1.245 hole 0.864: 1(0,0)
  round 1.245 hole 0.864: 2(0,-2.5)
CPRC34_250PMA
  rect 1.325x1.325 hole 0.95: 1(0,0)
  round 1.325 hole 0.95: 2(0,-2.5)
CPRC55_200MA
  rect 1.275x1.275 hole 0.9: 1(0,0)
  round 1.275 hole 0.9: 2(0,-2)
CPRC55_200PMA
  rect 1.175x1.175 hole 0.8: 1(0,0)
  round 1.175 hole 0.8: 2(0,-2)
CPRC63_250PMA
  rect 1.315x1.315 hole 0.94: 1(0,0)
  round 1.315 hole 0.94: 2(0,-2.5)
CPRC68_250PMA
  rect 1.315x1.315 hole 0.94: 1(0,0)
  round 1.315 hole 0.94: 2(0,-2.5)
CPRC85_350MA
  rect 1.325x1.325 hole 0.95: 1(0,0)
  round 1.325 hole 0.95: 2(0,-3.5)
CPRC100_500PMA
  rect 1.346x1.346 hole 0.965: 1(0,0)
  round 1.346 hole 0.965: 2(0,-5)
DDR4_TJV_4X72_3M_MB
  round 0.254 hole 2.438x1.194 unplated: (2.7,5.65) (2.7,-68.9) (2.7,-132.3)
  rect 0.965x0.965 hole 0.66: 1(0,0)
  round 0.965 hole 0.66: 2(1.6,-0.85) 3(0,-1.7) 4(1.6,-2.55) 5(0,-3.4) 6(1.6,-4.25) 7(0,-5.1) 8(1.6,-5.95) 9(0,-6.8) 10(1.6,-7.65) 11(0,-8.5) 12(1.6,-9.35) 13(0,-10.2) 14(1.6,-11.05) 15(0,-11.9) 16(1.6,-12.75) 17(0,-13.6) 18(1.6,-14.45) 19(0,-15.3) 20(1.6,-16.15) 21(0,-17) 22(1.6,-17.85) 23(0,-18.7) 24(1.6,-19.55) 25(0,-20.4) 26(1.6,-21.25) 27(0,-22.1) 28(1.6,-22.95) 29(0,-23.8) 30(1.6,-24.65) 31(0,-25.5) 32(1.6,-26.35) 33(0,-27.2) 34(1.6,-28.05) 35(0,-28.9) 36(1.6,-29.75) 37(0,-30.6) 38(1.6,-31.45) 39(0,-32.3) 40(1.6,-33.15) 41(0,-34) 42(1.6,-34.85) 43(0,-35.7) 44(1.6,-36.55) 45(0,-37.4) 46(1.6,-38.25) 47(0,-39.1) 48(1.6,-39.95) 49(0,-40.8) 50(1.6,-41.65) 51(0,-42.5) 52(1.6,-43.35) 53(0,-44.2) 54(1.6,-45.05) 55(0,-45.9) 56(1.6,-46.75) 57(0,-47.6) 58(1.6,-48.45) 59(0,-49.3) 60(1.6,-50.15) 61(0,-51) 62(1.6,-51.85) 63(0,-52.7) 64(1.6,-53.55) 65(0,-54.4) 66(1.6,-55.25) 67(0,-56.1) 68(1.6,-56.95) 69(0,-57.8) 70(1.6,-58.65) 71(0,-59.5) 72(1.6,-60.35) 73(0,-61.2) 74(1.6,-62.05) 75(0,-62.9) 76(1.6,-63.75) 77(0,-64.6) 78(1.6,-70.55) 79(0,-71.4) 80(1.6,-72.25) 81(0,-73.1) 82(1.6,-73.95) 83(0,-74.8) 84(1.6,-75.65) 85(0,-76.5) 86(1.6,-77.35) 87(0,-78.2) 88(1.6,-79.05) 89(0,-79.9) 90(1.6,-80.75) 91(0,-81.6) 92(1.6,-82.45) 93(0,-83.3) 94(1.6,-84.15) 95(0,-85) 96(1.6,-85.85) 97(0,-86.7) 98(1.6,-87.55) 99(0,-88.4) 100(1.6,-89.25) 101(0,-90.1) 102(1.6,-90.95) 103(0,-91.8) 104(1.6,-92.65) 105(0,-93.5) 106(1.6,-94.35) 107(0,-95.2) 108(1.6,-96.05) 109(0,-96.9) 110(1.6,-97.75) 111(0,-98.6) 112(1.6,-99.45) 113(0,-100.3) 114(1.6,-101.15) 115(0,-102) 116(1.6,-102.85) 117(0,-103.7) 118(1.6,-104.55) 119(0,-105.4) 120(1.6,-106.25) 121(0,-107.1) 122(1.6,-107.95) 123(0,-108.8) 124(1.6,-109.65) 125(0,-110.5) 126(1.6,-111.35) 127(0,-112.2) 128(1.6,-113.05) 129(0,-113.9) 130(1.6,-114.75) 131(0,-115.6) 132(1.6,-116.45) 133(0,-117.3) 134(1.6,-118.15) 135(0,-119) 136(1.6,-119.85) 137(0,-120.7) 138(1.6,-121.55) 139(0,-122.4) 140(1.6,-123.25) 141(0,-124.1) 142(1.6,-124.95) 143(0,-125.8) 144(1.6,-126.65) 145(3.8,0) 146(5.4,-0.85) 147(3.8,-1.7) 148(5.4,-2.55) 149(3.8,-3.4) 150(5.4,-4.25) 151(3.8,-5.1) 152(5.4,-5.95) 153(3.8,-6.8) 154(5.4,-7.65) 155(3.8,-8.5) 156(5.4,-9.35) 157(3.8,-10.2) 158(5.4,-11.05) 159(3.8,-11.9) 160(5.4,-12.75) 161(3.8,-13.6) 162(5.4,-14.45) 163(3.8,-15.3) 164(5.4,-16.15) 165(3.8,-17) 166(5.4,-17.85) 167(3.8,-18.7) 168(5.4,-19.55) 169(3.8,-20.4) 170(5.4,-21.25) 171(3.8,-22.1) 172(5.4,-22.95) 173(3.8,-23.8) 174(5.4,-24.65) 175(3.8,-25.5) 176(5.4,-26.35) 177(3.8,-27.2) 178(5.4,-28.05) 179(3.8,-28.9) 180(5.4,-29.75) 181(3.8,-30.6) 182(5.4,-31.45) 183(3.8,-32.3) 184(5.4,-33.15) 185(3.8,-34) 186(5.4,-34.85) 187(3.8,-35.7) 188(5.4,-36.55) 189(3.8,-37.4) 190(5.4,-38.25) 191(3.8,-39.1) 192(5.4,-39.95) 193(3.8,-40.8) 194(5.4,-41.65) 195(3.8,-42.5) 196(5.4,-43.35) 197(3.8,-44.2) 198(5.4,-45.05) 199(3.8,-45.9) 200(5.4,-46.75) 201(3.8,-47.6) 202(5.4,-48.45) 203(3.8,-49.3) 204(5.4,-50.15) 205(3.8,-51) 206(5.4,-51.85) 207(3.8,-52.7) 208(5.4,-53.55) 209(3.8,-54.4) 210(5.4,-55.25) 211(3.8,-56.1) 212(5.4,-56.95) 213(3.8,-57.8) 214(5.4,-58.65) 215(3.8,-59.5) 216(5.4,-60.35) 217(3.8,-61.2) 218(5.4,-62.05) 219(3.8,-62.9) 220(5.4,-63.75) 221(3.8,-64.6) 222(5.4,-70.55) 223(3.8,-71.4) 224(5.4,-72.25) 225(3.8,-73.1) 226(5.4,-73.95) 227(3.8,-74.8) 228(5.4,-75.65) 229(3.8,-76.5) 230(5.4,-77.35) 231(3.8,-78.2) 232(5.4,-79.05) 233(3.8,-79.9) 234(5.4,-80.75) 235(3.8,-81.6) 236(5.4,-82.45) 237(3.8,-83.3) 238(5.4,-84.15) 239(3.8,-85) 240(5.4,-85.85) 241(3.8,-86.7) 242(5.4,-87.55) 243(3.8,-88.4) 244(5.4,-89.25) 245(3.8,-90.1) 246(5.4,-90.95) 247(3.8,-91.8) 248(5.4,-92.65) 249(3.8,-93.5) 250(5.4,-94.35) 251(3.8,-95.2) 252(5.4,-96.05) 253(3.8,-96.9) 254(5.4,-97.75) 255(3.8,-98.6) 256(5.4,-99.45) 257(3.8,-100.3) 258(5.4,-101.15) 259(3.8,-102) 260(5.4,-102.85) 261(3.8,-103.7) 262(5.4,-104.55) 263(3.8,-105.4) 264(5.4,-106.25) 265(3.8,-107.1) 266(5.4,-107.95) 267(3.8,-108.8) 268(5.4,-109.65) 269(3.8,-110.5) 270(5.4,-111.35) 271(3.8,-112.2) 272(5.4,-113.05) 273(3.8,-113.9) 274(5.4,-114.75) 275(3.8,-115.6) 276(5.4,-116.45) 277(3.8,-117.3) 278(5.4,-118.15) 279(3.8,-119) 280(5.4,-119.85) 281(3.8,-120.7) 282(5.4,-121.55) 283(3.8,-122.4) 284(5.4,-123.25) 285(3.8,-124.1) 286(5.4,-124.95) 287(3.8,-125.8) 288(5.4,-126.65)
DIN_TJR_12P_5EM_MA
  rect 1.375x1.375 hole 1: 1(0,0)
  round 1.375 hole 1: 2(2.59,0) 3(-2.11,0) 4(4.7,0) 5(-2.11,-2.49) 6(4.7,-2.49) 7(0,-7.06) 8(2.59,-7.06) 9(-2.11,-7.06) 10(4.7,-7.06) 11(-2.11,-9.55) 12(4.7,-9.55)
  round 2.675 hole 2.3: MH1(-5.455,3) MH2(1.295,3.81) MH3(8.045,3) MH4(-5.455,-7.06) MH5(8.045,-7.06)
DP_HDMI_TJR_19P_20P_4EM_2M_IA
  round 0.254 hole 1.6 unplated: (-13.2,-6.9) (0.8,-6.9)
  round 0.94 hole 0.559: B1(-1.45,-3.9) B2(-2.2,-5.4) B3(-2.95,-3.9) B4(-2.95,-6.9) B5(-3.7,-5.4) B6(-4.45,-6.9) B7(-4.45,-3.9) B8(-5.2,-5.4) B9(-5.95,-3.9) B10(-5.95,-6.9) B11(-6.7,-5.4) B12(-7.45,-6.9) B13(-7.45,-3.9) B14(-8.2,-5.4) B15(-8.95,-3.9) B16(-8.95,-6.9) B17(-9.7,-5.4) B18(-10.45,-6.9) B19(-10.45,-3.9)
  oval 1.295x2.692 hole 0.813x2.21: MH1(-14.45,0.8) MH2(2.05,0.8)
  oval 1.448x2.362 hole 0.838x1.753: MH3(2.05,-11.1) MH4(-14.45,-11.1)
  rect 0.787x0.787 hole 0.406: T1(0,0)
  round 0.787 hole 0.406: T2(-0.5,-1.4) T3(-1.4,0) T4(-1.8,-1.4) T5(-2.7,0) T6(-3.2,-1.4) T7(-4,0) T8(-4.5,-1.4) T9(-5.4,0) T10(-5.8,-1.4) T11(-6.7,0) T12(-7.2,-1.4) T13(-8,0) T14(-8.5,-1.4) T15(-9.3,0) T16(-9.8,-1.4) T17(-10.7,0) T18(-11.1,-1.4) T19(-12,0) T20(-12.4,-1.4)
FIDUCIAL_40
  round 1.016 smd: 1(0,0)
GND_ISOLATION
  rect 0.635x0.889 smd: 1(0,0) 2(0,-0.864)
HDMI_TJR_19P_4EM_1M_MA
  round 0.25 hole 1.7 unplated: (-4.75,-6.5)
  rect 0.925x0.925 hole 0.55: 1(0,0)
  round 0.925 hole 0.55: 2(-0.75,-1.5) 3(-1.5,0) 4(-1.5,-3) 5(-2.25,-1.5) 6(-3,-3) 7(-3,0) 8(-3.75,-1.5) 9(-4.5,0) 10(-4.5,-3) 11(-5.25,-1.5) 12(-6,-3) 13(-6,0) 14(-6.75,-1.5) 15(-7.5,0) 16(-7.5,-3) 17(-8.25,-1.5) 18(-9,-3) 19(-9,0)
  oval 1.275x3.075 hole 0.9x2.7: MH1(2.5,-2.34) MH2(-12,-2.34)
  oval 1.275x2.475 hole 0.9x2.1: MH3(3.1,-8.3) MH4(-12.6,-8.3)
HDR_SJV_2X10_K1_2M_IA
  round 0.254 hole 1.422 unplated: (1.714,1.486) (1.714,-12.916)
  rect 2.921x0.737 smd: 2(3.429,0) 3(0,-1.27) 4(3.429,-1.27) 5(0,-2.54) 6(3.429,-2.54) 7(0,-3.81) 8(3.429,-3.81) 9(0,-5.08) 10(3.429,-5.08) 11(0,-6.35) 12(3.429,-6.35) 13(0,-7.62) 14(3.429,-7.62) 15(0,-8.89) 16(3.429,-8.89) 17(0,-10.16) 18(3.429,-10.16) 19(0,-11.43) 20(3.429,-11.43)
HDR_SPV_2X14_K4K21K22IA
  rect 3.683x1.27 smd: 1(0,0) 2(4.953,0) 3(0,-2.54) 5(0,-5.08) 6(4.953,-5.08) 7(0,-7.62) 8(4.953,-7.62) 9(0,-10.16) 10(4.953,-10.16) 11(0,-12.7) 12(4.953,-12.7) 13(0,-15.24) 14(4.953,-15.24) 15(0,-17.78) 16(4.953,-17.78) 17(0,-20.32) 18(4.953,-20.32) 19(0,-22.86) 20(4.953,-22.86) 23(0,-27.94) 24(4.953,-27.94) 25(0,-30.48) 26(4.953,-30.48) 27(0,-33.02) 28(4.953,-33.02)
HDR_SPV_2X25_2M_K29K30K31_50IA
  round 0.254 hole 1.422 unplated: (0.001,16.828) (0.001,-16.828)
  rect 2.921x0.737 smd: 1(-1.714,15.24) 2(1.714,15.24) 3(-1.714,13.97) 4(1.714,13.97) 5(-1.714,12.7) 6(1.714,12.7) 7(-1.714,11.43) 8(1.714,11.43) 9(-1.714,10.16) 10(1.714,10.16) 11(-1.714,8.89) 12(1.714,8.89) 13(-1.714,7.62) 14(1.714,7.62) 15(-1.714,6.35) 16(1.714,6.35) 17(-1.714,5.08) 18(1.714,5.08) 19(-1.714,3.81) 20(1.714,3.81) 21(-1.714,2.54) 22(1.714,2.54) 23(-1.714,1.27) 24(1.714,1.27) 25(-1.714,0) 26(1.714,0) 27(-1.714,-1.27) 28(1.714,-1.27) 32(1.714,-3.81) 33(-1.714,-5.08) 34(1.714,-5.08) 35(-1.714,-6.35) 36(1.714,-6.35) 37(-1.714,-7.62) 38(1.714,-7.62) 39(-1.714,-8.89) 40(1.714,-8.89) 41(-1.714,-10.16) 42(1.714,-10.16) 43(-1.714,-11.43) 44(1.714,-11.43) 45(-1.714,-12.7) 46(1.714,-12.7) 47(-1.714,-13.97) 48(1.714,-13.97) 49(-1.714,-15.24) 50(1.714,-15.24)
HDR_TJV_1X5_IA
  rect 1.397x1.397 hole 1.016: 1(0,0)
  round 1.397 hole 1.016: 2(0,-2.54) 3(0,-5.08) 4(0,-7.62) 5(0,-10.16)
HDR_TJV_2X8_K12_100X100IA
  rect 1.676x1.676 hole 1.295: 1(0,0)
  round 1.676 hole 1.295: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 9(0,-10.16) 10(2.54,-10.16) 11(0,-12.7) 13(0,-15.24) 14(2.54,-15.24) 15(0,-17.78) 16(2.54,-17.78)
HDR_TPR_2X4_420MA
  rect 2.175x2.175 hole 1.8: 1(0,0)
  round 2.175 hole 1.8: 2(4.2,0) 3(8.4,0) 4(12.6,0) 5(0,-5.5) 6(4.2,-5.5) 7(8.4,-5.5) 8(12.6,-5.5)
HDR_TPV_1X2_2540_MA_CCG1
  rect 1.525x1.525 hole 1.15: 1(0,1.27)
  round 1.525 hole 1.15: 2(0,-1.27)
HDR_TPV_1X2MB
  rect 1.275x1.275 hole 0.9: 1(0,0)
  round 1.275 hole 0.9: 2(0,-5)
HDR_TPV_1X3_50IB
  rect 1.041x1.041 hole 0.737: 1(0,0)
  round 1.041 hole 0.737: 2(0,-1.27) 3(0,-2.54)
HDR_TPV_1X3_254MB
  rect 1.395x1.395 hole 1.02: 1(0,0)
  round 1.395 hole 1.02: 3(0,-5.08)
HDR_TPV_1X3_2540_MB
  rect 1.525x1.525 hole 1.15: 1(0,0)
  round 1.525 hole 1.15: 2(0,-2.54) 3(0,-5.08)
HDR_TPV_1X3IA
  rect 1.6x1.6 hole 1.219: 1(0,0)
  round 1.6 hole 1.219: 2(0,-2.54) 3(0,-5.08)
HDR_TPV_1X4_1M_IB
  round 0.254 hole 1.499 unplated: (2.16,-5.08)
  rect 1.6x1.6 hole 1.219: 1(0,0)
  round 1.6 hole 1.219: 2(0,-2.54) 3(0,-5.08) 4(0,-7.62)
HDR_TPV_1X4IA
  rect 1.6x1.6 hole 1.219: 1(0,0)
  round 1.6 hole 1.219: 2(0,-2.54) 3(0,-5.08) 4(0,-7.62)
HDR_TPV_1X5IA
  rect 1.6x1.6 hole 1.219: 1(0,0)
  round 1.6 hole 1.219: 2(0,-2.54) 3(0,-5.08) 4(0,-7.62) 5(0,-10.16)
HDR_TPV_2X2MA
  rect 1.565x1.565 hole 1.19: 1(0,0)
  round 1.565 hole 1.19: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54)
HDR_TPV_2X3_100IA
  rect 1.575x1.575 hole 1.194: 1(0,0)
  round 1.575 hole 1.194: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08)
HDR_TPV_2X4_K7_254MA
  rect 1.575x1.575 hole 1.194: 1(0,0)
  round 1.575 hole 1.194: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 8(2.54,-7.62)
HDR_TPV_2X4IA
  rect 1.6x1.6 hole 1.219: 1(0,0)
  round 1.6 hole 1.219: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62)
HDR_TPV_2X5_254MA
  rect 1.6x1.6 hole 1.219: 1(0,0)
  round 1.6 hole 1.219: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 9(0,-10.16) 10(2.54,-10.16)
HDR_TPV_2X5_254MC
  rect 1.395x1.395 hole 1.02: 1(0,0)
  round 1.395 hole 1.02: 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 9(0,-10.16) 10(2.54,-10.16)
HDR_TPV_2X5_K10_2540MA
  rect 1.525x1.525 hole 1.15: 1(0,0)
  round 1.525 hole 1.15: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 9(0,-10.16)
HDR_TPV_2X6_254MA
  rect 1.575x1.575 hole 1.194: 1(0,0)
  round 1.575 hole 1.194: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 9(0,-10.16) 10(2.54,-10.16) 11(0,-12.7) 12(2.54,-12.7)
HDR_TPV_2X10_K1_2M_MA
  round 1.725 hole 1.35: (0.635,1.587) (0.635,-13.018)
  round 1.041 hole 0.66: 2(1.27,0) 3(0,-1.27) 4(1.27,-1.27) 5(0,-2.54) 6(1.27,-2.54) 7(0,-3.81) 8(1.27,-3.81) 9(0,-5.08) 10(1.27,-5.08) 11(0,-6.35) 12(1.27,-6.35) 13(0,-7.62) 14(1.27,-7.62) 15(0,-8.89) 16(1.27,-8.89) 17(0,-10.16) 18(1.27,-10.16) 19(0,-11.43) 20(1.27,-11.43)
HDR_TPV_2X10IB
  rect 1.016x1.016 hole 0.635: 1(0.032,0)
  round 1.016 hole 0.635: 2(1.302,0) 3(0.032,-1.27) 4(1.302,-1.27) 5(0.032,-2.54) 6(1.302,-2.54) 7(0.032,-3.81) 8(1.302,-3.81) 9(0.032,-5.08) 10(1.302,-5.08) 11(0.032,-6.35) 12(1.302,-6.35) 13(0.032,-7.62) 14(1.302,-7.62) 15(0.032,-8.89) 16(1.302,-8.89) 17(0.032,-10.16) 18(1.302,-10.16) 19(0.032,-11.43) 20(1.302,-11.43)
HDR_TPV_2X20_1M_2X2MA
  round 0.25 hole 1 unplated: (1,-37)
  rect 1.375x1.375 hole 1: 1(0,0)
  round 1.375 hole 1: 2(2,0) 3(0,-2) 4(2,-2) 5(0,-4) 6(2,-4) 7(0,-6) 8(2,-6) 9(0,-8) 10(2,-8) 11(0,-10) 12(2,-10) 13(0,-12) 14(2,-12) 15(0,-14) 16(2,-14) 17(0,-16) 18(2,-16) 19(0,-18) 20(2,-18) 21(0,-20) 22(2,-20) 23(0,-22) 24(2,-22) 25(0,-24) 26(2,-24) 27(0,-26) 28(2,-26) 29(0,-28) 30(2,-28) 31(0,-30) 32(2,-30) 33(0,-32) 34(2,-32) 35(0,-34) 36(2,-34) 37(0,-36) 38(2,-36) 39(0,-38) 40(2,-38)
I415X295_345IA
  rect 1.549x1.549 hole 1.168: 1(0,0)
  round 1.549 hole 1.168: 2(8.763,0)
INS_7000_4320_MA
  round 7 hole 4.32: 1(0,0)
LAI_SJV_PCIE3_X8_MIDBUS_4M_IB
  round 0.254 hole 2.362 unplated: (-1.702,-28.702) (-1.702,2.489)
  round 0.254 hole 0.889 unplated: (1.346,-29.388)
  round 0.254 hole 0.838 unplated: (1.346,3.175)
  round 0.635 smd: 1(0,0) 2(-3.404,-1.275) 3(0,-1.001) 4(-3.404,-2.276) 5(0,-2.002) 6(-3.404,-3.277) 7(0,-4.552) 8(-3.404,-4.277) 9(0,-5.552) 10(-3.404,-5.278) 11(0,-6.553) 12(-3.404,-7.828) 13(0,-7.554) 14(-3.404,-8.829) 15(0,-8.555) 16(-3.404,-9.83) 17(0,-11.105) 18(-3.404,-10.831) 19(0,-12.106) 20(-3.404,-11.831) 21(0,-13.106) 22(-3.404,-14.382) 23(0,-14.107) 24(-3.404,-15.382) 25(0,-15.108) 26(-3.404,-16.383) 27(0,-17.658) 28(-3.404,-17.384) 29(0,-18.659) 30(-3.404,-18.384) 31(0,-19.66) 32(-3.404,-20.935) 33(0,-20.66) 34(-3.404,-21.935) 35(0,-21.661) 36(-3.404,-22.936) 37(0,-24.211) 38(-3.404,-23.937) 39(0,-25.212) 40(-3.404,-24.938) 41(0,-26.213)
LCC3_10X6_35MA
  rect 0.3x0.2 smd: 1(0,0) 2(0,-0.35)
  rect 0.3x0.55 smd: 3(0.65,-0.175)
LCC5_S30_65DF1MA
  rect 0.5x0.35 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95)
  custom 0.57x0.57 smd: 5(1.91,-0.975)
LCC6_S10_35MA
  rect 0.525x0.2 smd: 1(0,0) 2(0,-0.35) 3(0,-0.7) 4(0.675,-0.7) 5(0.675,-0.35) 6(0.675,0)
LCC6_S10_35MC
  rect 0.4x0.175 smd: 1(0,0)
  rect 0.35x0.175 smd: 2(-0.025,-0.35) 3(-0.025,-0.7) 4(0.525,-0.7) 5(0.525,-0.35) 6(0.525,0)
LCC7_2050X1550_MA
  rect 0.65x0.2 smd: 1(-0.675,0.6) 2(-0.675,0.2) 7(0.675,0.2) 8(0.675,0.6)
  custom 0.15x0.15 smd: 4(-0.593,-0.4) 6(0.593,-0.4)
  rect 0.2x0.65 smd: 9(0,0.925)
LCC8_16X10_40MA
  custom 0.051x0.051 smd: 1(0,0) 2(0,-0.4) 7(0.813,-0.4) 8(0.813,0)
  custom 0.152x0.152 smd: 3(0,-1.003) 6(0.813,-1.003)
LCC8_50X60_127DF50X31MA
  rect 0.965x1.727 smd: 1(0,0)
  rect 0.965x0.457 smd: 3(0,-1.905) 4(0,-3.175) 5(5.436,-3.175) 6(5.436,-1.905) 7(5.436,-0.635) 8(5.436,0.635)
  custom 0.787x0.787 smd: 9(2.718,-1.27)
LCC8_56X53_127MA
  rect 0.65x0.5 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81)
  custom 1.15x1.15 smd: 5(3.49,-1.905)
LCC8_79X59_20IA
  custom 0.064x0.064 smd: 1(-0.622,0.752) 2(-0.622,0.252) 7(0.622,0.252) 8(0.622,0.752)
  custom 0.191x0.191 smd: 3(-0.559,-0.503) 5(0.559,-0.503)
LCC8_80X60_127DF340X430MA
  custom 0.12x0.12 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(7.685,-3.81) 6(7.685,-2.54) 7(7.685,-1.27) 8(7.685,0)
  rect 3.4x4.3 smd: 9(3.842,-1.905)
LCC8_S20_50DF16X10MA
  custom 0.075x0.075 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(2.015,-1.5) 6(2.015,-1) 7(2.015,-0.5) 8(2.015,0)
  rect 1x1.6 smd: 9(1.008,-0.75)
LCC8_S21_50_DF09X16MA
  rect 0.475x0.3 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.875,-1.5) 6(1.875,-1) 7(1.875,-0.5) 8(1.875,0)
  rect 0.9x1.6 smd: 9(0.938,-0.75)
LCC8_S21_50DF16X9_VIA_MA
  rect 0.584x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.981,-1.5) 6(1.981,-1) 7(1.981,-0.5) 8(1.981,0)
  rect 0.889x1.6 smd: 9(0.991,-0.75)
LCC8_S21_50DF16X9MA
  rect 0.584x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.981,-1.5) 6(1.981,-1) 7(1.981,-0.5) 8(1.981,0)
  rect 0.889x1.6 smd: 9(0.991,-0.75)
LCC8_S33_65DF18X27MA
  custom 0.194x0.194 smd: 1(-1.562,0.65)
  rect 0.775x0.4 smd: 3(-1.562,-0.325) 4(-1.562,-0.975) 5(1.562,-0.975) 6(1.562,-0.325) 7(1.562,0.325) 8(1.562,0.975)
  custom 0.45x0.45 smd: 9(0,0)
LCC9_6100X5100_127_MA
  rect 0.83x0.61 smd: 1(-2.828,1.905) 5(2.842,-1.905) 6(2.842,-0.635) 7(2.842,0.635) 8(2.842,1.905)
  custom 0.5x0.5 smd: 2(-2.243,-0.105)
  rect 2.15x4 smd: 9(0.532,0)
LCC10_25X10_50MB
  rect 0.575x0.25 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0.775,-2) 7(0.775,-1.5) 8(0.775,-1) 9(0.775,-0.5) 10(0.775,0)
LCC10_S26_50DF125X215MA
  rect 0.575x0.3 smd: 1(-1.163,1) 2(-1.163,0.5) 3(-1.163,0) 4(-1.163,-0.5) 5(-1.163,-1) 6(1.163,-1) 7(1.163,-0.5) 8(1.163,0) 9(1.163,0.5) 10(1.163,1)
  rect 1.25x2.15 smd: 11(0,0)
LCC10_S30_50DF26X17MA
  rect 0.675x0.3 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(2.875,-2) 7(2.875,-1.5) 8(2.875,-1) 9(2.875,-0.5) 10(2.875,0)
  rect 1.7x2.6 smd: 11(1.438,-1)
LCC12_S16_40MB
  rect 0.575x0.2 smd: 1(-0.787,0.6) 4(-0.787,-0.6) 7(0.787,-0.6) 10(0.787,0.6)
  rect 0.5x0.2 smd: 2(-0.825,0.2) 3(-0.825,-0.2) 8(0.825,-0.2) 9(0.825,0.2)
  rect 0.2x0.5 smd: 5(-0.2,-0.825) 6(0.2,-0.825) 11(0.2,0.825) 12(-0.2,0.825)
LCC12_S25_40DF20X13MA
  custom 0.05x0.05 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(2.4,-2) 8(2.4,-1.6) 9(2.4,-1.2) 10(2.4,-0.8) 11(2.4,-0.4) 12(2.4,0)
  rect 1.3x2 smd: 13(1.2,-1)
LCC14_30X20_40DF26X9MA
  rect 0.65x0.2 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(1.95,-2.4) 9(1.95,-2) 10(1.95,-1.6) 11(1.95,-1.2) 12(1.95,-0.8) 13(1.95,-0.4) 14(1.95,0)
  rect 0.9x2.6 smd: 15(0.975,-1.2)
LCC14_S365_50DFS205MA
  rect 0.3x0.775 smd: 1(-0.75,1.688) 7(-0.75,-1.688) 8(0.75,-1.688) 14(0.75,1.688)
  rect 0.775x0.3 smd: 2(-1.688,1) 3(-1.688,0.5) 4(-1.688,0) 5(-1.688,-0.5) 6(-1.688,-1) 9(1.688,-1) 10(1.688,-0.5) 11(1.688,0) 12(1.688,0.5) 13(1.688,1)
  custom 0.514x0.514 smd: 15(0,0)
LCC16_40X35_50DF26X21_VIA_MA
  custom 0.075x0.075 smd: 1(-0.75,1.913) 2(-1.663,1.25) 3(-1.663,0.75) 4(-1.663,0.25) 5(-1.663,-0.25) 6(-1.663,-0.75) 7(-1.663,-1.25) 8(-0.75,-1.913) 9(0.75,-1.913) 10(1.663,-1.25) 11(1.663,-0.75) 12(1.663,-0.25) 13(1.663,0.25) 14(1.663,0.75) 15(1.663,1.25) 16(0.75,1.913)
  rect 2.05x2.55 smd: 17(0,0)
LCC20_S118_16DFS67IA
  custom 0.051x0.051 smd: 1(-1.46,0.798) 2(-1.46,0.399) 3(-1.46,0) 4(-1.46,-0.399) 5(-1.46,-0.798) 6(-0.798,-1.46) 7(-0.399,-1.46) 8(0,-1.46) 9(0.399,-1.46) 10(0.798,-1.46) 11(1.46,-0.798) 12(1.46,-0.399) 13(1.46,0) 14(1.46,0.399) 15(1.46,0.798) 16(0.798,1.46) 17(0.399,1.46) 18(0,1.46) 19(-0.399,1.46) 20(-0.798,1.46)
  rect 1.702x1.702 smd: 21(0,0)
LCC31_S51_50MA
  rect 0.75x0.3 smd: 1(-2.425,1.75) 2(-2.425,1.25) 3(-2.425,0.75) 4(-2.425,0.25) 5(-2.425,-0.25) 6(-2.425,-0.75) 7(-2.425,-1.25) 8(-2.425,-1.75)
  custom 0.325x0.325 smd: 9(-1.25,-2.475)
  custom 0.544x0.544 smd: 12(0.755,-2.475)
  custom 0.188x0.188 smd: 16(2.425,-0.25) 24(1.25,2.425)
  rect 0.3x0.75 smd: 27(0.25,2.425) 28(-0.25,2.425) 29(-0.75,2.425) 30(-1.25,2.425) 31(-1.75,2.425)
  rect 1.13x1.42 smd: 32(-1.185,1.04)
  rect 0.4x0.55 smd: 33(0.1,1.475)
LCC48_S60_40DFS30MA
  custom 0.05x0.05 smd: 1(-2.825,2.2) 2(-2.825,1.8) 3(-2.825,1.4) 4(-2.825,1) 5(-2.825,0.6) 6(-2.825,0.2) 7(-2.825,-0.2) 8(-2.825,-0.6) 9(-2.825,-1) 10(-2.825,-1.4) 11(-2.825,-1.8) 12(-2.825,-2.2) 13(-2.2,-2.825) 14(-1.8,-2.825) 15(-1.4,-2.825) 16(-1,-2.825) 17(-0.6,-2.825) 18(-0.2,-2.825) 19(0.2,-2.825) 20(0.6,-2.825) 21(1,-2.825) 22(1.4,-2.825) 23(1.8,-2.825) 24(2.2,-2.825) 25(2.825,-2.2) 26(2.825,-1.8) 27(2.825,-1.4) 28(2.825,-1) 29(2.825,-0.6) 30(2.825,-0.2) 31(2.825,0.2) 32(2.825,0.6) 33(2.825,1) 34(2.825,1.4) 35(2.825,1.8) 36(2.825,2.2) 37(2.2,2.825) 38(1.8,2.825) 39(1.4,2.825) 40(1,2.825) 41(0.6,2.825) 42(0.2,2.825) 43(-0.2,2.825) 44(-0.6,2.825) 45(-1,2.825) 46(-1.4,2.825) 47(-1.8,2.825) 48(-2.2,2.825)
  rect 3x3 smd: 49(0,0)
LCC48_S60_40DFS45MB
  custom 0.05x0.05 smd: 1(-2.875,2.2) 2(-2.875,1.8) 3(-2.875,1.4) 4(-2.875,1) 5(-2.875,0.6) 6(-2.875,0.2) 7(-2.875,-0.2) 8(-2.875,-0.6) 9(-2.875,-1) 10(-2.875,-1.4) 11(-2.875,-1.8) 12(-2.875,-2.2) 13(-2.2,-2.875) 14(-1.8,-2.875) 15(-1.4,-2.875) 16(-1,-2.875) 17(-0.6,-2.875) 18(-0.2,-2.875) 19(0.2,-2.875) 20(0.6,-2.875) 21(1,-2.875) 22(1.4,-2.875) 23(1.8,-2.875) 24(2.2,-2.875) 25(2.875,-2.2) 26(2.875,-1.8) 27(2.875,-1.4) 28(2.875,-1) 29(2.875,-0.6) 30(2.875,-0.2) 31(2.875,0.2) 32(2.875,0.6) 33(2.875,1) 34(2.875,1.4) 35(2.875,1.8) 36(2.875,2.2) 37(2.2,2.875) 38(1.8,2.875) 39(1.4,2.875) 40(1,2.875) 41(0.6,2.875) 42(0.2,2.875) 43(-0.2,2.875) 44(-0.6,2.875) 45(-1,2.875) 46(-1.4,2.875) 47(-1.8,2.875) 48(-2.2,2.875)
  rect 4.5x4.5 smd: 49(0,0)
LCC56_S70_40DFS52MA
  rect 0.875x0.2 smd: 1(-3.288,2.6) 2(-3.288,2.2) 3(-3.288,1.8) 4(-3.288,1.4) 5(-3.288,1) 6(-3.288,0.6) 7(-3.288,0.2) 8(-3.288,-0.2) 9(-3.288,-0.6) 10(-3.288,-1) 11(-3.288,-1.4) 12(-3.288,-1.8) 13(-3.288,-2.2) 14(-3.288,-2.6) 29(3.288,-2.6) 30(3.288,-2.2) 31(3.288,-1.8) 32(3.288,-1.4) 33(3.288,-1) 34(3.288,-0.6) 35(3.288,-0.2) 36(3.288,0.2) 37(3.288,0.6) 38(3.288,1) 39(3.288,1.4) 40(3.288,1.8) 41(3.288,2.2) 42(3.288,2.6)
  rect 0.2x0.875 smd: 15(-2.6,-3.288) 16(-2.2,-3.288) 17(-1.8,-3.288) 18(-1.4,-3.288) 19(-1,-3.288) 20(-0.6,-3.288) 21(-0.2,-3.288) 22(0.2,-3.288) 23(0.6,-3.288) 24(1,-3.288) 25(1.4,-3.288) 26(1.8,-3.288) 27(2.2,-3.288) 28(2.6,-3.288) 43(2.6,3.288) 44(2.2,3.288) 45(1.8,3.288) 46(1.4,3.288) 47(1,3.288) 48(0.6,3.288) 49(0.2,3.288) 50(-0.2,3.288) 51(-0.6,3.288) 52(-1,3.288) 53(-1.4,3.288) 54(-1.8,3.288) 55(-2.2,3.288) 56(-2.6,3.288)
  rect 5.2x5.2 smd: 57(0,0)
LCC56_S7150_40DF340X550_MA
  custom 0.15x0.15 smd: 1(-3.4,2.4) 3(-3.4,1.6) 11(-3.4,-1.6) 13(-3.4,-2.4)
  custom 0.05x0.05 smd: 5(-3.4,1) 6(-3.4,0.6) 7(-3.4,0.2) 8(-3.4,-0.2) 9(-3.4,-0.6) 10(-3.4,-1) 15(-2.6,-3.4) 16(-2.2,-3.4) 17(-1.8,-3.4) 18(-1.4,-3.4) 19(-1,-3.4) 20(-0.6,-3.4) 21(-0.2,-3.4) 22(0.2,-3.4) 23(0.6,-3.4) 24(1,-3.4) 25(1.4,-3.4) 26(1.8,-3.4) 27(2.2,-3.4) 28(2.6,-3.4) 29(3.4,-2.6) 30(3.4,-2.2) 31(3.4,-1.8) 32(3.4,-1.4) 33(3.4,-1) 34(3.4,-0.6) 35(3.4,-0.2) 36(3.4,0.2) 37(3.4,0.6) 38(3.4,1) 39(3.4,1.4) 40(3.4,1.8) 41(3.4,2.2) 42(3.4,2.6) 43(2.6,3.4) 44(2.2,3.4) 45(1.8,3.4) 46(1.4,3.4) 47(1,3.4) 48(0.6,3.4) 49(0.2,3.4) 50(-0.2,3.4) 51(-0.6,3.4) 52(-1,3.4) 53(-1.4,3.4) 54(-1.8,3.4) 55(-2.2,3.4) 56(-2.6,3.4)
  rect 1.75x2.6 smd: 57(-1.875,1.45)
  rect 1.75x2.55 smd: 58(-1.875,-1.475)
  rect 3.4x5.5 smd: 59(1.05,0)
LPDB_LGA1200_CML_S_LP6930_MA
  oval 0.508x0.457 smd: A4(-16.188,18.288) AU1(-18.931,-14.631) AU39(18.016,-15.545) AU40(18.931,-15.545) B3(-17.102,17.373) C2(-18.016,16.459) D1(-18.931,15.545) D40(18.931,14.631)
  oval 0.355x0.457 smd: A5(-15.273,18.288) A6(-14.359,18.288) A7(-13.444,18.288) A8(-12.53,18.288) A12(-8.872,18.288) A13(-7.958,18.288) A14(-7.044,18.288) A15(-6.129,18.288) A16(-5.215,18.288) A17(-4.3,18.288) A18(-3.386,18.288) A23(1.186,18.288) A24(2.1,18.288) A25(3.015,18.288) A26(3.929,18.288) A27(4.844,18.288) A28(5.758,18.288) A29(6.672,18.288) A30(7.587,18.288) A31(10.701,17.374) A32(11.616,17.374) A33(12.53,17.374) A34(13.444,17.374) A35(14.359,17.374) A36(15.273,17.374) A37(16.188,17.374) AB38(17.102,-1.829) AU18(-1.186,-15.545) AU19(-0.272,-15.545) AU20(0.643,-15.545) AU21(1.557,-15.545) AU22(2.472,-15.545) AU23(3.386,-15.545) AV14(-4.844,-16.459) AV15(-3.929,-16.459) AV16(-3.015,-16.459) AV17(-2.1,-16.459) AV18(-1.186,-16.459) AV19(-0.272,-16.459) AV20(0.643,-16.459) AV21(1.557,-16.459) AV22(2.472,-16.459) AV23(3.386,-16.459) AV24(4.3,-16.459) AV25(5.215,-16.459) AV26(6.129,-16.459) AV27(7.044,-16.459) AV28(7.958,-16.459) AV29(8.872,-16.459) AV30(9.787,-16.459) AV31(10.701,-16.459) AW4(-16.188,-16.459) AW5(-15.273,-16.459) AW6(-14.359,-16.459) AW7(-13.444,-16.459) AW8(-12.53,-16.459) AW9(-11.616,-16.459) AW10(-10.701,-16.459) AW12(-6.672,-17.373) AW13(-5.758,-17.373) AW14(-4.844,-17.373) AW15(-3.929,-17.373) AW16(-3.015,-17.373) AW17(-2.1,-17.373) AW18(-1.186,-17.373) AW23(3.386,-17.373) AW24(4.3,-17.373) AW25(5.215,-17.373) AW26(6.129,-17.373) AW27(7.044,-17.373) AW28(7.958,-17.373) AW29(8.872,-17.373) AW30(9.787,-17.373) AW31(10.701,-17.373) AW32(11.616,-17.373) AW33(12.53,-17.373) AW34(13.444,-17.373) AW35(14.359,-17.373) AW36(15.273,-17.373) AY4(-16.188,-17.374) AY5(-15.273,-17.374) AY6(-14.359,-17.374) AY7(-13.444,-17.374) AY8(-12.53,-17.374) AY12(-6.672,-18.288) AY13(-5.758,-18.288) AY14(-4.844,-18.288) AY15(-3.929,-18.288) AY16(-3.015,-18.288) AY17(-2.1,-18.288) AY18(-1.186,-18.288) AY23(3.386,-18.288) AY24(4.3,-18.288) AY25(5.215,-18.288) AY26(6.129,-18.288) AY27(7.044,-18.288) AY28(7.958,-18.288) AY29(8.872,-18.288) AY30(9.787,-18.288) AY31(10.701,-18.288) AY32(11.616,-18.288) AY33(12.53,-18.288) AY34(13.444,-18.288) AY35(14.359,-18.288) AY36(15.273,-18.288) B6(-14.359,17.373) B8(-12.53,17.373) B9(-11.616,17.373) B10(-10.701,17.373) B11(-9.787,17.373) B12(-8.872,17.373) B13(-7.958,17.373) B14(-7.044,17.373) B15(-6.129,17.373) B36(15.273,16.459) B37(16.188,16.459) B38(17.102,16.459) C9(-11.616,16.459) C10(-10.701,16.459) C11(-9.787,16.459) C12(-8.872,16.459) C13(-7.958,16.459) D3(-17.102,15.545) D10(-10.701,15.545) F3(-17.102,13.716) H3(-17.102,11.887) K3(-17.102,10.058) M3(-17.102,8.229) N3(-17.102,7.315) P3(-17.102,6.401) W3(-17.102,1.829) Y3(-17.102,0.914)
  oval 0.457x0.508 smd: A38(17.102,17.374) AW3(-17.102,-16.459) AY3(-17.102,-17.374)
  oval 0.457x0.355 smd: AA3(-17.102,0) AA4(-16.188,0) AB3(-17.102,-0.915) AB4(-16.188,-0.915) AB39(18.016,-1.829) AB40(18.931,-1.829) AC1(-18.931,-1.829) AC2(-18.016,-1.829) AC3(-17.102,-1.829) AC38(17.102,-2.743) AC39(18.016,-2.743) AC40(18.931,-2.743) AD1(-18.931,-2.743) AD2(-18.016,-2.743) AD38(17.102,-3.657) AD39(18.016,-3.657) AD40(18.931,-3.657) AE1(-18.931,-3.658) AE2(-18.016,-3.658) AE39(18.016,-4.572) AE40(18.931,-4.572) AF1(-18.931,-4.572) AF2(-18.016,-4.572) AF39(18.016,-5.486) AF40(18.931,-5.486) AG1(-18.931,-5.487) AG2(-18.016,-5.487) AG39(18.016,-6.401) AG40(18.931,-6.401) AH1(-18.931,-6.401) AH2(-18.016,-6.401) AH39(18.016,-7.315) AH40(18.931,-7.315) AJ1(-18.931,-7.315) AJ2(-18.016,-7.315) AJ39(18.016,-8.229) AJ40(18.931,-8.229) AK1(-18.931,-8.23) AK2(-18.016,-8.23) AK39(18.016,-9.144) AK40(18.931,-9.144) AL1(-18.931,-9.144) AL2(-18.016,-9.144) AL39(18.016,-10.058) AL40(18.931,-10.058) AM1(-18.931,-10.059) AM2(-18.016,-10.059) AM39(18.016,-10.973) AM40(18.931,-10.973) AN1(-18.931,-10.973) AN2(-18.016,-10.973) AN39(18.016,-11.887) AN40(18.931,-11.887) AP1(-18.931,-11.887) AP2(-18.016,-11.887) AP39(18.016,-12.801) AP40(18.931,-12.801) AR1(-18.931,-12.802) AR2(-18.016,-12.802) AR39(18.016,-13.716) AR40(18.931,-13.716) AT1(-18.931,-13.716) AT2(-18.016,-13.716) AT39(18.016,-14.63) AT40(18.931,-14.63) B4(-16.188,17.373) B5(-15.273,17.373) C3(-17.102,16.459) C4(-16.188,16.459) D2(-18.016,15.545) E1(-18.931,14.63) E2(-18.016,14.63) E39(18.016,13.716) E40(18.931,13.716) F1(-18.931,13.716) F2(-18.016,13.716) F39(18.016,12.802) F40(18.931,12.802) G1(-18.931,12.801) G2(-18.016,12.801) G39(18.016,11.887) G40(18.931,11.887) H1(-18.931,11.887) H2(-18.016,11.887) H39(18.016,10.973) H40(18.931,10.973) J1(-18.931,10.973) J2(-18.016,10.973) J39(18.016,10.059) J40(18.931,10.059) K1(-18.931,10.058) K2(-18.016,10.058) K39(18.016,9.144) K40(18.931,9.144) L1(-18.931,9.144) L2(-18.016,9.144) L39(18.016,8.23) L40(18.931,8.23) M1(-18.931,8.229) M2(-18.016,8.229) M39(18.016,7.315) M40(18.931,7.315) N1(-18.931,7.315) N2(-18.016,7.315) N39(18.016,6.401) N40(18.931,6.401) P1(-18.931,6.401) P2(-18.016,6.401) P40(18.931,5.487) R1(-18.931,5.486) R2(-18.016,5.486) R40(18.931,4.572) T1(-18.931,4.572) T2(-18.016,4.572) T40(18.931,3.658) U1(-18.931,3.657) U2(-18.016,3.657) U40(18.931,2.743) V1(-18.931,2.743) V2(-18.016,2.743) V40(18.931,1.829) W1(-18.931,1.829) W2(-18.016,1.829)
  round 0.419 smd: AA5(-15.273,0) AA6(-14.359,0) AA7(-13.444,0) AA8(-12.53,0) AB5(-15.273,-0.915) AB6(-14.359,-0.915) AB7(-13.444,-0.915) AB8(-12.53,-0.915) AB37(16.188,-1.829) AC4(-16.188,-1.829) AC5(-15.273,-1.829) AC6(-14.359,-1.829) AC7(-13.444,-1.829) AC8(-12.53,-1.829) AC33(12.53,-2.743) AC34(13.444,-2.743) AC35(14.359,-2.743) AC36(15.273,-2.743) AC37(16.188,-2.743) AD3(-17.102,-2.743) AD4(-16.188,-2.743) AD5(-15.273,-2.743) AD6(-14.359,-2.743) AD7(-13.444,-2.743) AD8(-12.53,-2.743) AD33(12.53,-3.657) AD34(13.444,-3.657) AD35(14.359,-3.657) AD36(15.273,-3.657) AD37(16.188,-3.657) AE3(-17.102,-3.658) AE4(-16.188,-3.658) AE5(-15.273,-3.658) AE6(-14.359,-3.658) AE7(-13.444,-3.658) AE8(-12.53,-3.658) AE33(12.53,-4.572) AE34(13.444,-4.572) AE35(14.359,-4.572) AE36(15.273,-4.572) AE37(16.188,-4.572) AE38(17.102,-4.572) AF3(-17.102,-4.572) AF4(-16.188,-4.572) AF5(-15.273,-4.572) AF6(-14.359,-4.572) AF7(-13.444,-4.572) AF8(-12.53,-4.572) AF33(12.53,-5.486) AF34(13.444,-5.486) AF35(14.359,-5.486) AF36(15.273,-5.486) AF37(16.188,-5.486) AF38(17.102,-5.486) AG3(-17.102,-5.487) AG4(-16.188,-5.487) AG5(-15.273,-5.487) AG6(-14.359,-5.487) AG7(-13.444,-5.487) AG8(-12.53,-5.487) AG33(12.53,-6.401) AG34(13.444,-6.401) AG35(14.359,-6.401) AG36(15.273,-6.401) AG37(16.188,-6.401) AG38(17.102,-6.401) AH3(-17.102,-6.401) AH4(-16.188,-6.401) AH5(-15.273,-6.401) AH6(-14.359,-6.401) AH7(-13.444,-6.401) AH8(-12.53,-6.401) AH32(11.616,-7.315) AH33(12.53,-7.315) AH34(13.444,-7.315) AH35(14.359,-7.315) AH36(15.273,-7.315) AH37(16.188,-7.315) AH38(17.102,-7.315) AJ3(-17.102,-7.315) AJ4(-16.188,-7.315) AJ5(-15.273,-7.315) AJ6(-14.359,-7.315) AJ7(-13.444,-7.315) AJ8(-12.53,-7.315) AJ9(-11.616,-7.315) AJ11(-7.587,-8.229) AJ25(5.215,-8.229) AJ26(6.129,-8.229) AJ27(7.044,-8.229) AJ28(7.958,-8.229) AJ29(8.872,-8.229) AJ30(9.787,-8.229) AJ31(10.701,-8.229) AJ32(11.616,-8.229) AJ33(12.53,-8.229) AJ34(13.444,-8.229) AJ35(14.359,-8.229) AJ36(15.273,-8.229) AJ37(16.188,-8.229) AJ38(17.102,-8.229) AK3(-17.102,-8.23) AK4(-16.188,-8.23) AK5(-15.273,-8.23) AK6(-14.359,-8.23) AK7(-13.444,-8.23) AK8(-12.53,-8.23) AK9(-11.616,-8.23) AK10(-10.701,-8.23) AK11(-7.587,-9.144) AK12(-6.672,-9.144) AK24(4.3,-9.144) AK25(5.215,-9.144) AK26(6.129,-9.144) AK27(7.044,-9.144) AK28(7.958,-9.144) AK29(8.872,-9.144) AK30(9.787,-9.144) AK31(10.701,-9.144) AK32(11.616,-9.144) AK33(12.53,-9.144) AK34(13.444,-9.144) AK35(14.359,-9.144) AK36(15.273,-9.144) AK37(16.188,-9.144) AK38(17.102,-9.144) AL3(-17.102,-9.144) AL4(-16.188,-9.144) AL5(-15.273,-9.144) AL6(-14.359,-9.144) AL7(-13.444,-9.144) AL8(-12.53,-9.144) AL9(-11.616,-9.144) AL10(-10.701,-9.144) AL11(-7.587,-10.058) AL12(-6.672,-10.058) AL13(-5.758,-10.058) AL14(-4.844,-10.058) AL15(-3.929,-10.058) AL16(-3.015,-10.058) AL17(-2.1,-10.058) AL18(-1.186,-10.058) AL19(-0.272,-10.058) AL20(0.643,-10.058) AL21(1.557,-10.058) AL22(2.472,-10.058) AL23(3.386,-10.058) AL24(4.3,-10.058) AL25(5.215,-10.058) AL26(6.129,-10.058) AL27(7.044,-10.058) AL28(7.958,-10.058) AL29(8.872,-10.058) AL30(9.787,-10.058) AL31(10.701,-10.058) AL32(11.616,-10.058) AL33(12.53,-10.058) AL34(13.444,-10.058) AL35(14.359,-10.058) AL36(15.273,-10.058) AL37(16.188,-10.058) AL38(17.102,-10.058) AM3(-17.102,-10.059) AM4(-16.188,-10.059) AM5(-15.273,-10.059) AM6(-14.359,-10.059) AM7(-13.444,-10.059) AM8(-12.53,-10.059) AM9(-11.616,-10.059) AM10(-10.701,-10.059) AM11(-7.587,-10.973) AM12(-6.672,-10.973) AM13(-5.758,-10.973) AM14(-4.844,-10.973) AM15(-3.929,-10.973) AM16(-3.015,-10.973) AM17(-2.1,-10.973) AM18(-1.186,-10.973) AM19(-0.272,-10.973) AM20(0.643,-10.973) AM21(1.557,-10.973) AM22(2.472,-10.973) AM23(3.386,-10.973) AM24(4.3,-10.973) AM25(5.215,-10.973) AM26(6.129,-10.973) AM27(7.044,-10.973) AM28(7.958,-10.973) AM29(8.872,-10.973) AM30(9.787,-10.973) AM31(10.701,-10.973) AM32(11.616,-10.973) AM33(12.53,-10.973) AM34(13.444,-10.973) AM35(14.359,-10.973) AM36(15.273,-10.973) AM37(16.188,-10.973) AM38(17.102,-10.973) AN3(-17.102,-10.973) AN4(-16.188,-10.973) AN5(-15.273,-10.973) AN6(-14.359,-10.973) AN7(-13.444,-10.973) AN8(-12.53,-10.973) AN9(-11.616,-10.973) AN10(-10.701,-10.973) AN11(-7.587,-11.887) AN12(-6.672,-11.887) AN13(-5.758,-11.887) AN14(-4.844,-11.887) AN15(-3.929,-11.887) AN16(-3.015,-11.887) AN17(-2.1,-11.887) AN18(-1.186,-11.887) AN19(-0.272,-11.887) AN20(0.643,-11.887) AN21(1.557,-11.887) AN22(2.472,-11.887) AN23(3.386,-11.887) AN24(4.3,-11.887) AN25(5.215,-11.887) AN26(6.129,-11.887) AN27(7.044,-11.887) AN28(7.958,-11.887) AN29(8.872,-11.887) AN30(9.787,-11.887) AN31(10.701,-11.887) AN32(11.616,-11.887) AN33(12.53,-11.887) AN34(13.444,-11.887) AN35(14.359,-11.887) AN36(15.273,-11.887) AN37(16.188,-11.887) AN38(17.102,-11.887) AP3(-17.102,-11.887) AP4(-16.188,-11.887) AP5(-15.273,-11.887) AP6(-14.359,-11.887) AP7(-13.444,-11.887) AP8(-12.53,-11.887) AP9(-11.616,-11.887) AP10(-10.701,-11.887) AP11(-7.587,-12.801) AP12(-6.672,-12.801) AP13(-5.758,-12.801) AP14(-4.844,-12.801) AP15(-3.929,-12.801) AP16(-3.015,-12.801) AP17(-2.1,-12.801) AP18(-1.186,-12.801) AP19(-0.272,-12.801) AP20(0.643,-12.801) AP21(1.557,-12.801) AP22(2.472,-12.801) AP23(3.386,-12.801) AP24(4.3,-12.801) AP25(5.215,-12.801) AP26(6.129,-12.801) AP27(7.044,-12.801) AP28(7.958,-12.801) AP29(8.872,-12.801) AP30(9.787,-12.801) AP31(10.701,-12.801) AP32(11.616,-12.801) AP33(12.53,-12.801) AP34(13.444,-12.801) AP35(14.359,-12.801) AP36(15.273,-12.801) AP37(16.188,-12.801) AP38(17.102,-12.801) AR3(-17.102,-12.802) AR4(-16.188,-12.802) AR5(-15.273,-12.802) AR6(-14.359,-12.802) AR7(-13.444,-12.802) AR8(-12.53,-12.802) AR9(-11.616,-12.802) AR10(-10.701,-12.802) AR11(-7.587,-13.716) AR12(-6.672,-13.716) AR13(-5.758,-13.716) AR14(-4.844,-13.716) AR15(-3.929,-13.716) AR16(-3.015,-13.716) AR17(-2.1,-13.716) AR18(-1.186,-13.716) AR19(-0.272,-13.716) AR20(0.643,-13.716) AR21(1.557,-13.716) AR22(2.472,-13.716) AR23(3.386,-13.716) AR24(4.3,-13.716) AR25(5.215,-13.716) AR26(6.129,-13.716) AR27(7.044,-13.716) AR28(7.958,-13.716) AR29(8.872,-13.716) AR30(9.787,-13.716) AR31(10.701,-13.716) AR32(11.616,-13.716) AR33(12.53,-13.716) AR34(13.444,-13.716) AR35(14.359,-13.716) AR36(15.273,-13.716) AR37(16.188,-13.716) AR38(17.102,-13.716) AT3(-17.102,-13.716) AT4(-16.188,-13.716) AT5(-15.273,-13.716) AT6(-14.359,-13.716) AT7(-13.444,-13.716) AT8(-12.53,-13.716) AT9(-11.616,-13.716) AT10(-10.701,-13.716) AT11(-7.587,-14.63) AT12(-6.672,-14.63) AT13(-5.758,-14.63) AT14(-4.844,-14.63) AT15(-3.929,-14.63) AT16(-3.015,-14.63) AT17(-2.1,-14.63) AT18(-1.186,-14.63) AT19(-0.272,-14.63) AT20(0.643,-14.63) AT21(1.557,-14.63) AT22(2.472,-14.63) AT23(3.386,-14.63) AT24(4.3,-14.63) AT25(5.215,-14.63) AT26(6.129,-14.63) AT27(7.044,-14.63) AT28(7.958,-14.63) AT29(8.872,-14.63) AT30(9.787,-14.63) AT31(10.701,-14.63) AT32(11.616,-14.63) AT33(12.53,-14.63) AT34(13.444,-14.63) AT35(14.359,-14.63) AT36(15.273,-14.63) AT37(16.188,-14.63) AT38(17.102,-14.63) AU2(-18.016,-14.631) AU3(-17.102,-14.631) AU4(-16.188,-14.631) AU5(-15.273,-14.631) AU6(-14.359,-14.631) AU7(-13.444,-14.631) AU8(-12.53,-14.631) AU9(-11.616,-14.631) AU10(-10.701,-14.631) AU11(-7.587,-15.545) AU12(-6.672,-15.545) AU13(-5.758,-15.545) AU14(-4.844,-15.545) AU15(-3.929,-15.545) AU16(-3.015,-15.545) AU17(-2.1,-15.545) AU24(4.3,-15.545) AU25(5.215,-15.545) AU26(6.129,-15.545) AU27(7.044,-15.545) AU28(7.958,-15.545) AU29(8.872,-15.545) AU30(9.787,-15.545) AU31(10.701,-15.545) AU32(11.616,-15.545) AU33(12.53,-15.545) AU34(13.444,-15.545) AU35(14.359,-15.545) AU36(15.273,-15.545) AU37(16.188,-15.545) AU38(17.102,-15.545) AV3(-17.102,-15.545) AV4(-16.188,-15.545) AV5(-15.273,-15.545) AV6(-14.359,-15.545) AV7(-13.444,-15.545) AV8(-12.53,-15.545) AV9(-11.616,-15.545) AV10(-10.701,-15.545) AV11(-7.587,-16.459) AV12(-6.672,-16.459) AV13(-5.758,-16.459) AV32(11.616,-16.459) AV33(12.53,-16.459) AV34(13.444,-16.459) AV35(14.359,-16.459) AV36(15.273,-16.459) AV37(16.188,-16.459) AW11(-7.587,-17.373) B7(-13.444,17.373) B16(-5.215,17.373) B17(-4.3,17.373) C5(-15.273,16.459) C6(-14.359,16.459) C7(-13.444,16.459) C8(-12.53,16.459) C14(-7.044,16.459) C15(-6.129,16.459) C16(-5.215,16.459) C17(-4.3,16.459) C36(15.273,15.545) C37(16.188,15.545) C38(17.102,15.545) D4(-16.188,15.545) D5(-15.273,15.545) D6(-14.359,15.545) D7(-13.444,15.545) D8(-12.53,15.545) D9(-11.616,15.545) D11(-9.787,15.545) D12(-8.872,15.545) D13(-7.958,15.545) D14(-7.044,15.545) D15(-6.129,15.545) D16(-5.215,15.545) D17(-4.3,15.545) D36(15.273,14.631) D37(16.188,14.631) D38(17.102,14.631) D39(18.016,14.631) E3(-17.102,14.63) E4(-16.188,14.63) E5(-15.273,14.63) E6(-14.359,14.63) E7(-13.444,14.63) E8(-12.53,14.63) E9(-11.616,14.63) E10(-10.701,14.63) E11(-9.787,14.63) E12(-8.872,14.63) E13(-7.958,14.63) E14(-7.044,14.63) E15(-6.129,14.63) E16(-5.215,14.63) E17(-4.3,14.63) E35(14.359,13.716) E36(15.273,13.716) E37(16.188,13.716) E38(17.102,13.716) F4(-16.188,13.716) F5(-15.273,13.716) F6(-14.359,13.716) F7(-13.444,13.716) F8(-12.53,13.716) F9(-11.616,13.716) F10(-10.701,13.716) F11(-9.787,13.716) F12(-8.872,13.716) F13(-7.958,13.716) F14(-7.044,13.716) F15(-6.129,13.716) F16(-5.215,13.716) F17(-4.3,13.716) F35(14.359,12.802) F36(15.273,12.802) F37(16.188,12.802) F38(17.102,12.802) G3(-17.102,12.801) G4(-16.188,12.801) G5(-15.273,12.801) G6(-14.359,12.801) G7(-13.444,12.801) G8(-12.53,12.801) G9(-11.616,12.801) G10(-10.701,12.801) G11(-9.787,12.801) G12(-8.872,12.801) G13(-7.958,12.801) G14(-7.044,12.801) G15(-6.129,12.801) G16(-5.215,12.801) G17(-4.3,12.801) G35(14.359,11.887) G36(15.273,11.887) G37(16.188,11.887) G38(17.102,11.887) H4(-16.188,11.887) H5(-15.273,11.887) H6(-14.359,11.887) H7(-13.444,11.887) H8(-12.53,11.887) H9(-11.616,11.887) H10(-10.701,11.887) H11(-9.787,11.887) H12(-8.872,11.887) H13(-7.958,11.887) H14(-7.044,11.887) H15(-6.129,11.887) H16(-5.215,11.887) H17(-4.3,11.887) H35(14.359,10.973) H36(15.273,10.973) H37(16.188,10.973) H38(17.102,10.973) J3(-17.102,10.973) J4(-16.188,10.973) J5(-15.273,10.973) J6(-14.359,10.973) J7(-13.444,10.973) J8(-12.53,10.973) J9(-11.616,10.973) J10(-10.701,10.973) J11(-9.787,10.973) J12(-8.872,10.973) J13(-7.958,10.973) J14(-7.044,10.973) J15(-6.129,10.973) J16(-5.215,10.973) J17(-4.3,10.973) J35(14.359,10.059) J36(15.273,10.059) J37(16.188,10.059) J38(17.102,10.059) K4(-16.188,10.058) K5(-15.273,10.058) K6(-14.359,10.058) K7(-13.444,10.058) K8(-12.53,10.058) K9(-11.616,10.058) K10(-10.701,10.058) K11(-9.787,10.058) K12(-8.872,10.058) K13(-7.958,10.058) K14(-7.044,10.058) K15(-6.129,10.058) K16(-5.215,10.058) K17(-4.3,10.058) K34(13.444,9.144) K35(14.359,9.144) K36(15.273,9.144) K37(16.188,9.144) K38(17.102,9.144) L3(-17.102,9.144) L4(-16.188,9.144) L5(-15.273,9.144) L6(-14.359,9.144) L7(-13.444,9.144) L8(-12.53,9.144) L9(-11.616,9.144) L10(-10.701,9.144) L11(-9.787,9.144) L12(-8.872,9.144) L13(-7.958,9.144) L14(-7.044,9.144) L15(-6.129,9.144) L16(-5.215,9.144) L17(-4.3,9.144) L33(12.53,8.23) L34(13.444,8.23) L35(14.359,8.23) L36(15.273,8.23) L37(16.188,8.23) L38(17.102,8.23) M4(-16.188,8.229) M5(-15.273,8.229) M6(-14.359,8.229) M7(-13.444,8.229) M8(-12.53,8.229) M9(-11.616,8.229) M10(-10.701,8.229) M11(-9.787,8.229) M12(-8.872,8.229) M13(-7.958,8.229) M14(-7.044,8.229) M15(-6.129,8.229) M16(-5.215,8.229) M17(-4.3,8.229) M33(12.53,7.315) M34(13.444,7.315) M35(14.359,7.315) M36(15.273,7.315) M37(16.188,7.315) M38(17.102,7.315) N4(-16.188,7.315) N5(-15.273,7.315) N6(-14.359,7.315) N7(-13.444,7.315) N8(-12.53,7.315) N9(-11.616,7.315) N10(-10.701,7.315) N11(-9.787,7.315) N12(-8.872,7.315) N13(-7.958,7.315) N14(-7.044,7.315) N15(-6.129,7.315) N16(-5.215,7.315) N17(-4.3,7.315) N33(12.53,6.401) N34(13.444,6.401) N35(14.359,6.401) N36(15.273,6.401) N37(16.188,6.401) N38(17.102,6.401) P4(-16.188,6.401) P5(-15.273,6.401) P6(-14.359,6.401) P7(-13.444,6.401) P8(-12.53,6.401) P32(11.616,5.487) P33(12.53,5.487) P34(13.444,5.487) P35(14.359,5.487) P36(15.273,5.487) P37(16.188,5.487) P38(17.102,5.487) P39(18.016,5.487) R3(-17.102,5.486) R4(-16.188,5.486) R5(-15.273,5.486) R6(-14.359,5.486) R7(-13.444,5.486) R8(-12.53,5.486) R32(11.616,4.572) R33(12.53,4.572) R34(13.444,4.572) R35(14.359,4.572) R36(15.273,4.572) T3(-17.102,4.572) T4(-16.188,4.572) T5(-15.273,4.572) T6(-14.359,4.572) T7(-13.444,4.572) T8(-12.53,4.572) T32(11.616,3.658) T33(12.53,3.658) U3(-17.102,3.657) U4(-16.188,3.657) U5(-15.273,3.657) U6(-14.359,3.657) U7(-13.444,3.657) U8(-12.53,3.657) V3(-17.102,2.743) V4(-16.188,2.743) V5(-15.273,2.743) V6(-14.359,2.743) V7(-13.444,2.743) V8(-12.53,2.743) W4(-16.188,1.829) W5(-15.273,1.829) W6(-14.359,1.829) W7(-13.444,1.829) W8(-12.53,1.829) Y4(-16.188,0.914) Y5(-15.273,0.914) Y6(-14.359,0.914) Y7(-13.444,0.914) Y8(-12.53,0.914)
  round 0.429 smd: AA32(11.616,-0.914) AA33(12.53,-0.914) AA34(13.444,-0.914) AA35(14.359,-0.914) AA36(15.273,-0.914) AA37(16.188,-0.914) AA38(17.102,-0.914) AB32(11.616,-1.829) AB33(12.53,-1.829) AB34(13.444,-1.829) AB35(14.359,-1.829) AB36(15.273,-1.829) AC32(11.616,-2.743) AD32(11.616,-3.657) AE32(11.616,-4.572) AF32(11.616,-5.486) AG32(11.616,-6.401) AJ12(-6.672,-8.229) AJ13(-5.758,-8.229) AJ14(-4.844,-8.229) AJ15(-3.929,-8.229) AJ16(-3.015,-8.229) AJ17(-2.1,-8.229) AJ18(-1.186,-8.229) AJ19(-0.272,-8.229) AJ20(0.643,-8.229) AJ21(1.557,-8.229) AJ22(2.472,-8.229) AJ23(3.386,-8.229) AJ24(4.3,-8.229) AK13(-5.758,-9.144) AK14(-4.844,-9.144) AK15(-3.929,-9.144) AK16(-3.015,-9.144) AK17(-2.1,-9.144) AK18(-1.186,-9.144) AK19(-0.272,-9.144) AK20(0.643,-9.144) AK21(1.557,-9.144) AK22(2.472,-9.144) AK23(3.386,-9.144) B18(-3.386,17.373) B23(1.186,17.373) B24(2.1,17.373) B25(3.015,17.373) B26(3.929,17.373) B27(4.844,17.373) B28(5.758,17.373) B29(6.672,17.373) B30(7.587,17.373) B31(10.701,16.459) B32(11.616,16.459) B33(12.53,16.459) B34(13.444,16.459) B35(14.359,16.459) C18(-3.386,16.459) C19(-2.472,16.459) C20(-1.557,16.459) C21(-0.643,16.459) C22(0.272,16.459) C23(1.186,16.459) C24(2.1,16.459) C25(3.015,16.459) C26(3.929,16.459) C27(4.844,16.459) C28(5.758,16.459) C29(6.672,16.459) C30(7.587,16.459) C31(10.701,15.545) C32(11.616,15.545) C33(12.53,15.545) C34(13.444,15.545) C35(14.359,15.545) D18(-3.386,15.545) D19(-2.472,15.545) D20(-1.557,15.545) D21(-0.643,15.545) D22(0.272,15.545) D23(1.186,15.545) D24(2.1,15.545) D25(3.015,15.545) D26(3.929,15.545) D27(4.844,15.545) D28(5.758,15.545) D29(6.672,15.545) D30(7.587,15.545) D31(10.701,14.631) D32(11.616,14.631) D33(12.53,14.631) D34(13.444,14.631) D35(14.359,14.631) E18(-3.386,14.63) E19(-2.472,14.63) E20(-1.557,14.63) E21(-0.643,14.63) E22(0.272,14.63) E23(1.186,14.63) E24(2.1,14.63) E25(3.015,14.63) E26(3.929,14.63) E27(4.844,14.63) E28(5.758,14.63) E29(6.672,14.63) E30(7.587,14.63) E31(10.701,13.716) E32(11.616,13.716) E33(12.53,13.716) E34(13.444,13.716) F18(-3.386,13.716) F19(-2.472,13.716) F20(-1.557,13.716) F21(-0.643,13.716) F22(0.272,13.716) F23(1.186,13.716) F24(2.1,13.716) F25(3.015,13.716) F26(3.929,13.716) F27(4.844,13.716) F28(5.758,13.716) F29(6.672,13.716) F30(7.587,13.716) F31(10.701,12.802) F32(11.616,12.802) F33(12.53,12.802) F34(13.444,12.802) G18(-3.386,12.801) G19(-2.472,12.801) G20(-1.557,12.801) G21(-0.643,12.801) G22(0.272,12.801) G23(1.186,12.801) G24(2.1,12.801) G25(3.015,12.801) G26(3.929,12.801) G27(4.844,12.801) G28(5.758,12.801) G29(6.672,12.801) G30(7.587,12.801) G31(10.701,11.887) G32(11.616,11.887) G33(12.53,11.887) G34(13.444,11.887) H18(-3.386,11.887) H19(-2.472,11.887) H20(-1.557,11.887) H21(-0.643,11.887) H22(0.272,11.887) H23(1.186,11.887) H24(2.1,11.887) H25(3.015,11.887) H26(3.929,11.887) H27(4.844,11.887) H28(5.758,11.887) H29(6.672,11.887) H30(7.587,11.887) H31(10.701,10.973) H32(11.616,10.973) H33(12.53,10.973) H34(13.444,10.973) J18(-3.386,10.973) J19(-2.472,10.973) J20(-1.557,10.973) J21(-0.643,10.973) J22(0.272,10.973) J23(1.186,10.973) J24(2.1,10.973) J25(3.015,10.973) J26(3.929,10.973) J27(4.844,10.973) J28(5.758,10.973) J29(6.672,10.973) J30(7.587,10.973) J31(10.701,10.059) J32(11.616,10.059) J33(12.53,10.059) J34(13.444,10.059) K18(-3.386,10.058) K19(-2.472,10.058) K20(-1.557,10.058) K21(-0.643,10.058) K22(0.272,10.058) K23(1.186,10.058) K24(2.1,10.058) K25(3.015,10.058) K26(3.929,10.058) K27(4.844,10.058) K28(5.758,10.058) K29(6.672,10.058) K30(7.587,10.058) K31(10.701,9.144) K32(11.616,9.144) K33(12.53,9.144) L18(-3.386,9.144) L19(-2.472,9.144) L20(-1.557,9.144) L21(-0.643,9.144) L22(0.272,9.144) L23(1.186,9.144) L24(2.1,9.144) L25(3.015,9.144) L26(3.929,9.144) L27(4.844,9.144) L28(5.758,9.144) L29(6.672,9.144) L30(7.587,9.144) L31(10.701,8.23) L32(11.616,8.23) M18(-3.386,8.229) M19(-2.472,8.229) M20(-1.557,8.229) M21(-0.643,8.229) M22(0.272,8.229) M23(1.186,8.229) M24(2.1,8.229) M25(3.015,8.229) M26(3.929,8.229) M27(4.844,8.229) M28(5.758,8.229) M29(6.672,8.229) M30(7.587,8.229) M31(10.701,7.315) M32(11.616,7.315) N18(-3.386,7.315) N19(-2.472,7.315) N20(-1.557,7.315) N21(-0.643,7.315) N22(0.272,7.315) N23(1.186,7.315) N24(2.1,7.315) N25(3.015,7.315) N26(3.929,7.315) N27(4.844,7.315) N28(5.758,7.315) N29(6.672,7.315) N30(7.587,7.315) N32(11.616,6.401) R37(16.188,4.572) R38(17.102,4.572) R39(18.016,4.572) T34(13.444,3.658) T35(14.359,3.658) T36(15.273,3.658) T37(16.188,3.658) T38(17.102,3.658) T39(18.016,3.658) U32(11.616,2.743) U33(12.53,2.743) U34(13.444,2.743) U35(14.359,2.743) U36(15.273,2.743) U37(16.188,2.743) U38(17.102,2.743) U39(18.016,2.743) V32(11.616,1.829) V33(12.53,1.829) V34(13.444,1.829) V35(14.359,1.829) V36(15.273,1.829) V37(16.188,1.829) V38(17.102,1.829) V39(18.016,1.829) W32(11.616,0.915) W33(12.53,0.915) W34(13.444,0.915) W35(14.359,0.915) W36(15.273,0.915) W37(16.188,0.915) W38(17.102,0.915) Y32(11.616,0) Y33(12.53,0) Y34(13.444,0) Y35(14.359,0) Y36(15.273,0) Y37(16.188,0) Y38(17.102,0)
  round 0.508 smd: AV1(-18.931,-15.545) AV2(-18.016,-15.545) AV38(17.102,-16.459) AV39(18.016,-16.459) AW2(-18.016,-16.459) AW37(16.188,-17.373) AW38(17.102,-17.373) B39(18.016,16.459) C39(18.016,15.545) C40(18.931,15.545)
LPDB_XLGA1200_CML_S_LP6930_MA_KOZ
  round 0.254 hole 4.03 unplated: (-38.115,37.5) (-38.115,-37.5) (36.885,37.5) (36.885,-37.5)
  round 0.254 hole 3.8 unplated: (-34.91,0) (26.11,18) (26.11,-18)
MICROSD_SJR_10P_4EM_MA
  rect 0.7x1.2 smd: 1(0,0) 2(-1.1,0) 3(-2.2,0) 4(-3.3,0) 5(-4.4,0) 6(-5.5,0) 7(-6.6,0) 8(-7.7,0) 9(-8.65,0)
  rect 1x0.8 smd: 10(-9.6,-10.5)
  rect 1x1.2 smd: 11(1.55,0) 12(-9.6,-4.3)
  rect 1x2.8 smd: 13(-9.6,-14.65)
  rect 1.3x1.9 smd: 14(3.9,-15.1)
PCIE_SJR_75P_KEYE_2EM_2M_MB_KOZ_2230_CCG
  round 0.25 hole 1.1 unplated: (-4.725,0.75)
  round 0.25 hole 1.6 unplated: (-4.725,-19.25)
  rect 1.55x0.3 smd: 1(0,0) 2(-6.45,-0.25) 3(0,-0.5) 4(-6.45,-0.75) 5(0,-1) 6(-6.45,-1.25) 7(0,-1.5) 8(-6.45,-1.75) 9(0,-2) 10(-6.45,-2.25) 11(0,-2.5) 12(-6.45,-2.75) 13(0,-3) 14(-6.45,-3.25) 15(0,-3.5) 16(-6.45,-3.75) 17(0,-4) 18(-6.45,-4.25) 19(0,-4.5) 20(-6.45,-4.75) 21(0,-5) 22(-6.45,-5.25) 23(0,-5.5) 32(-6.45,-7.75) 33(0,-8) 34(-6.45,-8.25) 35(0,-8.5) 36(-6.45,-8.75) 37(0,-9) 38(-6.45,-9.25) 39(0,-9.5) 40(-6.45,-9.75) 41(0,-10) 42(-6.45,-10.25) 43(0,-10.5) 44(-6.45,-10.75) 45(0,-11) 46(-6.45,-11.25) 47(0,-11.5) 48(-6.45,-11.75) 49(0,-12) 50(-6.45,-12.25) 51(0,-12.5) 52(-6.45,-12.75) 53(0,-13) 54(-6.45,-13.25) 55(0,-13.5) 56(-6.45,-13.75) 57(0,-14) 58(-6.45,-14.25) 59(0,-14.5) 60(-6.45,-14.75) 61(0,-15) 62(-6.45,-15.25) 63(0,-15.5) 64(-6.45,-15.75) 65(0,-16) 66(-6.45,-16.25) 67(0,-16.5) 68(-6.45,-16.75) 69(0,-17) 70(-6.45,-17.25) 71(0,-17.5) 72(-6.45,-17.75) 73(0,-18) 74(-6.45,-18.25) 75(0,-18.5)
  rect 2.75x1.2 smd: MH1(-0.225,1.1) MH2(-0.225,-19.6)
PCIE_TPV_4X16_2M_MA_CCG
  round 0.25 hole 2.35 unplated: (-1.25,-11.65) (-1.25,-34.8)
  rect 1.075x1.075 hole 0.7: A1(0,0)
  round 1.075 hole 0.7: A2(2,-1) A3(0,-2) A4(2,-3) A5(0,-4) A6(2,-5) A7(0,-6) A8(2,-7) A9(0,-8) A10(2,-9) A11(0,-10) A12(2,-13) A13(0,-14) A14(2,-15) A15(0,-16) A16(2,-17) A17(0,-18) A18(2,-19) A19(0,-20) A20(2,-21) A21(0,-22) A22(2,-23) A23(0,-24) A24(2,-25) A25(0,-26) A26(2,-27) A27(0,-28) A28(2,-29) A29(0,-30) A30(2,-31) A31(0,-32) A32(2,-33) B1(-2.5,0) B2(-4.5,-1) B3(-2.5,-2) B4(-4.5,-3) B5(-2.5,-4) B6(-4.5,-5) B7(-2.5,-6) B8(-4.5,-7) B9(-2.5,-8) B10(-4.5,-9) B11(-2.5,-10) B12(-4.5,-13) B13(-2.5,-14) B14(-4.5,-15) B15(-2.5,-16) B16(-4.5,-17) B17(-2.5,-18) B18(-4.5,-19) B19(-2.5,-20) B20(-4.5,-21) B21(-2.5,-22) B22(-4.5,-23) B23(-2.5,-24) B24(-4.5,-25) B25(-2.5,-26) B26(-4.5,-27) B27(-2.5,-28) B28(-4.5,-29) B29(-2.5,-30) B30(-4.5,-31) B31(-2.5,-32) B32(-4.5,-33)
PCIE_TPV_4X41_2M_IA
  round 0.254 hole 2.362 unplated: (-1.25,-11.65) (-1.25,-84.802)
  rect 1.092x1.092 hole 0.711: A1(0,0)
  round 1.092 hole 0.711: A2(2,-1) A3(0,-2) A4(2,-3) A5(0,-4) A6(2,-5) A7(0,-6) A8(2,-7) A9(0,-8) A10(2,-9) A11(0,-10) A12(2,-13) A13(0,-14) A14(2,-15) A15(0,-16) A16(2,-17) A17(0,-18) A18(2,-19) A19(0,-20) A20(2,-21) A21(0,-22) A22(2,-23) A23(0,-24) A24(2,-25) A25(0,-26) A26(2,-27) A27(0,-28) A28(2,-29) A29(0,-30) A30(2,-31) A31(0,-32) A32(2,-33) A33(0,-34) A34(2,-35) A35(0,-36) A36(2,-37) A37(0,-38) A38(2,-39) A39(0,-40) A40(2,-41) A41(0,-42) A42(2,-43) A43(0,-44) A44(2,-45) A45(0,-46) A46(2,-47) A47(0,-48) A48(2,-49) A49(0,-50) A50(2,-51) A51(0,-52) A52(2,-53) A53(0,-54) A54(2,-55) A55(0,-56) A56(2,-57) A57(0,-58) A58(2,-59) A59(0,-60) A60(2,-61) A61(0,-62) A62(2,-63) A63(0,-64) A64(2,-65) A65(0,-66) A66(2,-67) A67(0,-68) A68(2,-69) A69(0,-70) A70(2,-71) A71(0,-72) A72(2,-73) A73(0,-74) A74(2,-75) A75(0,-76) A76(2,-77) A77(0,-78) A78(2,-79) A79(0,-80) A80(2,-81) A81(0,-82) A82(2,-83) B1(-2.5,0) B2(-4.5,-1) B3(-2.5,-2) B4(-4.5,-3) B5(-2.5,-4) B6(-4.5,-5) B7(-2.5,-6) B8(-4.5,-7) B9(-2.5,-8) B10(-4.5,-9) B11(-2.5,-10) B12(-4.5,-13) B13(-2.5,-14) B14(-4.5,-15) B15(-2.5,-16) B16(-4.5,-17) B17(-2.5,-18) B18(-4.5,-19) B19(-2.5,-20) B20(-4.5,-21) B21(-2.5,-22) B22(-4.5,-23) B23(-2.5,-24) B24(-4.5,-25) B25(-2.5,-26) B26(-4.5,-27) B27(-2.5,-28) B28(-4.5,-29) B29(-2.5,-30) B30(-4.5,-31) B31(-2.5,-32) B32(-4.5,-33) B33(-2.5,-34) B34(-4.5,-35) B35(-2.5,-36) B36(-4.5,-37) B37(-2.5,-38) B38(-4.5,-39) B39(-2.5,-40) B40(-4.5,-41) B41(-2.5,-42) B42(-4.5,-43) B43(-2.5,-44) B44(-4.5,-45) B45(-2.5,-46) B46(-4.5,-47) B47(-2.5,-48) B48(-4.5,-49) B49(-2.5,-50) B50(-4.5,-51) B51(-2.5,-52) B52(-4.5,-53) B53(-2.5,-54) B54(-4.5,-55) B55(-2.5,-56) B56(-4.5,-57) B57(-2.5,-58) B58(-4.5,-59) B59(-2.5,-60) B60(-4.5,-61) B61(-2.5,-62) B62(-4.5,-63) B63(-2.5,-64) B64(-4.5,-65) B65(-2.5,-66) B66(-4.5,-67) B67(-2.5,-68) B68(-4.5,-69) B69(-2.5,-70) B70(-4.5,-71) B71(-2.5,-72) B72(-4.5,-73) B73(-2.5,-74) B74(-4.5,-75) B75(-2.5,-76) B76(-4.5,-77) B77(-2.5,-78) B78(-4.5,-79) B79(-2.5,-80) B80(-4.5,-81) B81(-2.5,-82) B82(-4.5,-83)
