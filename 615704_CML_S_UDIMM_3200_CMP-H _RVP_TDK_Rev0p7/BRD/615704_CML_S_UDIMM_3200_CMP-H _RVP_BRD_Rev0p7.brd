# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_PM_DOWN_R: length 57.1
  TOP w0.089: 215.26,203.2 215.26,200.84 215.96,200.14 215.96,197.7 215.78,197.51 215.78,196.95 215.57,196.75 214.95,196.75 J3D1.D13
  TOP w0.1: 215.26,203.2 215.26,203.99 207.04,212.21 195.82,212.21 194.33,213.69 183.77,213.69 177.8,219.67 R4C6.1
H_PM_SYNC: length 522.3
  TOP w0.089: 216.89,201.55 216.89,200.25 216.83,200.2 216.83,197.93 216.29,197.39 J3D1.C15
  TOP w0.1: v1(179.32,228.22) 179.45,228.08 179.45,225.53 179.95,225.03 179.95,223.02 179.56,222.63 179.56,220.16 179.99,219.73 180.93,219.73 182.96,221.76 185.71,221.76 189.57,217.9 193.2,217.9 197.15,213.96 207.68,213.96 v1(215.39,206.25) 216.89,204.75 216.89,201.55 ; v1(136.9,213.49) 136.29,212.88 130.02,212.88 128.85,211.71 126.71,211.71 126.21,212.21 125.47,212.21 124.31,213.36 122.89,213.36 122.01,212.48 102.38,212.48 96.13,206.23 96.13,191.75 95.46,191.08 95.46,188.08 96.13,187.41 96.13,181.29 97.53,179.89 97.53,174.3 100.83,171 R6D66.1
  LAY5 w0.125: v1(151.45,51.75) 163.18,51.75 170.02,58.59 171.13,58.59 173.39,60.85 173.39,64.32 179.38,70.32 197.81,70.32 198.67,71.18 209.63,71.18 210.24,70.57 217.23,70.57 217.84,71.18 230.97,71.18 232.81,69.34 238.88,69.34 v1(243.71,64.51)
  LAY6 w0.125: v1(215.39,206.25) 214.75,206.25 214.49,205.98 211.31,205.98 202.31,196.98 202.31,195.96 199.84,193.5 199.84,187.48 188.62,176.25 188.62,175.33 186.88,173.6 180.62,173.6 179.69,174.53 177.69,174.53 174.57,171.42 174.57,168.94 171.04,165.41 171.04,164.38 170.23,163.57 169,163.57 163.67,158.25 163.67,157.01 161.97,155.31 161.97,153.33 160.93,152.3 159.79,152.3 149.76,142.27 149.76,136.55 150.62,135.68 150.62,134.04 151.98,132.68 151.98,120.56 150.2,118.78 150.2,113.13 151.55,111.78 151.55,99.67 150.15,98.28 150.15,85.61 152.33,83.43 152.33,78.72 151.5,77.89 151.5,51.8 v1(151.45,51.75)
  BOTTOM w0.1: v1(136.9,213.49) 137.75,214.34 137.75,216.66 137.5,216.91 137.5,233.64 139.93,236.07 139.93,236.89 140.93,237.89 144.18,237.89 145.81,236.26 145.81,235.83 148.58,233.06 149.6,233.06 150.72,231.93 151.96,231.93 152.71,232.69 152.71,233.87 153.84,235 159.56,235 160.13,234.43 163.98,234.43 167.67,230.74 173.5,230.74 176.02,228.22 v1(179.32,228.22)
H_PM_SYNC_R: length 9.4
  TOP w0.089: U6E1.AF3 101.45,157.49 101.69,157.73 101.69,158.03 101.76,158.11 101.76,160.7 101.65,160.82 101.65,164.34 101.37,164.62 101.37,164.82
  TOP w0.1: 100.83,166.24 101.37,165.71 101.37,164.82
H_PRDY_N: length 105.5
  TOP w0.089: J3D1.L34 v1(235.41,189.41)
  TOP w0.1: v1(270.51,191.64) 270.79,191.92 270.79,195.74 269.36,197.16 269.36,206.12 265.53,209.95 264.01,209.95 263.83,209.78 262.28,209.78 262.1,209.95 261.59,209.95 R2C26.2 260.97,210.44 259.57,209.04 259.57,208.21 259.95,207.84 259.95,199.75 259.02,198.83 258.26,198.83 v1(257.81,198.37) ; v1(298.57,197.48) 298.06,197.48 R1C97.1
  BOTTOM w0.089: v1(235.41,189.41) 235.41,189.61 235.88,190.09 235.88,191.5 236.07,191.69 236.65,191.69 236.75,191.79 237.43,191.79 238.2,192.56 240.12,192.56 240.47,192.91 240.47,193.73 243.51,196.77 243.51,199.82 246.38,202.69 250.77,202.69 254.66,198.8
  BOTTOM w0.1: 254.66,198.8 257.37,198.8 v1(257.81,198.37) ; v1(298.57,197.48) 295.24,194.15 282.03,194.15 280.86,195.32 274.34,195.32 270.66,191.64 v1(270.51,191.64)
H_PREQ_N: length 103.9
  TOP w0.089: J3D1.K35 236.78,189.86 v1(236.32,190.32)
  TOP w0.1: v1(271.01,191.13) 271.01,195.83 269.59,197.26 269.59,206.21 265.37,210.44 R2C27.2 263.77,211.07 260.98,211.07 260.6,210.69 260.6,210.38 259.35,209.13 259.35,208.11 259.72,207.74 259.72,199.9 258.87,199.06 257.78,199.06 v1(257.04,198.32) ; v1(298.57,195.96) R1C101.1
  BOTTOM w0.089: 254.76,198.37 250.65,202.47 246.47,202.47 243.73,199.73 243.73,196.72 240.66,193.65 240.66,192.83 240.2,192.37 238.28,192.37 237.51,191.6 237.04,191.6 236.8,191.35 236.8,191.11 236.32,190.63 v1(236.32,190.32)
  BOTTOM w0.1: v1(271.01,191.13) 271.01,191.64 274.44,195.07 280.79,195.07 281.94,193.93 296.54,193.93 v1(298.57,195.96) ; 254.76,198.37 256.99,198.37 v1(257.04,198.32)
H_PROCHOT_BUFF_N: length 5.1
  TOP w0.1: R8E56.1 34.67,134.11 C8E18.1 34.95,132.62 U8F3.4 34.95,130.78 35.05,130.68 R8F71.2
H_PROCHOT_EC_N: length 240.6
  TOP w0.1: R8F71.1 35.68,130.05 34.54,130.05 34.3,129.81 34.3,128.44 34.79,127.95 R8F70.2 34.79,125.82 43.02,117.6 v1(43.43,117.6) ; J6J2.201 v1(142.82,20.78) ; U8F6.4 30.42,107 30.56,107.14 30.56,107.78 30.89,108.11 R8F31.1 32.29,109.5 v1(32.29,110.62)
  LAY3 w0.1: v1(32.29,110.62) 30.09,108.42 30.09,96.52 29.33,95.76 29.33,94.61 28.95,94.23 28.95,91.31 30.09,90.17 30.09,89.41 28.03,87.34 28.03,85.85 29.33,84.55 29.33,81.06 29.55,80.84 29.55,76.36 31.11,74.8 31.11,74.04 28.7,71.63 28.7,70.1 28.05,69.46 28.05,63.39 23.86,59.2 23.86,52.44 26.4,49.9 26.4,48.15 32.13,42.42 32.89,42.42 36.24,39.07 36.24,37.99 37.78,36.45 46.52,36.45 46.79,36.71 50.91,36.71 52.19,35.43 60.45,35.43 60.96,34.92 60.96,34.48 65.17,30.27 67.1,30.27 67.88,29.48 73.99,29.48 74.29,29.78 75.54,29.78 75.72,29.96 77.37,29.96 78.26,29.08 80.35,29.08 81.06,29.78 95.99,29.78 96.27,30.06 98.19,30.06 98.72,29.53 100.62,29.53 102.36,27.79 109.39,27.79 111.23,25.95 114.52,25.95 114.56,25.91 121.54,25.91 122.97,24.48 124.07,24.48 124.8,25.22 129.97,25.22 130.83,24.36 130.83,23.91 131.09,23.64 132.06,23.64 132.85,22.86 134.99,22.86 136.25,21.6 142,21.6 v1(142.82,20.78)
  BOTTOM w0.1: v1(43.43,117.6) 42.29,117.6 38.22,113.54 33.4,113.54 32.29,112.43 v1(32.29,110.62)
H_PROCHOT_N: length 714.1
  TOP w0.1: v1(166.49,234.19) 166.49,233.3 167.38,232.41 R5B45.1 R4B35.2 170.78,232.89 172.36,232.89 173.48,231.77 173.48,230.82 174.68,229.61 174.68,229.04 175,228.73 179.7,228.73 179.83,228.6 179.83,228.34 180.08,228.09 R4B40.2 180.08,227.07 R4C4.2 ; R8E56.2 34.54,131.16 33.9,130.52 33.74,130.52 32.54,129.32 32.54,125.89 v1(32.13,125.47) ; R5B82.2 v1(159.38,234.57)
  LAY5 w0.125: v1(243.45,79.88) 245.49,81.91 252.73,81.91 256.62,78.02 257.59,78.02 258.28,77.32 267.79,77.32 268.47,78.01 268.47,79.5 274.74,85.77 274.74,88.07 284.38,97.71 284.38,134.48 281.54,137.32 281.54,138.69 278.53,141.71 278.53,146.29 277.5,147.33 277.5,156.21 279.06,157.78 279.06,159.68 279.65,160.27 281.3,160.27 282.44,161.42 285.36,161.42 285.75,161.8 285.75,165.3 286.83,166.38 287.12,166.38 288.33,167.6 288.33,168.67 289.62,169.95 289.62,174.56 v1(289.56,174.62) 289.62,174.68 289.62,179.7 290.48,180.57 290.48,195.82 287.8,198.51 287.8,211.45 286.55,212.7 286.55,219.7 289.95,223.1 289.95,226.93 290.67,227.65 290.67,229.59 291.84,230.76 291.84,239.52 290.73,240.63 290.73,244.69 290.06,245.36 290.06,246 289.43,246.63 289.43,255.89 290.66,257.12 290.66,264.19 289.29,265.56 283.46,265.56 281.64,263.73 276.83,263.73 276.07,262.97 271.43,262.97 270.16,261.7 263.7,261.7 260.66,258.66 259.11,258.66 258.22,259.55 256.17,259.55 254.9,258.28 253.25,258.28 252.64,257.66 247.57,257.66 244.88,254.97 229.49,254.97 229.17,254.66 223.06,254.66 222.57,255.15 213.61,255.15 212.84,254.38 210.74,254.38 210.4,254.72 200.87,254.72 200.4,254.25 200.4,253.14 199.99,252.73 196.26,252.73 v1(195.75,253.24) ; v1(37.33,250.06) 37.45,249.95 52.75,249.95 53.11,250.3 68.58,250.3 71.84,247.04 72.76,247.04 73.72,248.01 75.16,248.01 75.62,247.56 76.03,247.56 79.99,243.59 82.2,243.59 82.87,244.26 84.64,244.26 85.38,243.52 88.55,243.52 88.77,243.3 105.51,243.3 106.25,244.04 107.35,244.04 108.55,242.84 108.55,241.91 109.59,240.88 116.04,240.88 117.63,242.46 126.5,242.46 127.71,243.66 131.26,243.66 133.17,245.57 134.59,245.57 139.04,250.01 147.95,250.01 149.01,248.96 149.01,248 149.96,247.05 155.4,247.05 158.86,250.52 172.01,250.52 v1(173.6,248.92) ; v1(159.38,234.57) 159.76,234.19 v1(166.49,234.19)
  LAY6 w0.125: v1(37.33,250.06) 36.19,248.92 36.19,247.91 34.29,246.01 34.29,245.49 33.4,244.6 32.9,244.6 31.54,243.24 31.54,241.47 29.97,239.89 29.97,236.6 30.82,235.75 30.82,231.08 29.16,229.42 29.16,228.66 30.18,227.65 30.18,223.64 31.07,222.75 31.07,217.35 31.49,216.92 31.49,212.35 31.88,211.96 31.88,210.6 32.6,209.89 33.88,209.89 35.14,208.63 35.14,207.53 36.83,205.84 36.83,199.42 37.49,198.76 37.49,198.01 35.3,195.82 35.3,191.51 35.81,191.01 35.81,185.91 33.52,183.63 33.52,182.37 30.73,179.58 30.73,177.42 31.11,177.04 31.11,166.48 30.73,166.1 30.73,159 29.97,158.24 29.97,152.65 30.22,152.4 30.73,152.4 31.11,152.02 31.11,145.41 30.22,144.52 30.22,141.44 29.67,140.89 29.67,136.84 31.63,134.88 31.63,129.69 32.46,128.85 32.46,125.81 v1(32.13,125.47) ; v1(166.49,234.19) 167.47,235.16 167.47,235.62 168.49,236.64 171.32,236.64 171.36,236.6 173.62,236.6 176.48,239.46 176.48,245.66 173.6,248.54 v1(173.6,248.92) 174.15,248.92 174.7,248.37 184.22,248.37 185.93,250.08 189.62,250.08 191.28,251.74 194.25,251.74 v1(195.75,253.24)
H_PROCHOT_R_N: length 55.4
  TOP w0.089: J3D1.A16 217.21,199.01 217.21,201.55
  TOP w0.1: R4B40.1 180.97,227.84 180.34,228.47 C4B35.1 180.84,228.6 181.48,227.96 181.48,227.07 181.22,226.82 181.22,225.93 184.78,222.38 186.05,222.38 190.08,218.35 193.32,218.35 197.31,214.36 207.96,214.36 217.21,205.11 217.21,201.55
H_PWRGD: length 603.7
  TOP w0.089: J3D1.D14 215.38,196.26 215.77,196.26 216.22,196.72 v1(216.69,196.72) ; 215.73,203.2 215.73,201.02 v1(215.88,200.86)
  TOP w0.1: 215.73,203.2 215.73,204 207.12,212.61 195.99,212.61 194.5,214.09 183.93,214.09 178.76,219.27 178.76,222.96 179.15,223.36 179.15,224.7 178.65,225.2 178.65,227.42 178.21,227.86 176.29,227.86 C4B36.1 175.24,227.86 174.7,227.86 173.95,228.6 v1(173.88,228.6) ; v1(136.9,212.72) 136.3,212.13 129.84,212.13 128.32,210.61 127.24,210.61 126.05,211.81 124.63,211.81 124.07,212.37 122.68,212.37 122.39,212.08 102.54,212.08 96.53,206.06 96.53,191.58 95.86,190.91 95.86,188.25 96.81,187.3 96.81,181.18 97.93,180.05 97.93,174.47 101.37,171.03 101.37,168.02 101.72,167.67 R6D67.2
  LAY3 w0.1: v1(252.22,67.69) 250.69,69.21 235.07,69.21 232.82,71.47 218.88,71.47 218.16,72.19 199.24,72.19 198.52,71.47 178.71,71.47 174.37,75.82 170.18,75.82 168.65,77.34 168.65,78.11 167.21,79.56 167.21,79.71 166.42,80.5 161.2,80.5 160.48,81.21 159.83,81.21 158.37,79.75 134.93,79.75 124.23,90.45 124.23,115.31 133.98,125.06 133.98,131.26 148.97,146.24 148.97,155.83 151.51,158.37 151.51,159.76 155.57,163.83 155.57,168.27 161.29,173.99 161.29,176.53 167.51,182.75 167.51,196.59 167.89,196.98 167.89,201.17 171.7,204.98 173.73,204.98 174.5,205.75 178.42,205.75 182.62,201.55 196.61,201.55 196.99,201.93 212.97,201.93 216.69,198.21 v1(216.69,196.72)
  BOTTOM w0.089: v1(215.88,200.86) 216.28,200.44
  BOTTOM w0.1: v1(252.22,67.69) 251.96,67.44 251.96,63.24 252.6,62.61 252.6,47.37 250.82,45.59 250.82,41.78 251.96,40.64 270.12,40.64 272.04,42.55 279.64,42.55 v1(281.81,40.38) ; 216.28,200.44 216.28,199.05 216.69,198.63 v1(216.69,196.72) ; v1(173.88,228.6) 173.99,228.7 173.99,229.61 173.33,230.27 167.57,230.27 163.81,234.03 154.19,234.03 153.14,232.98 153.14,232.55 152.12,231.53 150.56,231.53 149.51,232.58 148.47,232.58 145.34,235.72 145.34,236.17 144.01,237.49 141.09,237.49 140.33,236.73 140.33,235.9 137.9,233.46 137.9,217.13 138.15,216.88 138.15,213.97 v1(136.9,212.72)
H_PWRGD_R: length 9.1
  TOP w0.089: U6E1.AE3 101.95,157.57 101.88,157.64 101.88,157.94 101.95,158.01 101.95,160.78 101.84,160.89 101.84,160.89 101.84,164.6 101.72,164.72
  TOP w0.1: 101.72,164.72 R6D67.1
H_PWRGD_R21BV: length 13.2
  TOP w0.1: v1(34.01,204.88) 34.06,204.93 Q8C7.3 ; R8C47.1 v1(44.57,204.16)
  LAY5 w0.125: v1(44.57,204.16) 43.73,203.33 35.57,203.33 v1(34.01,204.88)
H_SKTOCC_N: length 551.8
  TOP w0.089: J3D1.AC37 v3(239.07,178.38)
  TOP w0.1: R4J5.2 173.99,10.03 Q4J1.2 175.38,11.94 175.38,17.4 172.08,20.7 J4J2.1 ; v1(93.72,167.64) R7D46.1
  LAY2 w0.1: v1(282.26,138.07) 282.03,138.29 281.82,138.29 275.99,144.12 275.99,148.1 263.67,160.42 263.67,167.94 253.41,178.2 242.2,178.2 241.93,177.93 239.53,177.93 v3(239.07,178.38)
  LAY5 w0.125: v1(85.72,43.43) 86.23,43.43 86.23,43.44 86.87,44.09 89.42,44.09 93.21,47.87 95.14,47.87 95.81,48.54 103.76,48.54 104.79,47.52 112.03,47.52 112.77,48.26 112.77,48.56 114.07,49.87 120.37,49.87 121.78,48.45 121.78,47.88 122.67,46.99 123.55,46.99 124.28,46.26 127.68,46.26 128.5,47.08 133.4,47.08 134.77,45.71 140.43,45.71 141.92,47.2 145.6,47.2 148.95,50.55 163.55,50.55 168.88,55.88 v1(170.12,55.88) 170.12,56.08 170.56,56.51 171.45,56.51 174.56,59.62 174.56,63.91 179.86,69.21 198.28,69.21 199.14,70.08 209.16,70.08 209.77,69.47 217.7,69.47 218.31,70.08 230.5,70.08 233.83,66.75 238.45,66.75 241.95,63.25 243.71,63.25 245.68,61.27 246.69,61.27 253.23,67.82 263.13,67.82 265.1,69.79 276.05,69.79 278.08,71.82 280.41,71.82 280.79,72.2 280.79,76.2 282.32,77.72 284.84,77.72 287.45,80.33 289,81.88 289,99.84 289.43,100.27 289.43,117.74 288.99,118.18 288.99,119.18 289.46,119.65 289.46,132.05 v1(288.41,133.09) ; v1(84.45,99.82) 83.94,100.33 83.94,115.19 83.56,115.57 83.56,116.71 89.02,122.17 89.02,127.74 89.66,128.37 89.66,134.6 90.3,135.24 90.3,137.58 91.31,138.58 91.31,157.22 92.83,158.75 92.83,166.75 v1(93.72,167.64)
  LAY6 w0.125: v1(84.45,99.82) 88.29,95.99 88.29,90.7 87.67,90.08 87.67,80.93 88.58,80.01 88.58,76.39 89.67,75.3 89.67,64.98 88.21,63.52 88.21,63.04 89.28,61.97 89.28,55.33 88.13,54.18 88.13,51.94 86.1,49.91 86.1,46.55 86.78,45.88 86.78,44.49 v1(85.72,43.43)
  BOTTOM w0.1: v1(288.41,133.09) 288.05,133.09 283.08,138.07 v1(282.26,138.07) ; J4J2.1 170.53,21.87 170.53,26.45 170.99,26.91 170.99,53.16 170.12,54.02 v1(170.12,55.88)
H_SKTOCC_N_R: length 11.9
  TOP w0.089: U6E1.AP3 97.56,157.52 97.48,157.6 97.48,157.94 97.49,157.94 97.49,157.96 97.57,158.04 97.57,159.05 97.52,159.1 97.52,159.1 97.52,160.85 97.52,161.12 94.35,164.29
  TOP w0.1: R7D46.2 92.96,166.24 92.83,166.11 92.83,165.35 v1(93.34,164.84) 93.8,164.84 94.35,164.29
H_TCK: length 79.8
  TOP w0.089: 245.99,189.22 243.96,189.22 242.78,188.03 J3D1.M40
  TOP w0.1: v1(293.75,216.79) 295.02,216.79 295.4,217.17 296.54,217.17 R1C32.1 ; 245.99,189.22 248.86,189.22 256.51,196.87 258.82,196.87 260.4,198.45 260.4,208.02 260.03,208.4 260.03,208.85 260.68,209.5 261.54,209.5 R2C28.1 262.53,208.51 264.69,208.51 268.35,204.85 v1(268.35,204.09)
  BOTTOM w0.1: v1(268.35,204.09) 268.35,204.33 268.45,204.43 269.27,204.43 273.43,208.59 278.59,208.59 280.44,210.44 281.43,210.44 282.32,211.33 282.57,211.33 282.91,210.99 284.39,210.99 285.36,211.96 289.05,211.96 293.75,216.66 v1(293.75,216.79)
H_TDI: length 77.7
  TOP w0.089: 245.99,188.91 244.07,188.91 242.84,187.67 241.33,187.67 240.77,187.12 J3D1.N39
  TOP w0.1: v1(290.34,219.63) 290.34,219.35 290.06,219.07 R1C23.1 ; v1(266.95,204.01) 266.95,205.23 R2C31.2 263.9,208.28 260.85,208.28 260.63,208.05 260.63,198.36 258.91,196.65 256.61,196.65 248.86,188.91 245.99,188.91
  BOTTOM w0.1: v1(266.95,204.01) 266.95,204.34 267.96,205.36 268.89,205.36 273.05,209.52 278.21,209.52 280.3,211.61 280.94,211.61 282.56,213.23 288.65,213.23 290.95,215.53 290.95,217.68 290.34,218.29 v1(290.34,219.63)
H_TDO: length 78.6
  TOP w0.089: J3D1.N40 241.35,187.12 241.66,187.43 242.97,187.43 244.2,188.66 245.99,188.66
  TOP w0.1: 245.99,188.66 248.94,188.66 256.7,196.42 259.01,196.42 260.85,198.26 260.85,207.52 R2C30.2 261.62,207.26 263.01,207.26 267.36,202.92 v1(267.43,202.92) ; R1C25.1 294.69,218.82 v1(295.07,219.2)
  BOTTOM w0.1: v1(295.07,219.2) 294.48,218.62 294.48,218.29 292.92,216.72 292.92,216.16 288.95,212.19 285.27,212.19 284.3,211.22 283,211.22 282.66,211.55 282.22,211.55 281.33,210.66 280.34,210.66 278.5,208.82 273.34,208.82 269.18,204.66 268.25,204.66 267.86,204.26 267.86,203.35 v1(267.43,202.92)
H_THERMTRIP_N: length 38.9
  TOP w0.1: R4D8.1 174.87,164.72 175.69,163.9 182.81,163.9 185.74,166.83 185.74,167.87 194.23,176.36 201.45,176.36 202.07,175.74 203.04,175.74 203.21,175.58 204.75,175.58 J3D1.AF3
H_TMS: length 74.6
  TOP w0.089: J3D1.L39 240.8,188.59 242.52,188.59 243.89,189.95 245.99,189.95
  TOP w0.1: v1(290.42,215.77) 290.42,215.79 289.61,216.61 289.61,218.39 R1C22.1 ; v1(268.83,205.97) 268.75,205.97 265.68,209.04 R2C29.2 263.9,209.55 262,209.55 261.82,209.72 260.58,209.72 259.8,208.94 259.8,208.3 260.17,207.93 260.17,199.6 259.08,198.5 259.08,198.12 258.53,197.57 256.22,197.57 248.6,189.95 245.99,189.95
  BOTTOM w0.1: v1(290.42,215.77) 290.44,215.75 290.44,215.34 288.56,213.46 282.46,213.46 280.85,211.84 280.21,211.84 278.12,209.75 272.61,209.75 v1(268.83,205.97)
H_TRST_N: length 70.7
  TOP w0.089: 245.99,189.6 243.89,189.6 242.68,188.39 241.16,188.39 240.88,188.11 240.88,187.91 240.68,187.71 240.06,187.71 239.53,187.17 J3D1.N38
  TOP w0.1: 245.99,189.6 248.75,189.6 256.37,197.22 258.68,197.22 259.61,198.16 v1(259.61,198.37) ; v1(292.35,219.71) 291.84,219.2 R1C24.1
  BOTTOM w0.1: v1(259.61,198.37) 259.61,199.29 263.26,202.94 266.79,202.94 267.51,203.66 267.51,204.41 268.11,205.01 269.03,205.01 273.19,209.17 278.35,209.17 280.32,211.14 281.14,211.14 282.21,212.22 284.09,212.22 284.54,212.66 288.76,212.66 291.33,215.24 291.33,218.69 v1(292.35,219.71)
HD_LED_N: length 7.9
  TOP w0.38: R9G35.1 R9G34.2 17.39,67.72 17.36,67.69 15.24,67.69 CR9G4.2 15.24,66.8 15.87,66.17 R9G41.2
HDA_BCLK_I2S0_SCLK: length 17.3
  TOP w0.089: 87.66,154.24 87.92,153.99 89.21,153.99 89.68,153.52 92.13,153.52 92.19,153.58 92.31,153.7 92.7,153.7 U6E1.BD11
  TOP w0.1: R7E8.1 R7E9.1 79.17,157.68 79.78,157.68 81.28,156.18 85.72,156.18 87.66,154.24
HDA_BCLK_I2S0_SCLK_HDR: length 155.7
  TOP w0.1: v1(67.56,167.51) 67.56,167.49 68.68,166.37 69.21,166.37 69.72,165.86 69.72,165.01 72.48,162.24 75.24,162.24 77.34,160.15 77.34,159.76 77.49,159.61 78.13,159.61 R7E9.2
  BOTTOM w0.1: v1(67.56,167.51) 67.56,170.77 61.17,177.16 61.17,180.23 59.03,182.37 59.03,185.63 54.83,189.83 53.24,189.83 51.18,191.9 51.18,192.53 49.37,194.34 46.6,194.34 44.89,196.05 44.89,196.84 43.59,198.14 43.59,200.75 42.16,202.18 42.06,202.18 39.62,204.62 39.62,208.74 32.42,215.94 29.8,215.94 26.88,218.86 26.88,220.37 26.31,220.93 26.31,227.34 24.14,229.52 24.14,241.27 24.95,242.09 24.95,252.45 22.64,254.76 18.83,254.76 16.73,256.86 14.64,256.86 9.74,261.76 9.74,263.85 8.38,265.21 8.38,266.19 7.62,266.95 4.44,266.95 3.81,267.59 3.81,269.75 J9A4.1
HDA_CODEC_BCLK: length 191.4
  TOP w0.1: v1(70.3,165.35) 70.3,165.09 72.68,162.72 75.44,162.72 76.36,161.8 78.1,161.8 78.35,161.54 78.35,161.01 79.62,159.74 R7E10.2 ; v1(127.63,271.14) 128.77,270 C6A32.2 128.52,269.49 R6A64.1
  LAY5 w0.125: v1(77.08,201.67) 76.58,201.17 76.58,197.61 75.94,196.98 75.25,196.98 74.64,196.37 74.64,195.75 74.05,195.15 74.05,194.69 73.79,194.44 72.93,194.44 72.68,194.18 72.68,188.94 73.13,188.48 73.13,172.62 71.79,171.28 71.79,169.46 70.3,167.97 v1(70.3,165.35)
  LAY6 w0.125: v1(77.08,201.67) 76.2,202.56 75.56,202.56 74.7,203.42 74.7,221.38 73.28,222.8 73.28,236.68 74.43,237.82 74.43,241.98 73.28,243.12 73.28,249.56 74.04,250.32 74.04,253.87 73.02,254.89 71.23,254.89 68.82,257.3 68.82,261.48 69.22,261.88 69.22,262.27 75.5,268.55 81.6,268.55 83.43,270.38 83.43,271.78 85.56,273.9 95.39,273.9 95.8,274.32 105.79,274.32 106.42,274.95 108.2,274.95 112.9,270.26 123.82,270.26 124.14,270.57 127.06,270.57 v1(127.63,271.14)
HDA_CODEC_BCLK_R: length 6.1
  TOP w0.1: R6A64.2 127.12,270.76 127.12,271.4 126.87,271.65 126.87,274.19 125.75,275.31 EU6A1.11
HDA_CODEC_RESETO: length 118.1
  TOP w0.1: R6A63.2 125.85,270.89 v1(125.85,271.14) 125.85,273.05 R6A46.1 126.11,273.81 126.11,274.6 125.35,275.36 EU6A1.10 ; R8B7.1 v1(28.95,255.01)
  LAY5 w0.125: v1(46.99,269.44) 48.82,269.44 49.37,268.89 67.04,268.89 67.79,268.14 80.77,268.14 81.92,266.99 88.67,266.99 88.77,267.09 93.8,267.09 94.2,267.49 97.56,267.49 98.04,267 99.87,267 100.35,267.49 109.14,267.49 111.82,270.16 114.68,270.16 115.46,269.38 121.8,269.38 122.8,270.38 125.47,270.38 125.85,270.76 v1(125.85,271.14)
  LAY6 w0.125: v1(28.95,255.01) 29.4,255.46 29.4,260.52 30.38,261.5 36.48,261.5 38.35,263.37 38.35,264.01 39.13,264.79 43.48,264.79 44.64,265.96 45,265.96 46.99,267.94 v1(46.99,269.44)
HDA_CODEC_RESETO_R: length 2
  TOP w0.1: R8B7.2 30.6,255.65 30.73,255.78 30.73,256.16 30.6,256.28 Q8B1.2
HDA_CODEC_SDI: length 3.8
  TOP w0.1: R6A50.2 128.01,274.06 127.7,274.06 126.82,274.94 EU6A1.13
HDA_CODEC_SDI_R: length 182.1
  TOP w0.1: R7E2.2 73.06,161.54 71.94,161.54 69.66,163.83 v1(69.34,163.83) ; R6A50.1 v1(128.52,271.91)
  LAY5 w0.125: v1(77.08,203.96) 76.96,203.83 75.31,203.83 74.55,203.08 74.55,197.69 71.67,194.82 71.67,192.15 70.23,190.7 70.23,180.97 69.97,180.72 69.97,177.83 68.83,176.69 68.83,168.4 69.29,167.94 69.29,163.88 v1(69.34,163.83)
  LAY6 w0.125: v1(77.08,203.96) 77.09,203.96 77.09,217.8 76.32,218.57 76.32,246.25 74.79,247.79 74.79,254.18 73.33,255.64 71.55,255.64 69.57,257.61 69.57,261.13 69.97,261.53 69.97,261.96 75.81,267.79 81.91,267.79 84.19,270.07 84.19,271.24 85.36,272.41 93.67,272.41 94.43,271.65 109.72,271.65 111.87,269.5 113.03,269.5 113.8,268.73 116.33,268.73 117.1,269.5 124.13,269.5 124.45,269.82 128.21,269.82 129.03,270.64 129.03,271.4 v1(128.52,271.91)
HDA_CODEC_SDO: length 192.5
  TOP w0.1: R7E7.2 76.07,159.15 75.45,159.76 73.91,159.76 72.41,161.26 71.9,161.26 70.1,163.07 v1(69.34,163.07) ; v1(127.76,274.7) 127.38,275.08 127.38,276.6 127.14,276.84 EU6A1.14
  LAY5 w0.125: v1(69.34,163.07) 69.82,163.55 69.82,164.11 69.54,164.39 69.54,168.05 69.08,168.5 69.08,176.59 70.22,177.72 70.22,180.57 70.99,181.33 70.99,191.11 71.92,192.04 71.92,194.71 74.8,197.59 74.8,202.18 75.18,202.56 76.45,202.56 v1(77.08,203.2)
  LAY6 w0.125: v1(127.76,274.7) 127.76,274.32 129.92,272.16 129.92,271.17 128.32,269.57 124.66,269.57 123.57,268.48 122.04,268.48 121.27,269.25 117.2,269.25 116.43,268.48 112.54,268.48 109.62,271.4 94.33,271.4 93.57,272.16 85.47,272.16 84.44,271.13 84.44,269.97 82.02,267.54 75.92,267.54 70.23,261.85 70.23,261.43 69.83,261.03 69.83,257.83 70.86,256.79 73.15,256.79 75.04,254.9 75.04,247.89 76.57,246.36 76.57,218.67 77.34,217.91 77.34,204.47 77.61,204.2 77.61,203.72 v1(77.08,203.2)
HDA_CODEC_SYNC: length 190.4
  TOP w0.1: R7E5.2 72,159.76 70.99,159.76 v1(70.23,160.53) ; EU6A1.12 126.31,275.76 126.49,275.59 126.49,274.95 127.5,273.94 R6A47.1 127.88,273.56 128.01,273.43 128.01,271.65 v1(128.52,271.14) R6A55.2
  LAY5 w0.125: v1(70.23,160.53) 69.72,161.03 69.72,162.43 70.07,162.79 70.07,164.21 69.79,164.5 69.79,176.94 70.47,177.62 70.47,180.42 71.75,181.69 71.75,191.51 72.18,191.94 72.18,194.61 75.05,197.48 75.05,201.17 75.43,201.55 76.2,201.55 v1(77.08,202.44)
  LAY6 w0.125: v1(77.08,202.44) 76.45,203.07 76.45,203.2 75.94,203.71 75.56,203.71 75.2,204.06 75.2,221.59 73.78,223.01 73.78,236.47 74.93,237.62 74.93,242.19 73.78,243.33 73.78,249.35 74.54,250.11 74.54,254.08 73.23,255.39 71.44,255.39 69.32,257.51 69.32,261.24 69.72,261.64 69.72,262.06 75.71,268.05 81.81,268.05 83.93,270.17 83.93,271.34 86,273.4 95.59,273.4 96.01,273.82 105.99,273.82 106.63,274.45 107.99,274.45 112.69,269.76 113.13,269.76 113.91,268.98 116.2,268.98 116.97,269.75 124.03,269.75 124.34,270.07 127.45,270.07 v1(128.52,271.14)
HDA_PCH_PWREN: length 7.4
  TOP w0.1: R9B6.2 R9B5.2 R9B4.2 6.22,256.92 J9A4.13
HDA_RST_N_I2S_MCLK_HDR: length 16
  TOP w0.1: R9A8.2 v1(16.86,272.79)
  BOTTOM w0.1: v1(16.86,272.79) 16.36,273.3 11.43,273.3 9.9,271.78 6.85,271.78 6.35,271.27 6.35,269.75 J9A4.3
HDA_RST_N_SNDW1_CLK: length 1.9
  TOP w0.1: v1(17.65,268.73) R9A12.1 R9A11.2
HDA_RST_N_SW1_CK_I2S_MCLK_HDR: length 9.9
  TOP w0.1: R9A13.2 10.66,268.6 12.7,268.6 14.22,270.13 15.36,270.13 15.72,270.49 R9A7.1 R9A8.1 16.89,271.13 16.89,269.62
HDA_RSTB_I2S1_SCLK: length 24
  TOP w0.089: 81.91,157.35 R7E11.1
  TOP w0.1: 81.91,157.35 81.28,157.35 80.61,158.02 80.61,159.92 79.3,161.23 79.3,162.24 77.44,164.11 75.59,164.11 R7D50.1 ; R7E11.1 82.67,157.86 84.62,157.86 88.09,154.38 89.38,154.38 89.81,153.95 91.8,153.95 91.9,154.05 92.5,154.05 U6E1.BE10
HDA_RSTB_I2S1_SCLK_R: length 141.3
  TOP w0.1: v1(68.8,167.64) 69.88,167.64 72.04,165.48 73.17,165.48 73.5,165.15 73.5,164.49 R7D50.2 ; R9A11.1 R9A10.1 14.98,269.11 v1(14.98,267.97)
  BOTTOM w0.1: v1(68.8,167.64) 68.8,170.87 63.98,175.69 63.98,179.4 62.86,180.53 62.21,180.53 61.08,181.66 61.08,184.92 50.71,195.29 47.63,195.29 46.3,196.62 46.3,196.77 44.83,198.25 44.83,199 45.01,199.19 45.01,201.58 41.4,205.19 41.4,208.31 32.82,216.89 30.19,216.89 27.83,219.25 27.83,220.76 27.26,221.33 27.26,227.74 25.09,229.91 25.09,240.88 25.9,241.7 25.9,252.84 23.47,255.28 23.47,262.62 23.2,262.89 17.27,262.89 15.36,264.79 15.36,267.59 v1(14.98,267.97)
HDA_SDI0_I2S0_RXD_HDR: length 6.5
  TOP w0.1: J9A4.9 7.74,257.68 R9B3.2
HDA_SDI0_I2S0_RXD_HDR_R: length 135.9
  TOP w0.1: R9B3.1 v1(11.81,257.68) ; v1(67.05,164.77) 67.13,164.77 67.59,164.31 69.75,164.31 72.29,161.77 74.61,161.77 R7E1.2
  BOTTOM w0.1: v1(67.05,164.77) 67.05,165.73 66.43,166.35 66.43,170.59 63.37,173.65 61.64,173.65 59.79,175.51 59.79,176.82 60.24,177.27 60.24,179.84 58.1,181.98 58.1,185.25 54.44,188.9 51.62,188.9 47.18,193.35 46.28,193.35 44.35,195.28 43.62,195.28 42.66,196.24 42.66,198.75 39.52,201.89 39.52,203.41 38.06,204.87 38.06,208.99 32.04,215.01 28.57,215.01 25.95,217.63 25.95,219.98 25.39,220.55 25.39,224.76 24.67,225.47 24.67,227.55 23.21,229 23.21,241.7 20.7,244.22 20.7,248.03 20.06,248.66 18.73,248.66 18.22,249.17 18.22,254.05 16.63,255.65 14.09,255.65 12.06,257.68 v1(11.81,257.68)
HDA_SDI_0_I2S0_RXD: length 20.5
  TOP w0.089: 87.62,154 87.82,153.8 89.06,153.8 89.53,153.33 92.4,153.33 U6E1.BE11
  TOP w0.1: R7E1.1 75.26,160.28 76.58,158.96 76.58,158.49 77.87,157.21 79.58,157.21 80.81,155.98 85.64,155.98 87.62,154
HDA_SDI_1_I2S1_RXD: length 10.2
  TOP w0.1: R7E12.1 83.23,156.41 85.78,156.41 88.01,154.18 89.3,154.18 89.73,153.75 91.97,153.75 U6E1.BF10
HDA_SDI_1_I2S1_RXD_HDR: length 24
  TOP w0.1: J9A4.11 3.55,259.33 3.55,271.65 3.94,272.04 R9A5.2
HDA_SDI_1_I2S1_RXD_SW1_DATA: length 165.8
  TOP w0.1: v1(68.8,166.9) 69.44,166.9 72.64,163.7 73.4,163.7 73.91,163.19 75.82,163.19 76.32,163.7 77.17,163.7 78.83,162.05 78.83,161.21 80.13,159.9 80.13,158 81.54,156.59 R7E12.2 ; v1(15.11,270.64) 14.96,270.64 R9A6.1 R9A5.1
  BOTTOM w0.1: v1(68.8,166.9) 68.83,166.9 69.31,167.38 69.31,171.04 66.15,174.2 66.15,174.38 67.24,175.47 67.24,175.61 67.09,175.75 66.95,175.75 65.84,174.65 65.7,174.65 65.56,174.79 65.56,174.93 66.67,176.04 66.67,176.18 66.53,176.32 66.39,176.32 65.3,175.23 65.12,175.23 64.46,175.89 64.46,179.6 62.1,181.96 62.1,182.62 61.56,183.16 61.56,185.11 50.91,195.77 48.32,195.77 46.16,197.93 45.83,197.93 45.3,198.46 45.3,198.81 45.48,198.99 45.48,201.78 42.86,204.41 42.86,209.23 42.16,209.93 40.45,209.93 38.73,211.65 38.73,214.12 38.22,214.63 35.75,214.63 31.68,218.69 29.21,218.69 28.31,219.59 28.31,223.13 28.95,223.77 28.95,225.3 28.18,226.07 28.18,228.86 27.94,229.11 27.45,229.11 27.2,228.85 26.87,228.85 25.57,230.15 25.57,236.75 26.12,237.3 26.12,240.63 27.14,241.65 27.14,242.19 26.38,242.95 26.38,253.14 24,255.52 24,262.76 23.4,263.36 19.08,263.36 16.25,266.19 16.25,268.22 15.11,269.37 v1(15.11,270.64)
HDA_SDO_I2S0_TXD: length 19.8
  TOP w0.089: 87.58,153.76 87.73,153.61 88.96,153.61 89.46,153.1 91.37,153.1 91.52,152.95 U6E1.BF12
  TOP w0.1: R7E4.2 R7E6.1 75.69,157.86 76.89,157.86 77.77,156.98 79.49,156.98 80.72,155.75 85.59,155.75 87.58,153.76
HDA_SDO_I2S0_TXD_HDR: length 162.7
  TOP w0.1: v1(67.05,164.08) 67.89,164.08 68.52,163.45 68.52,162.36 69.4,161.48 70.04,161.48 71.24,160.27 72.09,160.27 73.47,158.89 73.76,158.89 R7E6.2
  BOTTOM w0.1: v1(67.05,164.08) 67.31,164.08 68.04,164.82 68.04,165.44 67.72,165.76 67.34,165.76 66.66,166.45 66.66,170.68 63.47,173.87 61.74,173.87 60.01,175.6 60.01,176.72 60.47,177.18 60.47,179.93 58.32,182.08 58.32,185.34 54.54,189.13 51.72,189.13 50.96,189.88 50.96,190.02 51.17,190.23 51.17,190.37 51.03,190.52 50.89,190.52 50.68,190.31 50.54,190.31 50.4,190.45 50.4,190.59 50.54,190.74 50.54,190.88 50.4,191.02 50.26,191.02 50.11,190.87 49.97,190.87 49.83,191.01 49.83,191.16 49.91,191.24 49.91,191.38 49.77,191.52 49.63,191.52 49.55,191.44 49.41,191.44 49.27,191.58 49.27,191.72 49.69,192.15 49.69,192.29 49.55,192.43 49.41,192.43 48.98,192 48.84,192 47.27,193.57 46.38,193.57 44.44,195.51 43.71,195.51 42.89,196.34 42.89,198.85 39.75,201.99 39.75,203.5 38.28,204.96 38.28,209.09 32.13,215.24 28.66,215.24 26.18,217.72 26.18,220.08 25.61,220.64 25.61,227.05 23.44,229.23 23.44,241.57 24.25,242.38 24.25,243.04 23.23,244.06 23.23,253.18 22.35,254.06 18.54,254.06 16.44,256.16 14.35,256.16 11.83,258.67 11.69,258.67 10.59,257.57 10.45,257.57 10.31,257.71 10.31,257.85 11.41,258.95 11.41,259.1 11.27,259.24 11.12,259.24 10.02,258.14 9.88,258.14 9.74,258.28 9.74,258.42 10.84,259.52 10.84,259.66 10.7,259.8 10.56,259.8 9.46,258.7 9.32,258.7 9.17,258.84 9.17,258.99 10.28,260.09 10.28,260.23 9.04,261.47 9.04,262.99 7.74,264.29 5.96,264.29 J9A4.7
HDA_SDO_I2S0_TXD_J: length 53.7
  TOP w0.1: v1(70.23,162.18) 70.48,161.92 70.48,161.8 71.24,161.03 72.13,161.03 73.91,159.26 R7E4.1 ; v1(65.27,189.61) 71.88,189.61 72.21,189.28 76.31,189.28 78.42,191.39 J7D2.2
  BOTTOM w0.1: v1(70.23,162.18) 70.99,162.94 70.99,166.11 72.09,167.22 72.09,172.34 65.63,178.81 65.63,180.75 64.13,182.24 64.13,188.47 v1(65.27,189.61)
HDA_SYNC_I2S0_SFRM: length 22.4
  TOP w0.089: U6E1.BG13 91.01,152.76 90.86,152.91 89.38,152.91 88.88,153.41 87.64,153.41 87.42,153.63
  TOP w0.1: 87.42,153.63 85.53,155.52 80.62,155.52 79.39,156.75 77.68,156.75 76.82,157.61 73.27,157.61 R7E5.1 R7E3.1
HDA_SYNC_I2S0_SFRM_HDR: length 160.5
  TOP w0.1: R7E3.2 68.29,161.7 68.29,162.84 v1(67.56,163.57)
  BOTTOM w0.1: J9A4.5 5.96,264.54 7.81,264.54 9.26,263.09 9.26,261.56 14.44,256.38 16.53,256.38 18.63,254.29 22.45,254.29 24.48,252.25 24.48,251.99 24.38,251.89 23.68,251.89 23.58,251.79 23.58,251.59 23.68,251.49 24.38,251.49 24.48,251.39 24.48,251.19 24.38,251.09 23.68,251.09 23.58,250.99 23.58,250.79 23.68,250.69 24.38,250.69 24.48,250.59 24.48,250.39 24.38,250.29 23.68,250.29 23.58,250.19 23.58,249.99 23.68,249.89 24.38,249.89 24.48,249.79 24.48,249.59 24.38,249.49 23.68,249.49 23.58,249.39 23.58,249.19 23.68,249.09 24.38,249.09 24.48,248.99 24.48,248.79 24.38,248.69 23.68,248.69 23.58,248.59 23.58,248.39 23.68,248.29 24.38,248.29 24.48,248.19 24.48,247.99 24.38,247.89 23.68,247.89 23.58,247.79 23.58,247.59 23.68,247.49 24.38,247.49 24.48,247.39 24.48,247.19 24.38,247.09 23.68,247.09 23.58,246.99 23.58,246.79 23.68,246.69 24.38,246.69 24.48,246.59 24.48,246.39 24.38,246.29 23.68,246.29 23.58,246.19 23.58,245.99 23.68,245.89 24.38,245.89 24.48,245.79 24.48,245.59 24.38,245.49 23.68,245.49 23.58,245.39 23.58,245.19 23.68,245.09 24.38,245.09 24.48,244.99 24.48,244.79 24.38,244.69 23.68,244.69 23.58,244.59 23.58,244.39 23.68,244.29 24.38,244.29 24.48,244.19 24.48,242.29 23.66,241.47 23.66,229.32 25.84,227.15 25.84,220.74 26.4,220.17 26.4,217.82 28.76,215.46 32.23,215.46 38.51,209.18 38.51,205.06 42.41,201.15 42.41,199.64 43.11,198.94 43.11,197.94 44.42,196.64 44.42,195.85 46.47,193.8 47.37,193.8 48.05,193.12 49.28,193.12 53.04,189.36 54.63,189.36 58.55,185.44 58.55,182.17 60.69,180.03 60.69,176.79 61.08,176.4 61.08,175.26 62.24,174.1 63.56,174.1 66.89,170.78 66.89,166.54 67.44,165.99 67.81,165.99 68.27,165.53 68.27,164.28 v1(67.56,163.57)
HDACPU_SCLK: length 10.8
  TOP w0.089: U6E1.AM3 98.55,157.65 98.33,157.86 98.33,158.1 98.33,159.07 98.33,159.36 98.28,159.41 98.28,159.42 98.28,161.17 98.28,161.61 96.06,163.83 96.06,164.04
  TOP w0.1: 96.06,164.04 96.06,164.42 94.86,165.61 R7D48.1
HDACPU_SCLK_R: length 172
  TOP w0.089: J3D1.M9 v1(210.35,189.41)
  TOP w0.1: R7D48.2 94.86,168.15 93.77,169.24 v1(93.77,169.67)
  LAY8 w0.1: v1(195.32,186.82) 191.26,190.88 191.26,199.79 187.47,203.58 185.8,203.58 185.42,203.96 185.42,205.36 178.43,212.34 176.4,212.34 175.26,213.49 163.7,213.49 163.19,213.99 160.52,213.99 160.02,213.49 155.32,213.49 152.01,216.79 149.88,216.79 148.01,214.92 148.01,211.71 146.99,210.69 145.66,210.69 144.78,211.58 143.25,211.58 141.22,209.55 140.58,209.55 139.7,208.66 136.27,208.66 126.23,198.63 112.9,198.63 108.33,194.05 108.33,193.04 105.21,189.93 101.66,189.93 95.66,183.93 95.66,171.56 v1(93.77,169.67)
  BOTTOM w0.089: v1(210.35,189.41) 209.9,188.96 209.9,186.38 209.7,186.17 209.61,186.17 207.3,186.17 206.81,186.66 202.56,186.66 202.15,187.07 201.93,187.07
  BOTTOM w0.1: v1(195.32,186.82) 195.46,186.67 200.89,186.67 201.29,187.07 201.93,187.07
HDACPU_SDI: length 2.5
  TOP w0.089: v1(212.18,188.49) J3D1.M10
  BOTTOM w0.089: v1(212.18,188.49) 211.34,187.65 R3P1.1
HDACPU_SDI_R: length 186.2
  TOP w0.089: 95.45,164.52 95.69,164.27 95.69,163.88 98.09,161.48 98.09,161.09 98.09,159.33 98.14,159.28 98.14,158.02 98.14,157.53 98.08,157.46 U6E1.AN3
  TOP w0.1: v1(92.96,168.4) 93.72,168.4 94.23,167.89 94.23,165.73 95.45,164.52
  LAY8 w0.1: v1(92.96,168.4) 93.98,168.4 94.61,167.77 95.75,167.77 96.52,168.53 96.52,183.51 101.98,188.97 106.42,188.97 112.77,195.32 124.33,195.32 131.31,202.31 134.43,202.31 138.65,206.53 139.92,206.53 140.81,207.42 144.43,207.42 145.32,206.53 147.03,206.53 148.71,208.21 148.71,214.63 150.17,216.09 151.72,216.09 155.03,212.78 156.65,212.78 158.24,211.2 160.07,211.2 161.09,212.22 168.52,212.22 169.09,212.78 174.96,212.78 176.11,211.64 178.14,211.64 184.71,205.07 184.71,203.67 185.51,202.88 187.18,202.88 190.56,199.5 190.56,190.06 v1(193.8,186.82)
  BOTTOM w0.089: R3P1.2 210.96,186.07 210.68,185.79 207.01,185.79 206.53,186.28 202.21,186.28 202.05,186.43 201.67,186.43
  BOTTOM w0.1: 201.67,186.43 201.48,186.43 201.22,186.18 194.43,186.18 v1(193.8,186.82)
HDACPU_SDO: length 9.9
  TOP w0.089: 96.43,164.04 96.43,163.76 98.47,161.72 98.47,161.25 98.47,159.49 98.52,159.44 98.52,158.06 U6E1.AM2
  TOP w0.1: 96.43,164.04 96.43,164.55 95.75,165.23 R7D49.1
HDACPU_SDO_R: length 171.9
  TOP w0.089: v1(211.27,188.49) J3D1.N9
  TOP w0.1: v1(95.12,168.53) 95.75,167.89 R7D49.2
  LAY8 w0.1: v1(95.12,168.53) 96.13,169.54 96.13,183.64 101.85,189.36 105.66,189.36 112.14,195.83 124.11,195.83 131.1,202.82 134.62,202.82 138.55,206.75 139.82,206.75 140.71,207.64 144.52,207.64 145.41,206.75 146.93,206.75 148.49,208.31 148.49,214.72 150.08,216.31 151.82,216.31 155.12,213.01 159.89,213.01 160.3,212.6 168.27,212.6 168.68,213.01 175.06,213.01 176.2,211.87 178.23,211.87 184.94,205.16 184.94,203.76 185.6,203.1 187.27,203.1 190.78,199.6 190.78,190.59 v1(194.56,186.82)
  BOTTOM w0.089: 201.93,186.82 202.05,186.82 202.4,186.47 206.67,186.47 207.15,185.98 210.41,185.98 210.79,186.37 210.79,188.02 v1(211.27,188.49)
  BOTTOM w0.1: 201.93,186.82 201.51,186.82 201.08,186.38 194.99,186.38 v1(194.56,186.82)
HDD_PROT: length 122.2
  TOP w0.1: J8H2.46 64.46,62.31 65.2,63.04 65.6,63.04 v1(66.21,63.65)
  LAY5 w0.125: v1(68.45,6.73) 68.69,6.97 71.55,6.97 72,6.52 81.11,6.52 85.4,10.8 99.05,10.8 100.71,9.14 103.88,9.14 104.01,9.02 111.5,9.02 112.01,8.51 113.11,8.51 113.37,8.77 117.72,8.77 119.01,7.49 v1(119.5,7.49)
  LAY6 w0.125: v1(68.45,6.73) 67.56,7.62 67.56,9.61 66.16,11.01 66.16,21.59 66.8,22.22 66.8,24.26 67.69,25.15 67.69,29.84 66.82,30.71 66.82,31.21 66.42,31.62 65.02,31.62 64.51,32.13 64.51,39.37 65.27,40.13 65.27,41.3 67.56,43.59 67.56,51.18 66.83,51.91 66.83,57.73 66.29,58.27 66.29,63.58 v1(66.21,63.65)
  BOTTOM w0.1: v1(119.5,7.49) 119.88,7.11 R6W3.1
HDD_PROT_R: length 3.1
  TOP w0.1: v1(120.77,4.19) 121.15,4.57 J5J2.18
  BOTTOM w0.1: v1(120.77,4.19) R6W3.2
HDMI_1.2V_ENABLE: length 22
  TOP w0.1: R2A64.1 272.59,262.46 v1(272.54,262.46) ; EU2A7.37 v1(253.28,263.06)
  LAY6 w0.125: v1(253.28,263.06) 254.84,261.49 270.89,261.49 271.85,262.46 v1(272.54,262.46)
HDMI_1P2S_EN: length 10.8
  TOP w0.1: C2A28.1 R2A65.2 275.18,261.75 ; 275.18,261.75 R2A64.2 274.19,261.11 273.41,260.33 EU2B1.3 ; 275.18,261.75 CR2A4.2 274.7,263.78 276.09,265.17 R2A71.2
HDMI_1P2S_FB: length 2
  TOP w0.2: R2A59.1 R2A63.1 270.94,261.69 EU2B1.5
HDMI_1P2S_FB_TOP: length 1
  TOP w0.2: R2A59.2 R2A57.1
HDMI_1P2S_PGOOD: length 1.3
  TOP w0.1: EU2B1.8 271.01,259.26 R2B4.2
HDMI_RESETB: length 2.9
  TOP w0.1: EU2A7.35 252.57,264.13 C2A26.1 R2A61.2
HDMIC_ALS_CLK_DN: length 2.6
  TOP w0.1: L2A4.4 258.9,270.87 258.9,270.43 258.23,269.76 258.23,269.32 258.3,269.25 EU2A7.13
HDMIC_ALS_CLK_DP: length 2.7
  TOP w0.1: EU2A7.14 257.9,269.21 258.03,269.33 258.03,269.84 258.7,270.51 258.7,270.91 L2A4.1
HDMIC_ALS_CLK_R_DN: length 20.7
  TOP w0.1: L2A4.3 258.92,272.51 258.92,272.74 258.67,273 258.67,273.18 EU2A2.5 EU2A2.6 258.81,274.38 258.63,274.56 258.63,274.86 258.45,275.04 258.45,275.23 v1(258.69,275.47)
  BOTTOM w0.1: J2A1.B12 264.88,284.34 264.78,284.24 264.78,283.81 264.11,283.14 264.11,282.47 264.86,281.72 264.86,280.71 264.18,280.03 258.57,280.03 257.37,278.84 257.37,277.04 258.38,276.03 258.38,275.78 v1(258.69,275.47)
HDMIC_ALS_CLK_R_DP: length 20.7
  TOP w0.1: L2A4.2 258.72,272.52 258.72,272.66 258.47,272.92 258.47,273.16 EU2A2.4 EU2A2.7 258.31,274.39 258.43,274.51 258.43,274.78 258.25,274.96 258.25,275.24 258.03,275.47 v1(257.86,275.47)
  BOTTOM w0.1: v1(257.86,275.47) 258.18,275.78 258.18,275.95 257.17,276.96 257.17,278.92 258.48,280.23 264.1,280.23 264.66,280.79 264.66,281.64 263.91,282.38 263.91,283.22 264.58,283.89 264.58,284.24 264.48,284.34 J2A1.B10
HDMIC_ALS_DATA0_DN: length 2.4
  TOP w0.1: L2A3.4 256.89,270.9 256.89,270.28 257,270.17 257,269.41 257.1,269.3 EU2A7.16
HDMIC_ALS_DATA0_DP: length 2.4
  TOP w0.1: EU2A7.17 256.7,269.28 256.8,269.38 256.8,270.09 256.69,270.2 256.69,270.89 L2A3.1
HDMIC_ALS_DATA0_R_DN: length 14.6
  TOP w0.1: J2A1.B9 263.48,281.34 263.36,281.21 263.36,280.76 262.12,279.53 258.44,279.53 257.16,278.24 257.16,274.66 257.31,274.51 EU2A2.9 EU2A2.2 257.15,273.17 257.15,272.92 256.9,272.67 256.9,272.5 L2A3.3
HDMIC_ALS_DATA0_R_DP: length 14.6
  TOP w0.1: L2A3.2 256.69,272.52 256.69,272.74 256.94,273 256.94,273.19 EU2A2.1 EU2A2.10 256.81,274.51 256.96,274.66 256.96,278.32 258.36,279.73 262.04,279.73 263.16,280.84 263.16,281.24 263.06,281.34 J2A1.B7
HDMIC_ALS_DATA1_DN: length 2.6
  TOP w0.1: EU2A7.19 255.9,269.34 255.81,269.44 255.81,270.08 255.24,270.65 255.24,270.9 L2A2.4
HDMIC_ALS_DATA1_DP: length 2.6
  TOP w0.1: EU2A7.20 255.5,269.34 255.61,269.44 255.61,270 255.04,270.56 255.04,270.89 L2A2.1
HDMIC_ALS_DATA1_R_DN: length 17.3
  TOP w0.1: L2A2.3 255.24,272.51 255.24,272.7 254.96,272.98 254.96,273.16 EU2A1.5 EU2A1.6 255.12,274.38 254.95,274.56 254.95,274.94 254.61,275.28 254.61,275.45 v1(254.88,275.72)
  BOTTOM w0.1: v1(254.88,275.72) 254.58,276.01 254.58,276.93 254.91,277.26 254.91,278.53 259.89,283.52 260.52,283.52 260.64,283.39 261.32,283.39 261.86,283.93 261.86,284.24 261.96,284.34 J2A1.B6
HDMIC_ALS_DATA1_R_DP: length 17.3
  TOP w0.1: L2A2.2 255.04,272.52 255.04,272.62 254.76,272.89 254.76,273.18 EU2A1.4 EU2A1.7 254.62,274.41 254.75,274.54 254.75,274.85 254.41,275.2 254.41,275.39 v1(254.08,275.72)
  BOTTOM w0.1: J2A1.B4 261.56,284.34 261.66,284.24 261.66,284.01 261.23,283.59 260.73,283.59 260.6,283.72 259.81,283.72 254.71,278.62 254.71,277.35 254.38,277.01 254.38,276.01 v1(254.08,275.72)
HDMIC_ALS_DATA2_DN: length 3.3
  TOP w0.1: L2A1.4 253.21,270.9 253.21,270.73 253.43,270.51 254,270.51 254.6,269.9 254.6,269.44 254.7,269.34 EU2A7.22
HDMIC_ALS_DATA2_DP: length 3.3
  TOP w0.1: L2A1.1 253.01,270.89 253.01,270.65 253.35,270.31 253.91,270.31 254.4,269.82 254.4,269.44 254.3,269.34 EU2A7.23
HDMIC_ALS_DATA2_R_DN: length 14.1
  TOP w0.1: J2A1.B3 260.53,281.34 260.31,281.12 260.31,280.68 259.89,280.26 257.47,280.26 254.76,277.55 254.76,277.08 253.61,275.94 253.61,274.95 253.49,274.83 253.49,274.52 253.62,274.39 EU2A1.9 EU2A1.2 253.49,273.19 253.49,272.92 253.2,272.63 253.2,272.52 L2A1.3
HDMIC_ALS_DATA2_R_DP: length 14.1
  TOP w0.1: J2A1.B1 260.01,281.34 260.11,281.24 260.11,280.77 259.81,280.46 257.39,280.46 254.56,277.63 254.56,277.17 253.41,276.02 253.41,275.03 253.29,274.91 253.29,274.55 253.12,274.38 EU2A1.10 EU2A1.1 253.26,273.18 253.26,272.97 253,272.72 253,272.52 L2A1.2
HDMIC_ALS_HPD: length 31.5
  TOP w0.1: v1(270,270.64) 270.33,270.96 270.33,272.13 270.48,272.29 R2A21.2 R2A9.1 271.54,272.3 EU2A6.1 EU2A6.10 271.54,274.41 v1(270.38,275.57)
  TOP w0.2: EU2A7.21 v1(255.1,269.75)
  LAY6 w0.125: v1(255.1,269.75) 256.5,271.14 267.58,271.14 267.84,270.89 267.84,270.25 268.22,269.87 269.24,269.87 v1(270,270.64)
  BOTTOM w0.1: v1(270.38,275.57) 269.76,275.57 268.09,277.24 268.09,278.13 268.51,278.55 J2A1.B19
HDMIC_ALS_SCL: length 36
  TOP w0.1: v1(260.75,266.95) 260.75,266.6 260.35,266.19 259.39,266.19 259.33,266.13 EU2A7.7 ; R2A22.2 272.87,271.85 v1(272.54,271.85) 272.54,271.96 272.04,272.46 EU2A6.2 EU2A6.9 272.04,274.67 v1(271.14,275.57)
  BOTTOM w0.1: v1(271.14,275.57) 270.11,276.6 269.87,276.6 269.36,277.11 269.36,277.75 269.74,278.13 269.74,281.14 268.82,282.07 267.74,282.07 J2A1.B15 ; v1(260.75,266.95) 259.58,268.12 259.58,268.78 259.84,269.04 259.84,269.49 262.54,272.2 263.22,272.2 264.78,273.77 270.55,273.77 272.39,271.92 272.44,271.92 272.51,271.85 v1(272.54,271.85)
HDMIC_ALS_SDA: length 40.9
  TOP w0.1: v1(274.44,273.53) 274.44,272.67 R2A23.2 273.55,272.79 273.17,272.79 273.04,272.93 EU2A6.4 EU2A6.7 273.04,274.49 v1(273.3,274.75) ; EU2A7.8 259.29,266.53 259.46,266.7 260.12,266.7 260.27,266.85 260.27,267.65 259.18,268.73 v1(258.82,268.73)
  BOTTOM w0.1: v1(274.44,273.53) 272.44,273.53 271.73,274.24 264.59,274.24 263.23,272.89 262.34,272.89 258.82,269.37 v1(258.82,268.73) ; J2A1.B16 267.22,284.34 271.65,279.91 271.65,274.95 272.33,274.28 272.83,274.28 v1(273.3,274.75)
HDMIC_I2C_ADDR: length 4.5
  TOP w0.1: EU2A7.31 250.26,265.73 R2A41.2
HDMIC_ID: length 4.3
  TOP w0.1: R2A44.2 249.65,265.33 EU2A7.32
HDMIC_PD: length 4.5
  TOP w0.1: R2B2.2 261.11,262.91 R2A56.2 R2A52.2 260.84,264.93 EU2A7.4
HDMID_BP_CLK_DN: length 8.8
  TOP w0.1: J3A2.12 243.03,284.34 242.79,284.09 242.79,283.81 242.08,283.1 242.08,282.58 242.84,281.81 242.84,280.64 242.91,280.58 242.91,280.07 243.06,279.92 EU3A1.6 EU3A1.5 243.06,278.42 242.92,278.28 242.92,277.17 R3A13.2
HDMID_BP_CLK_DP: length 8.8
  TOP w0.1: J3A2.10 242.47,284.34 242.59,284.21 242.59,283.9 241.88,283.19 241.88,282.5 242.64,281.73 242.64,280.56 242.71,280.5 242.71,280.05 242.56,279.9 EU3A1.7 EU3A1.4 242.56,278.42 242.72,278.25 242.72,277.14 R3A12.2
HDMID_BP_DATA0_DN: length 4.9
  TOP w0.1: R3A11.2 241.39,277.17 241.39,278.25 241.56,278.42 EU3A1.2 EU3A1.9 241.56,279.94 241.41,280.09 241.41,280.86 241.89,281.34 J3A2.9
HDMID_BP_DATA0_DP: length 4.9
  TOP w0.1: R3A10.2 241.19,277.14 241.19,278.26 241.06,278.39 EU3A1.1 EU3A1.10 241.06,279.92 241.21,280.08 241.21,280.61 J3A2.7
HDMID_BP_DATA1_DN: length 9
  TOP w0.1: R3A9.2 239.87,277.17 239.87,277.77 239.62,278.03 239.62,278.28 239.76,278.42 CR3A2.5 CR3A2.6 239.76,279.85 239.62,279.99 239.62,280.49 239.83,280.71 239.83,281.78 239.09,282.53 239.09,283.12 239.82,283.86 239.82,284.19 239.97,284.34 J3A2.6
HDMID_BP_DATA1_DP: length 9
  TOP w0.1: J3A2.4 239.48,284.34 239.62,284.2 239.62,283.94 238.89,283.21 238.89,282.45 239.63,281.7 239.63,280.8 239.42,280.58 239.42,280.03 239.26,279.87 CR3A2.7 CR3A2.4 239.26,278.42 239.42,278.26 239.42,277.95 239.67,277.69 239.67,277.14 R3A8.2
HDMID_BP_DATA2_DN: length 5.4
  TOP w0.1: R3A7.2 238.35,277.16 238.35,277.7 238.1,277.96 238.1,278.28 238.26,278.44 CR3A2.2 CR3A2.9 238.26,279.9 238.09,280.06 238.09,280.36 238.33,280.59 238.33,281.13 238.53,281.34 J3A2.3
HDMID_BP_DATA2_DP: length 5.4
  TOP w0.1: J3A2.1 237.96,281.34 238.13,281.17 238.13,280.68 237.89,280.44 237.89,280.06 237.76,279.92 CR3A2.10 CR3A2.1 237.76,278.44 237.9,278.3 237.9,277.88 238.15,277.62 238.15,277.14 R3A6.2
HDMID_CLK_DN: length 2.3
  TOP w0.1: R3A21.2 243.4,274.88 243.4,275.26 242.92,275.75 242.92,276.17 R3A13.1
HDMID_CLK_DP: length 2.3
  TOP w0.1: R3A12.1 242.72,276.2 242.72,275.66 243.2,275.18 243.2,274.95 R3A20.2
HDMID_CLK_R_DN: length 4
  TOP w0.1: 243.21,270.39 242.89,270.7 242.89,271.29 243.36,271.75 243.36,272.2 C3A15.2 243.36,272.88 243.36,273.33 R3A21.1
HDMID_CLK_R_DP: length 4
  TOP w0.1: U3A5.H2 242.43,270.39 242.69,270.65 242.69,270.7 242.69,270.7 242.69,271.37 243.16,271.84 243.16,272.2 C3A15.1 243.16,272.88 243.16,273.34 R3A20.1
HDMID_HPD: length 16.8
  TOP w0.1: 243.21,269.59 243.42,269.59 244.63,270.79 244.63,273.91 v1(244.47,274.06) ; v1(250.06,279.02) R2A2.1 Q2A1.2
  BOTTOM w0.1: v1(244.47,274.06) 245.11,273.43 246.12,273.43 250.06,277.37 v1(250.06,279.02)
HDMID_LS_CEXT: length 4.2
  TOP w0.1: U3A5.F7 238.41,269.01 238.04,269.37 238.04,269.83 237.89,269.98 237.26,269.98 236.47,270.76 C3A16.1
HDMID_LS_REXT: length 5.7
  TOP w0.1: R3A44.2 R3A40.1 237.49,266.83 238.77,266.83 239.21,266.39
HDMID_SCL: length 16.2
  TOP w0.1: J3A2.15 244.99,280.28 245.12,280.14 CR2A1.10 CR2A1.1 245.12,278.27 244.47,277.62 R2A3.2 244.22,276.99 244.04,276.81 244.04,275.64 245.2,274.48 245.67,274.48 245.99,274.15 245.99,270.87 243.21,268.08 243.21,267.99
HDMID_SDA: length 22.6
  TOP w0.1: v1(247.52,278.08) R2A5.2 246.63,276.99 C2A10.1 246.5,277.62 246.62,277.74 CR2A1.4 CR2A1.7 246.62,280.28 247.14,280.8 247.14,281.68 246.76,282.07 245.49,282.07 244.99,282.57 J3A2.16 ; 243.21,268.79 U3A5.F1 245.11,270.69 245.11,273.84 245.21,273.94 v1(245.36,273.94)
  BOTTOM w0.1: v1(245.36,273.94) 245.23,274.06 245.23,275.08 247.52,277.37 v1(247.52,278.08)
HDMID_SINK: length 4.8
  TOP w0.1: J3A2.19 245.62,280.47 CR2A1.9 CR2A1.2 245.62,277.76 245.36,277.49 R2A4.2
HDMID_SINK_R: length 12.6
  TOP w0.1: R2A4.1 245.36,275.78 246.24,274.9 247.85,274.9 248.15,275.21 248.15,275.78 249.68,277.31 249.68,278.13 250.06,278.51 250.95,278.51 251.2,278.26 251.2,277.24 251.71,276.73 252.47,276.73 252.92,276.29 Q2A1.3
HDMID_TX0_DN: length 2.1
  TOP w0.1: R3A19.2 241.42,274.96 241.42,276.19 R3A11.1
HDMID_TX0_DP: length 2
  TOP w0.1: R3A10.1 241.22,276.17 241.22,274.88 R3A18.2
HDMID_TX0_R_DN: length 3.9
  TOP w0.1: R3A19.1 241.45,273.33 241.45,272.88 C3A14.2 241.45,272.2 241.45,271.4 241.3,271.24 241.3,270.7 U3A5.H3
HDMID_TX0_R_DP: length 3.9
  TOP w0.1: R3A18.1 241.25,273.34 241.25,272.88 C3A14.1 241.25,272.2 241.25,271.48 241.1,271.33 241.1,270.68 240.81,270.39
HDMID_TX1_DN: length 2.2
  TOP w0.1: R3A17.2 239.59,274.88 239.59,275.25 239.87,275.53 239.87,276.17 R3A9.1
HDMID_TX1_DP: length 2.2
  TOP w0.1: R3A8.1 239.67,276.2 239.67,275.62 239.39,275.34 239.39,274.95 R3A16.2
HDMID_TX1_R_DN: length 3.9
  TOP w0.1: U3A5.H5 239.72,270.68 239.72,271.46 239.55,271.62 239.55,272.2 C3A13.2 239.55,272.88 239.55,273.33 R3A17.1
HDMID_TX1_R_DP: length 3.9
  TOP w0.1: R3A16.1 239.35,273.34 239.35,272.88 C3A13.1 239.35,272.2 239.35,271.54 239.52,271.37 239.52,270.7 239.21,270.39
HDMID_TX2_DN: length 2.3
  TOP w0.1: R3A15.2 237.66,274.9 237.66,275.05 238.35,275.73 238.35,276.17 R3A7.1
HDMID_TX2_DP: length 2.3
  TOP w0.1: R3A6.1 238.15,276.2 238.15,275.82 237.46,275.14 237.46,274.93 R3A14.2
HDMID_TX2_R_DN: length 4.1
  TOP w0.1: R3A15.1 237.64,273.33 237.64,272.88 C3A12.2 237.61,272.18 237.61,271.45 238.13,270.93 238.13,270.66 U3A5.H7
HDMID_TX2_R_DP: length 4.1
  TOP w0.1: R3A14.1 237.44,273.34 237.44,272.88 C3A12.1 237.41,272.23 237.41,271.37 237.93,270.85 237.93,270.71 U3A5.H8
HOME_BTN_EC_N: length 6.3
  TOP w0.1: U8F6.126 33.78,103.89 34.92,105.03 34.92,105.15 35.3,105.54 37.84,105.54 R8F40.2
HOME_BTN_N: length 14.9
  TOP w0.1: R8F40.1 39.76,105.55 39.76,106.42 41,107.67 SW8F1.1 SW8F1.2 40.99,111.02 40.76,110.79 40.76,109.98 40.61,109.83 C8F9.1 40.13,110.62 39.62,111.12 37.71,111.12 R8F27.2
HOME_BTN_PCH_N: length 158.3
  TOP w0.089: U6E1.AF47 101.45,135.89 101.7,135.64 101.7,135.32 101.77,135.25 101.77,131.76 100.83,130.82 100.83,128.31
  TOP w0.1: 100.83,128.31 100.83,128.14 100.39,127.7 100.39,120.96 102.61,118.74 102.61,117.86 102.14,117.38 102.14,116.53 101.95,116.34 101.95,110.34 101.48,109.86 101.48,105.15 102.1,104.52 v1(102.1,103.25) ; R8F28.2 38.8,109.38 CR8F3.3 38.8,107.76 v1(38.48,107.44)
  LAY5 w0.125: v1(102.1,103.25) 101.47,102.61 101.47,98.71 99.53,96.77 98.08,96.77 93.73,92.42 93.73,89.85 89.91,86.04 89.91,85.45 89.55,85.08 87.94,85.08 86.07,83.21 83.26,83.21 82.76,82.71 81.99,82.71 80.19,80.91 78.98,80.91 78.2,80.14 75.46,80.14 73.91,78.59 73.08,78.59 71.37,76.88 58.65,76.88 58.37,77.16 56.4,77.16 55.19,75.94 54.17,75.94 53.75,75.53 53.75,74.84 53.03,74.11 51.38,74.11 50.54,73.28 45.59,73.28 43.18,70.86 v1(43.18,68.71)
  LAY6 w0.125: v1(38.48,107.44) 38.48,107.2 38.22,106.94 38.22,98.2 38.73,97.69 38.73,95.33 38.47,95.08 38.47,92.73 38.35,92.61 38.35,90.27 38.86,89.76 38.86,80.42 41.85,77.42 41.85,73.34 42.54,72.64 42.54,69.34 v1(43.18,68.71)
HP_CONN_FB_DCPL_L: length 0.9
  TOP w0.2: R5A13.2 C5A11.1
HP_CONN_FB_DCPL_R: length 1.6
  TOP w0.2: 158.36,279.78 158.11,280.03 157.22,280.03 C5A8.1
HP_CONN_FB_L: length 3.9
  TOP w0.2: R5A8.2 148.71,282.32 148.97,282.07 148.97,281.56 FB5A2.1 150.24,280.29 R5A13.1
HP_CONN_FB_R: length 2.2
  TOP w0.2: FB5A3.1 160.14,278.64 R5A14.2 R5A10.1
HP_CONN_L: length 5
  TOP w0.2: J5A1.2 151.72,284.82 150.11,283.21 C5A5.1 149.47,282.32 FB5A2.2
HP_CONN_R: length 7.5
  TOP w0.2: J5A1.3 157.69,282.74 159,281.43 C5A6.1 161.67,281.05 160.65,280.03 FB5A3.2
HP_JD_CONN: length 6.9
  TOP w0.2: C5A4.1 159.92,282.74 J5A1.5 ; C5A4.1 160.27,284.1 160.02,284.35 160.02,285.24 160.78,286 161.41,286 ; C5A4.1 R5A6.2
HV_BP_VSEL_R: length 45.5
  TOP w0.26: R5A55.2 C5A30.1 R5A56.1 148.84,261.75 147.95,262.63 147.32,262.63 v1(146.93,263.02) ; R5A52.2 v1(143,259.79)
  BOTTOM w0.26: Q6L1.1 112.14,265.43 114.3,265.43 115.31,264.41 117.34,264.41 122.04,259.71 129.03,259.71 129.4,260.09 140.83,260.09 141.09,260.35 142.44,260.35 v1(143,259.79) 146.23,263.02 v1(146.93,263.02)
HV_VSEL_D: length 6
  TOP w0.26: R6A81.1 109.98,259.84 v1(110.23,259.59)
  BOTTOM w0.26: Q6L1.3 109.91,263.84 110.49,263.27 110.49,259.84 v1(110.23,259.59)
I2C1_PD_INT_N: length 5.7
  TOP w0.1: EU5A1.29 145.85,264.73 147.06,263.52 R5A45.2 148.33,262.76 149.73,262.76 149.98,263.02 R5A46.2
I2C1_PD_SCL: length 5.6
  TOP w0.1: EU5A1.27 144.56,262.59 145.41,261.75 R5A61.2 144.95,261.03 144.95,259.54 R5B6.2
I2C1_PD_SDA: length 5.8
  TOP w0.1: EU5A1.28 144.96,263.08 146.3,261.75 R5A62.2 145.87,261.06 145.87,260.27 146.05,260.09 146.05,259.33 R5B7.2
I2C2_PD_INT_N: length 8.8
  TOP w0.1: EU5A1.34 146.84,266.73 147.06,266.95 149.47,266.95 R5A29.2 150.49,266.95 151.13,266.95 151.38,266.7 151.38,264.67 151.76,264.29
I2C2_PD_SCL: length 4.9
  TOP w0.1: R5A38.2 149.47,264.92 148.08,264.92 R5A37.2 147.06,265.93 EU5A1.32
I2C2_PD_SDA: length 4.7
  TOP w0.1: EU5A1.33 147.46,266.33 R5A32.2 148.08,265.94 149.47,265.94 R5A33.2
I2C3_PD_SCL: length 94
  TOP w0.1: R6D9.1 133.22,193.29 132.84,193.67 v1(129.41,193.67) ; EU5A1.21 142.16,263.35 141.9,263.09 141.9,262.74 142.14,262.51 142.14,262.15 141.48,261.49 R5A59.2 140.97,261.87 v1(140.97,262.25)
  LAY5 w0.125: v1(129.41,193.67) 129.92,194.18 129.92,195.3 127.5,197.72 127.5,208.34 124.3,211.54 124.3,212.37 v1(123.82,212.85)
  LAY6 w0.125: v1(140.97,262.25) 140.97,262.14 130.82,251.99 130.09,251.99 126.69,248.6 126.69,246.9 119.41,239.62 119.41,238.53 118.26,237.37 118.26,226.19 119.22,225.23 120.37,225.23 122.4,223.2 122.4,214.27 v1(123.82,212.85)
