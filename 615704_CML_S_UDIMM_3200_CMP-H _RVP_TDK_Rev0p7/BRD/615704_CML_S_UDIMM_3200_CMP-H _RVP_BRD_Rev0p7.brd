# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_ESD1_FOX: length 2.1
  TOP w0.38: R7A13.1 82.55,260.6 82.29,260.86 EU7A2.11
GND_ESD2_FOX: length 2.1
  TOP w0.38: R7A11.1 76.07,260.09 EU7A1.11
V1P05A_BOOT: length 2
  TOP w0.3: EU5G3.10 161.81,92.98 161.45,92.62
  TOP w0.5: 161.45,92.62 160.74,92.62 R5G10.1
V1P05A_BOOT_R: length 1.1
  TOP w0.5: R5G10.2 C5G9.1
V1P05A_CS: length 3.1
  TOP w0.2: v1(165.98,92.84) 165.34,93.48 EU5G3.2
  BOTTOM w0.2: R5U1.1 165.48,92.33 v1(165.98,92.84)
V1P05A_EN: length 300.7
  TOP w0.2: R5G12.2 R5G9.2 168.91,92.96 166.87,92.96 166.75,93.09 C5G8.1 166.11,93.47 v1(165.98,93.6) 165.86,93.6 165.48,93.98 EU5G3.3
  TOP w0.3: R8E68.1 46.99,130.27 v1(46.6,129.89)
  LAY5 w0.125: v1(165.98,93.6) 166.49,93.09 166.49,89.05 161.01,83.56 159.48,83.56 157,81.09 149.51,81.09 149,80.57 138.99,80.57 138.62,80.21 136.18,80.21 134.34,78.36 117.62,78.36 114.57,81.41 105.76,81.41 105.12,80.77 101.19,80.77 83.67,63.25 78.26,63.25 76.54,61.53 75.47,61.53 74.03,60.09 74.03,58.67 73.53,58.16 71.5,58.16 70.73,57.4 66.04,57.4 65.78,57.66 62.99,57.66 61.6,56.27 51.68,56.27 51.61,56.34 49.77,56.34 49.43,55.99 49.43,55.02 47.88,53.48 47.88,53.17 46.39,51.68 43.43,51.68 41.44,49.69 31.08,49.69 30.86,49.91 26.67,49.91 23.09,53.48 23.09,58.43 19.43,62.1 19.43,69.18 18.14,70.46 18.14,80.73 19.04,81.62 19.04,102.67 18.57,103.15 18.57,105.57 19.17,106.17 19.17,108.79 18.41,109.56 18.41,119.71 21.38,122.69 21.38,129.51 18.03,132.86 18.03,137.41 v1(18.54,137.92)
  BOTTOM w0.1: v1(18.54,137.92) 19.3,137.16 21.03,137.16 21.59,136.6 21.59,135.55 22.88,134.25 22.88,133.18 24.5,131.56 29.26,131.56 30.91,129.9 40.59,129.9 40.89,130.2 46.29,130.2 v1(46.6,129.89)
V1P05A_FB: length 3.6
  TOP w0.2: EU5G3.4 166.48,94.48 C5G7.1 R5G4.1 R5G2.1
V1P05A_FB_R: length 3.9
  TOP w0.2: R5G4.2 C5G7.2 168.27,94.49 168.91,95.12 R5G6.1 R5G8.1
V1P05A_LG: length 7
  TOP w0.2: EU5G3.6 161.43,94.98 v1(161.29,95.12)
  TOP w0.508: R5G7.1 v1(156.21,94.36)
  BOTTOM w0.5: v1(161.29,95.12) 156.97,95.12 v1(156.21,94.36)
V1P05A_LG_R: length 1.7
  TOP w0.508: EU5G1.4 R5G7.2
V1P05A_MECC_R: length 1.2
  TOP w0.1: R6J30.2 113.41,8 113.28,8.13 R6J24.1
V1P05A_PWRGD: length 322.8
  TOP w0.1: v1(12.44,161.8) 15.11,161.8 18.16,158.75 29.53,158.75 32.83,162.05 36.26,162.05 38.54,164.34 U8D14.1 38.98,164.59 39.62,165.23 42.16,165.23 R8D89.2 R8D84.1
  TOP w0.2: EU5G3.1 165.08,92.98 165.98,92.07 v1(165.98,91.57) R5G13.2
  LAY5 w0.125: v1(165.98,91.57) 165.98,88.9 160.9,83.82 159.38,83.82 156.9,81.34 149.41,81.34 148.89,80.82 138.88,80.82 138.52,80.46 136.08,80.46 134.23,78.61 117.72,78.61 114.67,81.67 105.67,81.67 105.01,81.02 101.09,81.02 83.57,63.5 78.15,63.5 76.43,61.78 75.37,61.78 73.78,60.19 73.78,58.78 73.42,58.42 71.39,58.42 70.63,57.65 66.14,57.65 65.89,57.91 62.86,57.91 61.47,56.52 52.07,56.52 52,56.59 49.68,56.59 49.18,56.08 49.18,55.13 47.63,53.58 47.63,53.28 46.29,51.93 43.33,51.93 41.33,49.94 31.18,49.94 30.96,50.16 26.77,50.16 23.35,53.59 23.35,58.53 19.68,62.2 19.68,69.28 18.4,70.57 18.4,80.62 19.3,81.52 19.3,102.78 18.82,103.25 18.82,105.46 19.42,106.07 19.42,110.74 19.81,111.12 19.81,111.63 18.66,112.78 18.66,119.61 21.63,122.58 21.63,129.61 18.4,132.84 18.4,135.63 19.05,136.27 19.05,143.32 13.48,148.89 13.48,153.02 12.44,154.05 v1(12.44,161.8)
V1P05A_RF: length 1.9
  TOP w0.2: EU5G3.5 165.21,94.98 165.48,95.25 R5G1.2
V1P05A_SENSE_EAC_NEG: length 3.4
  TOP w0.1: R4H13.2 187.19,55.61 187.19,55.12 187.7,54.61 188.07,54.61 U4H1.B1
V1P05A_SENSE_EAC_POS: length 2.8
  TOP w0.1: R4H14.2 187.04,56.37 187.04,56.05 187.39,55.69 187.39,55.2 187.78,54.81 188.29,54.81 U4H1.A1
V1P05A_SENSE_NEG: length 223.9
  TOP w0.1: R4H13.1 v1(186.16,58.29)
  LAY3 w0.1: R6F37.4 130.3,100.98 130.4,100.88 130.77,100.88 132.03,99.62 132.03,92.79 138.59,86.23 172.12,86.23 176.58,81.77 176.58,79.32 177.08,78.82 193.63,78.82 194.77,77.67 202.73,77.67 203.42,78.36 203.78,78.36 v1(204.08,78.66) 204.39,78.36 205.19,78.36 206.41,79.58 217.25,79.58 219.54,77.29 244.68,77.29 246.84,75.13 255.22,75.13 260.25,70.1 265.17,70.1 267.58,67.69 269.74,67.69 270.35,67.08 273.53,67.08 276.68,63.93 276.68,60.88 277.95,59.61 277.95,57.98 278.15,57.78 v1(278.51,57.78)
  BOTTOM w0.1: v1(204.08,78.66) 203.78,78.36 203.45,78.36 202.63,77.54 182.67,77.54 179.19,74.07 179.19,72.26 186.87,64.59 186.87,59.26 186.63,59.03 186.63,58.39 186.53,58.29 v1(186.16,58.29)
V1P05A_SENSE_POS: length 223.2
  TOP w0.1: R4H14.1 v1(187.3,58.29)
  LAY3 w0.1: R6F37.3 130.3,100.57 130.4,100.67 130.68,100.67 131.82,99.53 131.82,92.71 138.5,86.03 172.03,86.03 176.37,81.69 176.37,79.24 177,78.61 193.54,78.61 194.69,77.47 202.81,77.47 203.5,78.16 203.78,78.16 v1(204.08,77.85) 204.39,78.16 205.28,78.16 206.5,79.37 217.17,79.37 219.45,77.09 244.6,77.09 246.76,74.93 255.14,74.93 260.17,69.9 265.09,69.9 267.5,67.48 269.66,67.48 270.27,66.87 273.44,66.87 276.47,63.84 276.47,60.8 277.74,59.53 277.74,57.88 277.64,57.78 v1(277.24,57.78)
  BOTTOM w0.1: v1(187.3,58.29) 186.93,58.29 186.83,58.39 186.83,58.95 187.07,59.18 187.07,64.67 179.39,72.34 179.39,73.99 182.75,77.34 202.72,77.34 203.53,78.16 203.78,78.16 v1(204.08,77.85)
V1P05A_SNB: length 1.4
  BOTTOM w0.5: R5U2.2 C5U1.1
V1P05A_SW: length 22
  TOP w0.3: EU5G3.8 v1(160.52,93.98)
  TOP w0.5: v1(160.52,93.98) 159.89,93.98 159.25,93.34 C5G9.2
  BOTTOM w0.5: v1(147.19,89.41) 147.19,91.31 R5U2.1
  BOTTOM w0.508: v1(160.52,93.98) 160.27,93.98 155.7,89.41 v1(147.19,89.41)
V1P05A_UG: length 18.1
  TOP w0.3: v1(161.29,93.34) 161.42,93.48 EU5G3.9
  TOP w0.508: R5G17.1 v1(148.97,83.69)
  BOTTOM w0.508: v1(148.97,83.69) 152.4,87.12 155.06,87.12 v1(161.29,93.34)
V1P05A_UG_R: length 1.6
  TOP w0.508: EU5G2.4 147.32,83.18 147.44,83.06
V1P05A_VAL_EN: length 1.6
  TOP w0.3: U8E5.4 v1(47.05,132.3) 47.05,131.6 R8E68.2
V1P05A_VAL_FB: length 4.6
  TOP w0.3: U8E5.5 47.55,132.65 48.76,131.44 R8E63.1 R8E64.2
V1P05A_VCC: length 4.5
  TOP w0.3: EU5G3.7 160.91,94.48 160.52,94.87 C5G6.1
  TOP w0.5: R5G5.2 158.49,93.98 159.38,94.87 C5G6.1
V1P05A_VIN: length 0.9
  TOP w0.3: R5G14.1 155.95,87.37
V1P05A_VIN_MIX: length 1
  TOP w0.3: R5G14.2 159.25,87.37
V1P8_AUD_EN_R: length 1.4
  TOP w0.1: U6A2.2 108.96,282.44 R6A19.2
V1P8_TCHPNLIO_DISCHRG: length 3.6
  TOP w0.1: R7D5.2 62.1,191.26 61.91,191.45 Q8D8.3
V1P8_TCHPNLIO_EN: length 71.5
  TOP w0.1: Q8E4.1 v1(34.06,153.9) ; v1(54.48,193.55) Q8C15.1 54.48,195.58 54.73,195.83 55.37,195.83 56,196.47 56,197.99 R8C71.1 56,199.01 56,202.06 56.64,202.69 SW7C1.7
  LAY5 w0.125: v1(37.13,191.92) 37.49,191.92 38.1,192.53 40.64,192.53 41.19,191.97 48.26,191.97 49.83,193.55 v1(54.48,193.55)
  LAY6 w0.125: v1(37.13,191.92) 37.13,191.9 36.83,191.59 36.83,184.23 34.67,182.08 34.67,176.02 33.93,175.28 33.93,170.43 35.26,169.11 35.26,166.93 34.06,165.74 v1(34.06,153.9)
V1P8_TCHPNLIO_EN_DIPSW: length 1.4
  TOP w0.1: SW7C1.2 R7C26.2
V1P8A_EN: length 4.1
  TOP w0.1: EU8F2.5 52.07,102.74 52.7,103.38 R8F44.2 C8F14.1 R8F37.2
V1P8A_EN_R: length 3.4
  TOP w0.1: R8F37.1 50.54,105.54 CR8F4.1 CR8F4.2
V1P8A_FB: length 4.3
  TOP w0.3: R8F46.1 47.11,103.58 C8F16.2 47.16,104.47 R8F41.2
  TOP w0.305: R8F46.1 47.75,102.74 48.8,101.69 EU8F2.6
V1P8A_PCH_VAL_EN: length 1.6
  TOP w0.3: R8E28.2 47.05,150.04 v1(47.05,150.69) U8E2.4
V1P8A_PCH_VAL_FB: length 5
  TOP w0.3: U8E2.5 47.55,151.09 48.66,149.98 50.55,149.98 R8E22.1 R8E23.2
V3DUAL_PCHVIN_NCH: length 1.5
  TOP w0.1: R8G41.2 EU8G2.4
V3P3_AUD_EN_R: length 1.9
  TOP w0.1: R8A9.2 32.63,283.97 U8A1.2
V3P3_AUD_SLEW: length 1.5
  TOP w0.1: C8A3.1 32.63,281.31 U8A1.7
V3P3_AUX_RST: length 2.9
  TOP w0.1: U8D5.2 42.76,172.43 43.05,172.72 43.05,173.61 R8D61.2 R8D66.1
V3P3A_FET_CTRL: length 284.8
  TOP w0.1: R8D24.1 R8D29.2 40.13,185.8 40.19,185.86 C8D8.2 41.46,185.86 41.52,185.8 C8D14.2 42.03,186.43 v1(43.3,187.7) ; R6J15.2 v1(133.09,23.37) ; v1(44.95,85.47) 48.51,89.03 48.51,93.22 49.27,93.98 R8G9.1 ; R7H65.1 v1(87.75,43.43)
  LAY3 w0.1: v1(133.09,23.37) 133.09,24 130.39,26.71 114.98,26.71 114.28,27.4 110.91,27.4 109.72,28.59 102.69,28.59 100.17,31.11 87.63,31.11 v1(87.24,30.73)
  LAY5 w0.125: v1(87.75,43.43) 87.17,42.85 83.81,42.85 83.12,42.16 77.06,42.16 76.68,42.55 75.79,42.55 74.93,41.69 72.15,41.69 71.3,42.54 61.13,42.54 60.28,41.7 54.1,41.7 53.28,40.88 47.56,40.88 v1(46.99,41.45)
  LAY6 w0.125: v1(43.3,187.7) 43.57,187.44 43.57,184.79 44.06,184.3 44.06,180.24 45.72,178.59 45.72,176.78 45.21,176.27 45.21,175.51 45.47,175.25 45.47,171.55 45.97,171.05 45.97,168.91 45.75,168.69 45.75,160.62 44.96,159.83 44.96,155.39 47.52,152.82 47.52,149.41 46.25,148.14 46.25,146.2 45.42,145.37 45.42,131.69 46.13,130.98 46.13,126.95 45.11,125.94 45.11,112.43 45.89,111.65 45.89,99.36 45.69,99.16 45.69,95.01 44.52,93.84 44.52,85.9 v1(44.95,85.47) 44.7,85.21 44.7,81.92 45.44,81.18 45.44,80.52 46.1,79.86 46.1,71.52 48.63,68.99 48.63,67.02 48.19,66.58 48.19,65.59 47.62,65.02 47.62,63.12 49.15,61.59 49.15,50.8 49.78,50.16 49.78,43.94 49.14,43.31 48.51,43.31 46.99,41.78 v1(46.99,41.45)
  LAY8 w0.1: v1(87.75,43.43) 87.25,42.93 87.25,30.74 v1(87.24,30.73)
V3P3A_FET_CTRL_VAL: length 2.6
  TOP w0.38: Q7H3.1 87.12,41.91 86.86,42.16 R7H65.2 C7H7.1
V3P3A_PCH_VAL_EN: length 1.6
  TOP w0.3: U8E4.4 v1(47.07,141.57) 47.07,141.55 47.01,141.48 R8E44.2
V3P3A_PCH_VAL_FB: length 4.1
  TOP w0.3: R8E42.2 R8E41.1 49.27,140.71 49.02,140.97 48.26,140.97 47.8,141.43 47.8,141.72 47.57,141.95 U8E4.5
V3P3A_VAL_R: length 1.4
  TOP w0.38: Q7H3.3 86.16,37.65 R7H70.1
V3P3AUX_EN: length 2.5
  TOP w0.25: 31.87,225.68 32.63,226.44 33.27,226.44 33.53,226.7 U8B3.2
V3P3AUX_EN_R: length 76.9
  TOP w0.1: R8C5.1 31.36,224.79 30.35,225.8 28.7,225.8 27.55,226.95 25.27,226.95 v1(25.14,226.82) ; v1(39.75,176.53) 40.89,176.53 41.27,176.15 41.27,172.97 41.46,172.78 U8D5.4
  LAY6 w0.125: v1(25.27,186.31) 25.27,187.7 26.16,188.59 26.16,197.99 26.92,198.75 26.92,201.04 25.9,202.06 25.9,202.89 26.41,203.4 26.41,204.32 26.92,204.83 26.92,207.77 26.54,208.15 26.54,212.73 26.18,213.09 26.18,221.75 25.58,222.35 25.58,226.39 v1(25.14,226.82)
  BOTTOM w0.1: v1(39.75,176.53) 30.98,176.53 27.43,180.08 27.43,180.61 25.27,182.77 v1(25.27,186.31)
V3P3AUX_SLEW: length 3
  TOP w0.25: C8B35.1 31.62,228.34 32.38,229.11 33.27,229.11 33.53,228.85 U8B3.7
V3P3DSW_EN: length 75.4
  TOP w0.1: EU8G1.5 55.34,89.25 55.49,89.41 55.49,91.18 R8G16.2 54.48,92.2 50.16,92.2 v1(49.65,91.69)
  TOP w0.2: v1(12.57,78.74) 11.81,79.5
  TOP w0.25: R9G21.1 C9G4.1 11.81,79.5
  LAY6 w0.125: v1(49.02,72.01) 49.02,73 48.38,73.64 48.38,79.15 50.03,80.81 50.03,87.6 49.65,87.98 v1(49.65,91.69)
  BOTTOM w0.1: v1(12.57,78.74) 13.97,77.34 13.97,75.78 17.68,72.06 17.68,70.96 17.9,70.74 25.52,70.74 26.41,69.85 28.84,69.85 31.06,72.07 46.16,72.07 46.86,71.37 48.38,71.37 v1(49.02,72.01)
V3P3DSW_EN_R: length 7.4
  TOP w0.25: J9G5.1 6.47,76.71 9.52,79.75 9.52,80.39 10.16,81.02 R9G21.2
V3P3DSW_FB: length 4.2
  TOP w0.25: EU8G1.6 52.08,89.28 R8G18.2 50.54,90.12 C8G5.2 51.43,90.17 R8G15.1
V3P3DSW_PCH_VAL_EN: length 1.7
  TOP w0.3: U8E1.4 v1(47.1,159.79) 47.07,159.76 R8E5.2
V3P3DSW_PCH_VAL_FB: length 3.8
  TOP w0.3: U8E1.5 47.6,160.24 48.71,159.13 R8E6.1 50.29,159.13 R8E7.2
V3P3DSW_PCH_VAL_VIN: length 2.2
  TOP w0.3: R8E5.1 45.33,159.89 45.33,161.92
V3P3DSW_VAL_EN: length 2.6
  TOP w0.3: U8F4.4 v1(47.02,123.41) 47.02,122.7 C8F22.1 45.99,122.66 R8F12.2
V3P3DSW_VAL_FB: length 2.6
  TOP w0.3: U8F4.5 47.52,123.76 47.75,123.54 47.75,122.81 R8F10.1 R8F11.2
V3P3DSW_VAL_VIN: length 4.1
  TOP w0.3: R8F12.1 45.59,121.79 45.21,122.17 45.21,125.32
V3P3DUAL_PCH_R: length 4
  TOP w0.1: Q8D6.3 45.78,193.61 45.33,194.05 R8D5.1 R8C83.2 R8D6.1
V3P3DUAL_PCH_R1: length 9.3
  TOP w0.1: Q8D6.2 46.73,191.39 46.35,191.77 44.57,191.77 43.68,192.66 Q8D1.6 42.92,193.04 43.05,193.17 44.19,193.17 44.57,193.55 44.57,194.56 R8D5.2
V3P3DUAL_PCHVIN_NCH: length 119.4
  TOP w0.1: v1(41.78,81.79) 41.65,81.66 R8G41.1 ; R8D18.2 41.14,190.02 41.04,190.12 v1(40.13,190.12) 41.02,191.01 Q8D1.3
  LAY6 w0.125: v1(41.78,81.79) 40,83.57 40,90.91 39.23,91.68 39.23,94.77 39.48,95.02 39.48,98.01 38.97,98.52 38.97,105.83 39.48,106.34 39.48,108.19 38.72,108.95 38.72,111.06 40.77,113.11 40.77,123.54 39.36,124.94 39.36,132.54 38.58,133.33 38.58,137.29 38.84,137.55 38.84,142.81 37.71,143.95 37.71,149.11 38.25,149.65 38.25,165.99 38.6,166.34 38.6,169.06 38.98,169.44 38.98,171.83 38.47,172.34 38.47,173.38 39.18,174.08 39.18,187.07 39.7,187.59 39.7,189.69 v1(40.13,190.12)
V3P3DUAL_PCHVIN_PCH: length 128.6
  TOP w0.1: v1(45.21,82.17) R8G44.1 ; v1(44.85,182.5) 45.32,182.97 45.32,188.96 45.72,189.36 46.48,189.36 47.37,190.24 47.37,192.02 48,192.66 48.51,192.66 49.27,193.42 49.27,194.82 C8C28.1 R8D6.2
  LAY6 w0.125: v1(44.85,182.5) 45.33,182.5 46.23,181.61 46.23,176.76 45.72,176.25 45.72,171.66 47.11,170.26 47.11,169.42 46,168.3 46,160.51 45.21,159.72 45.21,155.49 47.78,152.93 47.78,149.31 46.5,148.03 46.5,146.08 45.97,145.54 45.97,138.96 46.51,138.42 46.51,135.87 45.67,135.03 45.67,132.59 46.56,131.7 48.66,131.7 51.18,129.18 51.18,124.71 50.41,123.95 50.41,120.14 46.14,115.87 46.14,99.26 45.94,99.06 45.94,94.9 45.49,94.45 45.49,82.45 v1(45.21,82.17)
V3P3DX_CPU_SSD2_NCH: length 28.2
  TOP w0.3: Q5C3.3 152.17,205.77 152.42,206.01 154.28,206.01 154.63,205.66 Q5C4.3
  TOP w0.305: EU5C1.4 154.94,216.78 v1(154.94,216.79)
  TOP w0.38: v1(156.46,214.37) 156.46,214.67 EU5C5.4 ; v1(154.94,216.79) 155.44,217.3 155.95,217.3 156.59,217.93 C5C42.1 R5C69.1 ; R5C48.2 152.14,203.96 v1(152.27,204.09) 152.17,204.18 Q5C3.3
  LAY5 w0.38: v1(156.46,214.37) 154.94,215.9 v1(154.94,216.79)
  LAY6 w0.38: v1(152.27,204.09) 152.27,206.75 151.51,207.52 151.51,209.04 152.27,209.8 152.27,214.12 v1(154.94,216.79)
V3P3DX_CPU_SSD2_PCH: length 4.3
  TOP w0.38: Q5C1.4 154.94,212.34 155.7,213.1 CR5C1.2 157.35,211.93 C5C20.1 157.35,210.97 157.32,210.95
V3P3DX_SDCARD_SR_CAP: length 2.1
  TOP w0.203: U8C6.7 26.18,195.85 C8C27.2
V3P3S_DETECT: length 6.6
  TOP w0.1: R8D16.2 R8D10.1 C8D2.1 33.4,189.61 33.4,191.39 34.86,192.85 Q8D3.3
V3P3S_DRAIN: length 11.6
  TOP w0.508: R4G23.2 R4G24.2 172.97,67.69 172.08,66.8 172.08,61.09 171.06,60.07 Q4H2.6
V5.0DX_SSD_SENSE_EAC_NEG: length 2.1
  TOP w0.1: U4H1.A2 188.97,54.99 188.97,56.12 R4H15.2
V5.0DX_SSD_SENSE_EAC_POS: length 2
  TOP w0.1: U4H1.A3 189.17,55.01 189.17,56.22 R4H16.2
V5.0DX_SSD_SENSE_NEG: length 124.1
  TOP w0.1: R4H15.1 v1(188.45,58.29)
  LAY8 w0.1: R6J31.4 107.45,7.36 107.35,7.26 107.35,6.94 107.56,6.73 115.69,6.73 117.55,4.87 125.04,4.87 126.11,3.81 138.26,3.81 140.42,5.97 141.82,5.97 142.58,6.73 142.58,8.07 144.09,9.58 145.73,9.58 146.5,10.34 151.57,10.34 153.03,11.81 154.65,11.81 159.43,16.59 159.43,43.1 165.94,49.61 174.61,49.61 175.42,50.42 181.44,50.42 188.92,57.89 188.92,58.19 188.82,58.29 v1(188.45,58.29)
V5.0DX_SSD_SENSE_POS: length 124.8
  TOP w0.1: R4H16.1 v1(189.59,58.29)
  LAY8 w0.1: v1(189.59,58.29) 189.22,58.29 189.12,58.19 189.12,57.81 181.53,50.21 175.51,50.21 174.7,49.4 166.02,49.4 159.63,43.02 159.63,16.51 154.73,11.6 153.12,11.6 151.65,10.14 146.59,10.14 145.82,9.37 144.17,9.37 142.78,7.98 142.78,6.64 141.9,5.76 140.51,5.76 138.35,3.6 126.02,3.6 124.96,4.67 117.46,4.67 115.61,6.52 107.48,6.52 107.14,6.86 107.14,7.26 107.04,7.36 R6J31.3
V5_AUD_EN_R: length 1.3
  TOP w0.1: R6A13.2 106.55,284.1 U6A1.2
V5_AUD_SLEW: length 2.6
  TOP w0.1: C6A1.1 104.77,286.89 106.29,286.89 106.55,286.64 U6A1.7
V5A_FET_CTRL: length 293.5
  TOP w0.1: R8D27.1 C8D10.2 32.38,186.56 33.78,186.56 C8D11.2 R8D28.2 34.72,184.48 34.72,182.68 33.52,181.48 v1(31.87,181.48) ; R8G42.1 55.37,81.66 54.12,80.42 v1(53.46,80.42) ; R5J7.2 134.62,23.36 v1(135.63,23.36) ; R7H64.1 v1(82.95,42.67)
  LAY3 w0.1: v1(135.63,23.36) 132.06,26.93 115.08,26.93 114.38,27.63 111.01,27.63 109.82,28.82 102.78,28.82 100.26,31.34 85.69,31.34 v1(85.09,30.73)
  LAY5 w0.125: v1(48.51,41.5) 48.53,41.53 51.43,41.53 51.85,41.95 60.18,41.95 61.03,42.8 71.62,42.8 72.48,41.94 74.83,41.94 75.68,42.8 76.78,42.8 77.16,42.42 82.7,42.42 v1(82.95,42.67)
  LAY6 w0.125: v1(31.87,181.48) 31.06,181.48 29.71,180.13 29.71,177.8 30.69,176.83 30.69,166.75 29.45,165.52 29.45,145.78 28.65,144.98 28.65,136.45 29.08,136.02 29.08,135.13 30.48,133.73 30.48,122.8 28.91,121.23 28.91,112.11 29.52,111.49 29.52,110.05 30.48,109.1 30.48,106.69 31.25,105.92 31.66,105.92 32.34,105.23 32.34,93.56 31.87,93.09 31.87,86.86 31.75,86.75 31.75,80.22 v1(31.66,80.14) ; v1(48.51,41.5) 48.51,41.53 50.54,43.56 50.54,47.75 51.16,48.37 51.16,50.69 50.66,51.18 50.66,53.74 52.2,55.28 52.2,61.66 51.5,62.36 51.5,64.42 50.67,65.25 50.67,66.46 50.42,66.72 50.42,68.28 50.99,68.86 50.99,72.27 50.41,72.85 50.41,78.33 52.5,80.42 v1(53.46,80.42)
  LAY8 w0.1: v1(85.09,30.73) 85.09,39.75 82.95,41.88 v1(82.95,42.67)
  BOTTOM w0.1: v1(31.66,80.14) 32.3,80.77 39.75,80.77 40.25,81.28 44.45,81.28 45.46,80.26 53.31,80.26 v1(53.46,80.42)
V5A_FET_CTRL_VAL: length 2.6
  TOP w0.38: C7H6.1 R7H64.2 81.4,42.29 81.78,41.91 Q7H2.1
V5A_VAL_R: length 3.2
  TOP w0.5: R7H71.1 79.12,38.23 79.88,38.99 Q7H2.3
V5DUAL_PCHVIN_NCH: length 13.5
  TOP w0.5: EU4G1.4 186.68,83.31 v1(186.69,83.31) ; R4G5.2 187.86,93.88 v1(187.41,93.88) Q4G1.3
  BOTTOM w0.5: v1(187.41,93.88) 187.41,91.15 186.69,90.42 v1(186.69,83.31)
V5DUAL_PCHVIN_PCH: length 108.8
  TOP w0.1: R6J13.2 v1(127.63,24.12)
  TOP w0.5: v1(180.84,93.09) R4G7.2 C4G6.1
  TOP w0.508: Q4G2.4 v1(182.24,83.31)
  LAY5 w0.38: v1(127.63,24.12) 128.27,24.76 129.64,24.76 131.48,26.6 133.21,26.6 137.09,30.48 151.93,30.48 v1(158.26,36.8)
  LAY6 w0.38: v1(182.24,83.31) 182.24,81.32 180.53,79.61 180.53,77.58 163.23,60.28 159.46,60.28 157.48,58.29 157.48,49.93 158.26,49.15 v1(158.26,36.8)
  BOTTOM w0.5: v1(182.24,83.31) 182.24,91.69 v1(180.84,93.09)
V5DUAL_RC: length 14.8
  TOP w0.508: Q4H4.3 176.27,52.83 177.03,53.59 179.07,53.59 179.7,52.96 181.48,52.96 ; R4H30.1 181.35,54.23 C4H10.2 181.48,52.96 ; 181.48,52.96 C4H12.2 181.48,52.07 181.73,51.81 R4H34.2 R4H39.1 C4H15.2 R4H49.1
V5DX_SSD_SR_CAP: length 1.5
  TOP w0.2: U6J1.7 104.28,8.36 C6J1.1
V5S_DRAIN: length 8.6
  TOP w0.508: R4G25.2 R4H1.2 R4H2.2 173.48,60.45 173.1,60.07 173.1,58.26 Q4H2.3
V10A_CP: length 147
  TOP w0.38: CR1B2.2 284.35,248.41 284.98,249.05 284.98,250.95 v1(285.24,251.2) ; v1(171.06,248.66) 171.06,249.35 169.76,250.65 168.37,250.65 167.77,251.25 162.05,251.25 161.23,252.07 CR5B2.2
  TOP w0.5: CR1B2.2 285.26,247.5 286.25,246.51 R1B11.2
  LAY6 w0.38: v1(171.06,248.66) 171.06,248.67 172.61,250.22 176.1,250.22 176.74,250.86 185.07,250.86 185.36,251.15 189.27,251.15 191.36,253.24 194.31,253.24 195.07,254 197.35,254 199.01,252.34 202.84,252.34 203.78,253.28 207.17,253.28 208.53,254.63 209.42,254.63 210.18,253.87 214.03,253.87 214.79,254.63 215.64,254.63 216.02,254.25 216.02,253.89 216.64,253.28 223.52,253.28 223.9,253.66 223.9,254.25 224.4,254.76 225.29,254.76 225.55,254.5 230.11,254.5 233.04,257.43 233.8,257.43 234.18,257.05 234.18,256.27 235.08,255.38 273.86,255.38 274.06,255.18 282.12,255.18 284.39,252.91 284.39,252.05 v1(285.24,251.2)
V10A_CP_R: length 13.4
  TOP w0.5: U1B1.5 287.59,257.74 287.52,257.81 C1B1.1 286.89,256.54 288.54,254.89 CR1B1.3 288.54,253.91 286.89,252.26 R1B11.1
V12S_CPU_V10A: length 8.5
  TOP w0.5: R1B14.2 283.84,245.11 CR1B2.1 284.35,244.22 CR1B3.1 287.27,241.3 R1B29.2
V12S_DETECT: length 6.2
  TOP w0.1: Q8D4.3 38.86,192.29 38.86,191.64 38.6,191.39 38.6,190.24 38.86,189.99 R8D13.1 ; R8D13.1 R8D17.2 ; R8D13.1 C8D4.1
V12S_DRAIN: length 53.7
  TOP w0.38: v1(222.5,80.01) 222.4,79.91 Q3G2.3
  TOP w0.5: v1(226.82,79.88) 229.02,77.68 244.29,77.68 245.57,76.4 245.57,69.17 243.07,66.67 239.9,66.67 237.87,64.64 237.87,53.47
  LAY5 w0.125: v1(226.82,79.88) 226.69,79.75 222.75,79.75 v1(222.5,80.01)
VCC_1P8A_PWRGD: length 298.6
  TOP w0.1: v1(170.81,92.45) 170.18,92.45 R5G12.1 ; v1(42.49,160.91) 42.49,160.96 42.41,161.03 R8E4.1 ; v1(54.13,168.02) 54.1,168.02 53.59,168.53 52.95,168.53 50.7,166.27 43.08,166.27 42.92,166.11 42.92,163.57 43.38,163.12 43.38,161.97 44.06,161.29 v1(44.06,161.26) ; v1(47.87,106.31) 52.7,106.31 53.21,105.8 53.21,103.38 52.7,102.87 52.7,101.32 52.57,101.19 EU8F2.4
  LAY5 w0.125: v1(170.81,92.45) 165.98,87.63 165.48,87.63 161.16,83.31 159.58,83.31 157.11,80.84 149.65,80.84 149.14,80.32 139.09,80.32 138.73,79.95 136.29,79.95 134.44,78.1 117.52,78.1 114.47,81.15 105.86,81.15 105.22,80.51 101.33,80.51 83.81,62.99 78.51,62.99 76.79,61.27 75.58,61.27 74.29,59.98 74.29,58.57 73.63,57.91 71.6,57.91 70.84,57.15 66.46,57.15 64.82,55.51 54.29,55.51 53.79,55.01 v1(49.93,55.01)
  LAY6 w0.125: v1(49.93,55.01) 49.65,55.3 49.65,62.74 49.14,63.24 49.14,65.08 48.69,65.53 48.69,66.38 49.13,66.81 49.13,69.53 48.26,70.41 48.26,72.08 48.56,72.39 48.56,73.1 48.12,73.54 48.12,79.25 48.76,79.89 48.76,84.07 48.89,84.2 48.89,86.49 47.86,87.51 47.86,97.29 48.63,98.06 48.63,105.55 v1(47.87,106.31) 47.37,106.82 47.37,109.35 55.77,117.75 55.77,129.89 53.6,132.05 53.6,145.42 52.57,146.45 52.57,148.59 52.19,148.97 52.19,150.11 52.57,150.49 52.57,151.38 52.32,151.64 52.32,155.93 52.82,156.43 52.82,159.39 52.57,159.64 52.57,166.5 54.1,168.02 v1(54.13,168.02)
  BOTTOM w0.1: v1(54.13,168.02) 54.13,168.88 51.94,171.07 v1(51.18,171.07) ; v1(44.06,161.26) 44.04,161.26 43.68,160.91 v1(42.49,160.91)
VCC_3P3A_PWRGD: length 1.9
  TOP w0.1: Q8D14.3 38.41,161.99 38.73,161.67 R8E1.1
VCC_3P3DSW_PWRGD: length 123.1
  TOP w0.1: v1(49.65,92.45) 55.11,92.45 55.75,91.82 55.75,89.03 55.47,88.75 EU8G1.4 ; R8D43.1 49.91,183.51 49.27,184.15 46.99,184.15 R8D32.2 R8D26.1 v1(46.48,186.56)
  LAY6 w0.125: v1(49.65,92.45) 49.65,93.47 48.89,94.24 48.89,110.51 56.02,117.65 56.02,129.99 53.86,132.16 53.86,145.53 52.83,146.56 52.83,148.69 52.44,149.07 52.44,150.01 52.83,150.39 52.83,151.49 52.57,151.74 52.57,155.83 53.07,156.33 53.07,163.44 54.02,164.39 54.02,167.05 54.73,167.77 54.73,168.53 53.97,169.29 50.71,169.29 50.16,169.84 50.16,182.88 48.89,184.15 47.87,184.15 46.48,185.55 v1(46.48,186.56)
VCC_HDLED_PWR: length 13.7
  TOP w0.1: R9H2.2 R9H3.2 14.98,61.59 14.73,61.34 11.55,61.34 11.17,61.72 CP9H1.4 10.55,62.11 10.28,61.85 10.28,59.69 J9H1.1
VCCCORE_SENSE_N: length 189.5
  TOP w0.1: J3D1.C16 217.61,197.57 217.61,198.14 217.75,198.28 217.75,205.44 208.15,215.03 197.59,215.03 193.6,219.02 190.5,219.02 186.43,223.08 185.24,223.08 182.69,225.63 182.69,226.16 v1(182.93,226.39) ; v1(278.25,243.84) 277.49,243.08 TP2B1.1 R2B24.2
  LAY6 w0.115: v1(182.93,226.39) 182.72,226.19 182.72,225.91 182.37,225.55 181.41,225.55 180.11,226.85 180.11,228.7 179.34,229.46 179.34,245.58 180.34,246.58 188.72,246.58 191.42,249.28 198.85,249.28 200.02,250.44 216.7,250.44 217.08,250.82 231.9,250.82 234.54,253.47 273.27,253.47 275.23,251.5 275.23,243.71 275.63,243.31 277.72,243.31 v1(278.25,243.84)
VCCCORE_SENSE_P: length 189.1
  TOP w0.1: v1(278.25,243.08) 278.13,242.95 TP2B5.1 278.25,239.9 R2B32.2 ; J3D1.B16 217.55,198.43 217.55,205.36 208.07,214.83 197.5,214.83 193.51,218.82 190.41,218.82 186.35,222.88 185.16,222.88 182.49,225.55 182.49,226.26 182.36,226.39 v1(182.06,226.39)
  LAY6 w0.115: v1(278.25,243.08) 275.54,243.08 275,243.62 275,251.41 273.17,253.24 234.64,253.24 231.99,250.59 217.17,250.59 216.79,250.21 200.12,250.21 198.95,249.05 191.51,249.05 188.82,246.35 180.44,246.35 179.57,245.49 179.57,229.56 180.34,228.8 180.34,226.95 181.5,225.78 182.27,225.78 182.49,226 182.49,226.24 182.34,226.39 v1(182.06,226.39)
VCCGT_BT_PH1: length 2
  TOP w0.2: EU1D1.5 285.77,185.01 C1D3.1
VCCGT_BT_PH1_R: length 1.3
  TOP w0.5: R1D4.2 C1D3.2
VCCGT_BT_PH2: length 2
  TOP w0.2: C1D9.1 285.77,171.57 EU1D2.5
VCCGT_BT_PH2_R: length 1.3
  TOP w0.2: C1D9.2 R1D7.2
VCCGT_COMP: length 3.7
  TOP w0.2: R1C3.1 282.7,225.53 C1C1.1 282.7,226.82 282.34,227.18 EU1B1.39
VCCGT_IC_FB: length 7
  TOP w0.2: EU1B1.40 282.74,227.29 283.59,226.44 C1C1.2 283.59,225.53 R1C3.2 283.56,225.52 282.7,224.66 R1C6.1 282.09,224.05 C1C6.1 282.06,223.78 R1C7.1
VCCGT_IMON: length 3.7
  TOP w0.2: R2B56.2 276.22,228.73 276.92,229.42 276.92,229.89 277.84,230.81 EU1B1.27
VCCGT_ISEN1N: length 2.1
  TOP w0.2: EU1B1.43 283.94,228.63 284.47,228.09 R1B46.2
VCCGT_ISEN1N_R: length 82.6
  TOP w0.2: v1(279.9,178.48) 279.98,178.48 280.34,178.13 286.33,178.13 290.24,182.04 290.24,189.87 287.15,192.97 281.75,192.97 276.6,198.12 276.6,209.18 284.6,217.18 284.6,219.58 286.63,221.61 286.63,224.84 286.13,225.35 C1C4.1 R1C2.1 C1B22.1 286.13,227.96 R1B46.1 ; ISO2D1.2 v1(274.32,184.02)
  BOTTOM w0.2: v1(274.32,184.02) 274.57,183.77 275.37,183.77 279.4,179.75 279.4,178.69 279.6,178.48 v1(279.9,178.48)
VCCGT_ISEN1P: length 8.4
  TOP w0.2: R1C11.2 287.65,224.03 287.65,225.68 R1C2.2 C1B22.2 286.79,227.43 286.79,228.4 286.59,228.6 285.03,228.6 284.85,228.42 284.61,228.42 284.34,228.69 EU1B1.44
VCCGT_ISEN1P_R: length 73.7
  TOP w0.2: v1(279.9,177.8) 286.46,177.8 290.57,181.91 290.57,190.01 287.29,193.29 281.89,193.29 276.93,198.25 276.93,209.04 284.93,217.05 284.93,219.45 285.19,219.71 R1C20.1 ; ISO2D2.2 v1(274.32,183.26)
  BOTTOM w0.2: v1(274.32,183.26) 274.44,183.39 275.27,183.39 279.01,179.64 279.01,178.56 279.78,177.8 v1(279.9,177.8)
VCCGT_ISEN2N: length 1.4
  TOP w0.2: R1C1.2 283.14,228.09 EU1B1.41
VCCGT_ISEN2N_R: length 82.2
  TOP w0.2: ISO2D3.2 v1(274.32,172.72) ; v1(282.06,179.75) 282.14,179.75 282.5,179.4 286.12,179.4 289.17,182.45 289.17,189.36 286.63,191.9 281.43,191.9 274.95,198.37 274.95,209.17 283.08,217.3 283.08,220.22 285.24,222.38 285.24,224.41 284.98,224.66 C1C5.1 284.48,224.79 R1C5.1 C1C2.1 284.48,226.75 R1C1.1
  BOTTOM w0.2: v1(282.06,179.75) 281.99,179.75 281.23,179 281.23,177.17 280.59,176.54 278.77,176.54 276.22,173.99 276.22,172.85 275.97,172.59 274.44,172.59 v1(274.32,172.72)
VCCGT_ISEN2P: length 5.6
  TOP w0.2: EU1B1.42 283.54,228.56 285.36,226.73 C1C2.2 R1C5.2 285.36,224.92 285.87,224.41
VCCGT_ISEN2P_R: length 74.7
  TOP w0.2: R1C17.1 283.41,219.51 283.41,217.16 275.28,209.03 275.28,198.51 281.56,192.22 286.77,192.22 289.5,189.49 289.5,182.31 286.26,179.07 v1(282.06,179.07) ; ISO2D4.2 v1(274.32,171.96)
  BOTTOM w0.2: v1(274.32,171.96) 274.57,172.21 276.05,172.21 276.55,172.71 276.55,173.85 278.91,176.21 280.73,176.21 281.55,177.04 281.55,178.81 281.81,179.07 v1(282.06,179.07)
VCCGT_NTC1N: length 43.1
  TOP w0.2: v1(273.55,211.2) 273.55,211.88 270.31,215.13 270.31,224.25 ISO2C1.2 ; RT2D1.1 v1(270.25,189.23)
  LAY6 w0.2: v1(270.25,189.23) 270.51,189.48 270.51,190.04 270.12,190.43 269.23,190.43 266.95,192.7 266.95,199.64 269.16,201.86 269.16,205.57 273.86,210.27 273.86,211 273.66,211.2 v1(273.55,211.2)
VCCGT_NTC1P: length 43
  TOP w0.2: v1(274.06,211.83) 270.63,215.26 270.63,224.28 R2C9.1 ; RT2D1.2 v1(271.13,189.23)
  LAY6 w0.2: v1(274.06,211.83) 274.19,211.71 274.19,210.13 269.49,205.43 269.49,201.72 267.28,199.51 267.28,192.84 269.36,190.75 270.25,190.75 270.83,190.17 270.83,189.52 v1(271.13,189.23)
VCCGT_PH1: length 1.9
  TOP w0.2: EU1D1.7 285.95,186.01 R1D4.1
VCCGT_PH1_SNB: length 2.9
  BOTTOM w0.5: C1P2.1 279.52,187.45 278.89,186.82 R2P4.2
VCCGT_PH1_VCIN: length 3.5
  TOP w0.3: C1D4.1 286,183.13 R1D5.2 285.87,183.64 285.24,184.28 284.82,184.28 284.55,184.01 EU1D1.3
VCCGT_PH1_VDRV: length 2.9
  TOP w0.3: EU1D1.29 282.46,181.21 282.7,180.97 C1D5.1 R1D6.1
VCCGT_PH2: length 1.9
  TOP w0.2: R1D7.1 286,172.57 EU1D2.7
VCCGT_PH2_SNB: length 1.4
  BOTTOM w0.5: C2P1.1 279.27,173.23 R2P6.2
VCCGT_PH2_VCIN: length 3.6
  TOP w0.3: R1D8.2 C1D10.1 286.02,170.05 285.24,170.84 284.82,170.84 284.56,170.57 EU1D2.3
VCCGT_PH2_VDRV: length 3.2
  TOP w0.3: C1D11.1 282.72,167.51 282.46,167.78 EU1D2.29
  TOP w0.38: C1D11.1 283.87,167.13 R1D9.1
VCCGT_PWM_PH1: length 83.9
  TOP w0.2: v1(287.14,176.15) 287.27,176.02 289.68,176.02 291.92,178.26 291.92,190.93 288.29,194.56 282.47,194.56 278.2,198.83 278.2,208.35 287.65,217.8 287.65,219.2 289.05,220.6 289.05,226.57 290.19,227.71 290.19,230.88 289.17,231.9 286.84,231.9 286.15,231.21 EU1B1.50
  BOTTOM w0.2: R1P2.1 284.09,179.96 286.76,177.29 286.76,176.53 v1(287.14,176.15)
VCCGT_PWM_PH1_R: length 2.3
  TOP w0.2: EU1D1.1 284.6,183.01 284.86,182.75 284.86,182.37 v1(284.73,182.24)
  BOTTOM w0.2: R1P2.2 v1(284.73,182.24)
VCCGT_PWM_PH2: length 90.5
  TOP w0.2: EU1B1.49 286.21,230.81 286.98,231.57 288.92,231.57 289.86,230.63 289.86,227.84 288.67,226.65 288.67,220.68 287.27,219.28 287.27,217.93 277.87,208.54 277.87,198.62 282.26,194.24 288.15,194.24 291.59,190.79 291.59,178.39 289.93,176.73 286.83,176.73 286.51,176.4 286.51,175.89 289.12,173.28 289.12,170.94 289.05,170.86 v1(289.05,170.31)
  BOTTOM w0.2: v1(289.05,170.31) 288.16,170.31 286.89,169.04 285.36,169.04 284.48,168.15 R1P3.1
VCCGT_PWM_PH2_R: length 1.8
  TOP w0.2: EU1D2.1 284.45,169.57 284.6,169.42 v1(284.98,169.42)
  BOTTOM w0.2: 284.22,169.04 284.6,169.04 v1(284.98,169.42)
VCCGT_SENSE: length 125.3
  TOP w0.089: J3D1.AB37 v3(239.07,179.3)
  TOP w0.1: v1(281.63,220.22) 282.01,219.84 282.32,219.84 R1C14.2 282.44,220.6 283.08,221.23 TP1C1.1
  LAY2 w0.1: v1(268.73,164.84) 267.98,164.84 267.39,165.43 267.39,168.94 265.47,170.86 262.99,170.86 254.29,179.56 243.01,179.56 242.33,180.23 241.38,180.23 241.08,179.93 240.51,179.93 240.38,179.81 239.58,179.81 v3(239.07,179.3)
  LAY6 w0.115: v1(281.63,220.22) 281.86,220.44 282.6,220.44 283.21,219.84 283.21,213.61 278,208.41 278,200.97 282.32,196.64 283.29,196.64 284.5,195.43 284.5,194.59 290.47,188.63 290.47,174.72 287.52,171.77 287.52,168.72 282.65,163.85 270.81,163.85 270.11,164.55 269.02,164.55 v1(268.73,164.84)
VCCGT_SENSE_IC_N: length 7.8
  TOP w0.2: R1C13.1 R1C9.1 280.67,223.01 280.67,226.44 281.54,227.31 EU1B1.37
VCCGT_SENSE_IC_P: length 8.8
  TOP w0.2: R1C14.1 282.06,221.74 R1C10.2 281.81,222.25 281.43,222.63 281.43,223.39 280.99,223.83 280.99,225.62 281.68,226.31 R1C4.2 EU1B1.38
VCCGT_TSEN: length 55
  TOP w0.2: RT2D2.1 279.89,189.12 v1(279.16,189.12) ; EU1B1.30 278.33,229.61 278.13,229.41 278.13,228.84 276.8,227.51 276.8,226.34 276.47,226.01 276.47,225.32 275.94,224.79 R2C8.2 275.33,223.32 275.28,223.26 275.28,222.4 275.68,222 275.68,221.94 275.88,221.74 v1(275.94,221.74)
  LAY6 w0.2: v1(279.16,189.12) 278.75,189.12 277.56,190.31 273.57,190.31 271.4,192.48 269.29,192.48 268.55,193.22 268.55,199.08 270.45,200.99 270.45,203.17 270.45,203.18 270.45,205.1 275.58,210.23 275.58,218.95 276.31,219.68 276.31,220.96 275.94,221.34 v1(275.94,221.74)
VCCGT_VSWH_PH1: length 1.9
  BOTTOM w0.5: R2P4.1 278.89,182.5 v1(280.03,181.35)
VCCGT_VSWH_PH2: length 1.6
  BOTTOM w0.5: R2P6.1 278.76,168.65 v1(279.01,168.4)
VCCGT_ZCD#_PH1: length 1.8
  TOP w0.2: v1(284.98,183.64) 284.85,183.51 EU1D1.2
  BOTTOM w0.2: v1(284.98,183.64) 285.36,183.26 R1P1.2
VCCGT_ZCD#_PH2: length 3
  TOP w0.2: EU1D2.2 284.85,170.07 v1(284.98,170.2)
  BOTTOM w0.2: 283.33,169.04 284.5,170.2 v1(284.98,170.2)
VCCIO_0_BT: length 2.8
  TOP w0.2: EU5C3.5 162.38,200.46 162.48,200.35
  TOP w0.38: 162.48,200.35 162.56,200.28 162.56,199.9 162.94,199.52 R5C59.1
VCCIO_0_BT_R: length 1.5
  TOP w0.5: C5C38.2 163.7,196.85 163.44,197.1 R5C59.2
VCCIO_0_CS: length 0.9
  TOP w0.2: R5C47.1 159.93,202.99 EU5C3.14
VCCIO_0_EN: length 452.8
  TOP w0.1: R5E12.2 157.02,155.12 v1(157.02,155.24) ; R5E12.2 157.09,153.92 R5E13.2 157.09,152.46 154.88,150.24 153.41,150.24 152.27,149.1 CR5E1.1 ; R5E12.2 R5E11.2 R5E10.2 C5E7.1 ; v1(157.6,234.57) 157.95,234.92 R5B24.1 ; EU5C3.3 161.58,200.32 v1(161.51,200.25) ; v1(29.46,175.64) 29.71,175.89 R8D54.1
  LAY5 w0.125: v1(32.13,52.83) 33.17,52.83 34.19,53.85 44.82,53.85 45.33,53.34 45.84,53.34 46.16,53.65 46.16,54.29 46.48,54.61 46.48,55.49 47.49,56.51 47.77,56.51 49.11,57.84 52.73,57.84 53.87,58.98 62.25,58.98 62.33,59.06 65.02,59.06 67.95,61.99 69.6,61.99 69.96,62.36 71.62,62.36 72.51,61.47 73.27,61.47 77.85,66.04 82.71,66.04 88.93,72.26 89.79,72.26 92.92,75.39 92.92,76.89 94.38,78.36 95.63,78.36 103,85.72 106.07,85.72 107.59,87.25 113.03,87.25 115.57,84.72 119.13,84.72 120.01,85.6 120.01,91.6 119.26,92.35 119.26,107.46 118.31,108.41 118.31,110.87 117.6,111.58 117.6,113.03 117.98,113.41 123.19,113.41 124.63,114.85 134.32,114.85 v1(136.14,113.03)
  LAY6 w0.125: v1(32.13,52.83) 32,52.96 32,59.14 32.3,59.43 32.3,65.25 30.84,66.7 30.84,68.66 31.62,69.44 31.62,70.86 30.35,72.13 30.35,73.02 31.22,73.89 31.22,74.91 30.18,75.94 30.18,80.3 29.33,81.16 29.33,83.09 29.23,83.18 29.23,88.14 30.48,89.39 30.48,93.64 29.97,94.15 29.97,102.21 30.6,102.85 30.6,105.73 29.9,106.43 29.9,108.96 29.02,109.84 29.02,111.28 28.38,111.92 28.38,116.41 27.56,117.24 27.56,122.03 27.96,122.42 29,122.42 29.66,123.09 29.66,124.25 28.8,125.12 28.8,126.72 29.72,127.63 29.72,131.21 27.65,133.28 27.65,136.5 28.14,137 28.14,145.19 28.95,145.99 28.95,165.73 30.18,166.96 30.18,174.92 v1(29.46,175.64) ; v1(157.6,234.57) 157.6,234.69 157.25,235.05 154.15,235.05 153.92,234.82 153.92,233.42 151.63,231.13 151.63,228.09 154.72,225 154.72,221.35 156.74,219.33 156.74,217.4 160.14,213.99 160.14,211.58 159.38,210.82 159.38,209.55 157.35,207.52 157.35,202.56 158.62,201.29 160.47,201.29 v1(161.51,200.25) 159.33,198.07 159.33,195.85 160.75,194.44 160.75,189.25 157.08,185.58 157.08,182.12 158.99,180.2 158.99,176.45 158.61,176.07 158.61,167.89 156.46,165.74 156.46,164.46 156.97,163.96 156.97,161.67 156.46,161.16 156.46,155.8 v1(157.02,155.24) 156.85,155.07 156.85,152.98 147.19,143.33 147.19,137.8 146.3,136.91 146.3,133.13 146.95,132.48 146.95,122.74 141.35,117.14 141.35,115.72 141.12,115.49 139.59,115.49 139.23,115.13 138.44,115.13 136.35,113.03 v1(136.14,113.03)
VCCIO_0_FB: length 4.6
  TOP w0.2: R5C44.2 158.75,204.85 R5C38.1 R5C39.1 160.27,204.34 161.18,203.43 EU5C3.13
VCCIO_0_G0: length 5
  TOP w0.2: 165.73,205.1 165.5,205.33 164.56,205.33 R5C43.1 164.08,204.72 163.67,204.32 162.75,204.32 162.38,203.94 EU5C3.10
VCCIO_0_G1: length 53.6
  TOP w0.1: v1(156.97,159.89) 156.84,160.02 Q5E2.3
  TOP w0.2: EU5C3.11 161.98,203.83 v1(161.82,203.99) 162.56,204.72 R5C42.1 R5C36.2
  LAY6 w0.125: v1(161.82,203.99) 161.82,203.84 161.54,203.56 161.54,200.91 161.98,200.47 161.98,199.96 160.29,198.26 160.29,196.07 161,195.36 161,189.14 157.33,185.48 157.33,182.22 159.24,180.31 159.24,176.34 158.87,175.96 158.87,167.79 156.71,165.63 156.71,164.57 157.22,164.06 157.22,160.14 v1(156.97,159.89)
VCCIO_0_LG: length 3.5
  TOP w0.3: 163.7,202.94 163.22,202.94 EU5C3.8
  TOP w0.5: 163.7,202.94 R5C52.2
VCCIO_0_LG_R: length 5
  TOP w0.5: R5C52.1 166.62,198.33 167.12,197.83 EU5C4.5
VCCIO_0_LPM_N: length 4.2
  TOP w0.1: R5C72.2 162.35,197.66 162.35,199.08 R5C56.1
  TOP w0.2: EU5C3.4 161.98,200.6 162.05,200.53 162.05,199.64 R5C56.1
VCCIO_0_MODE: length 2.7
  TOP w0.2: EU5C3.1 160.78,200.76 160.14,200.12 R5C54.1 R5C58.2
VCCIO_0_PWRGD: length 48.9
  TOP w0.1: v1(161.14,197.86) 161.14,197.72 R5C64.2 160.52,198.12 R5C55.2 ; v1(151.14,195.71) 151.14,196.58 R5C70.1 151.38,196.85 152.14,196.85 152.34,196.65 v1(157.86,196.65) ; Q5D1.2 151.36,164.83 150.74,164.21 v1(150.64,164.21)
  LAY5 w0.125: v1(157.86,196.65) 158.19,196.98 159.76,196.98 160.65,197.86 v1(161.14,197.86)
  LAY6 w0.125: v1(151.14,195.71) 151.76,195.71 151.89,195.58 151.89,192.78 152.14,192.53 152.14,187.83 151.25,186.94 151.25,167.23 150.74,166.72 150.74,164.34 150.64,164.24 v1(150.64,164.21)
VCCIO_0_PWRGD_R: length 1.6
  TOP w0.2: EU5C3.2 161.18,200.68 161.01,200.5 161.01,199.54 R5C55.1
VCCIO_0_RGND: length 2.8
  TOP w0.2: EU5C3.12 161.58,203.5 161.03,204.04 R5C40.1 R5C41.1
VCCIO_0_SENSE: length 65.3
  TOP w0.2: v1(159.76,206.75) 160.27,206.25 R5C39.2 ; J3D1.D5 207.1,196.27 206.72,196.7 v1(206.69,196.7)
  LAY5 w0.2: v1(159.76,206.75) 162.71,209.7 178.79,209.7 181.86,206.63 181.86,204.34 184.07,202.13 192.18,202.13 194.8,204.74 202.7,204.74 208.48,198.97 208.48,197.66 209.16,196.98 209.16,196.47 208.97,196.28 207.12,196.28 v1(206.69,196.7)
VCCIO_0_SNB: length 1.8
  TOP w0.5: R5D1.1 167.76,193.67 167,194.44 C5C41.2
VCCIO_0_UG: length 2.5
  TOP w0.2: EU5C3.6 162.78,200.69 163.28,200.19 163.28,200.14
  TOP w0.5: R5C51.2 163.9,199.52 163.28,200.14
VCCIO_0_UG_R: length 5.8
  TOP w0.5: R5C51.1 165.22,202.06 168.58,202.06 169.22,201.42 EU5C4.3
VCCIO_0_VIN: length 1.2
  TOP w0.5: R4C19.1 172.36,202.72 171.83,202.18
VCCIO_0_VSW: length 10.5
  TOP w0.2: 164.08,200.4 163.7,200.4 163.18,200.93 EU5C3.7
  TOP w0.5: 165.48,198.25 C5C38.1 ; 165.48,198.25 165.48,199.97 165.47,199.98 165.47,200.18 165.25,200.4 165.05,200.4 165.05,200.4 164.08,200.4 ; 165.48,198.25 165.48,197.74 166.75,196.47 R5D1.2 169.16,196.47
VCCIO_1_2_AND: length 10.2
  TOP w0.1: U5E1.4 158.64,155.49 158.64,152.74 157.64,151.74 156.75,151.74 153.82,148.81 R5E58.1
VCCIO_1_2_BT: length 2.2
  TOP w0.2: 154.99,172.41 154.88,172.52 EU5D2.5
  TOP w0.38: 154.99,172.41 155.06,172.34 155.06,171.96 155.57,171.45 R5D31.1
VCCIO_1_2_BT_R: length 1.4
  TOP w0.5: C5D22.2 156.08,169.29 R5D31.2
VCCIO_1_2_CS: length 0.9
  TOP w0.2: EU5D2.14 152.44,175.05 R5D24.1
VCCIO_1_2_EN: length 219.6
  TOP w0.1: v1(149.42,151.99) 149.76,151.66 149.76,148.94 CR5E1.2 151.38,147.32 153.62,147.32 R5E58.2 153.83,147.53 R5E59.2 ; v1(151.13,17.78) 151.38,18.03 160.4,18.03 170.94,7.49 170.94,5.46 171.45,4.95 172.08,4.95 173.48,3.55 R4J9.1
  TOP w0.2: EU5D2.3 154.08,172.38 v1(154.02,172.31) 153.54,171.83 R5D34.2
  LAY6 w0.125: v1(151.13,17.78) 151.88,18.53 151.88,21.26 149.73,23.41 149.73,26.75 151.19,28.21 151.19,41.2 148.33,44.05 148.33,58.42 147.95,58.8 147.95,67.26 137.92,77.29 137.92,78.17 131.64,84.45 131.64,95.28 127.83,99.09 127.83,113.57 132.42,118.16 132.42,119.56 137.48,124.61 137.48,131.13 142.08,135.74 142.08,137.12 143.89,138.92 143.89,145.06 149.42,150.6 v1(149.42,151.99) 149.46,151.95 149.66,151.95 149.98,152.27 149.98,154.67 150.75,155.44 150.75,155.95 150.3,156.4 150.3,156.7 149.52,157.48 149.52,161.2 150.94,162.62 151.58,162.62 151.89,162.93 151.89,166.76 152.01,166.88 152.01,170.3 v1(154.02,172.31)
VCCIO_1_2_EN_DIODE: length 2
  TOP w0.1: R4J9.2 172.59,3.15 CR4J1.2
VCCIO_1_2_EN_MIX: length 177.2
  TOP w0.1: R5E59.1 154.72,149.39 156.84,151.51 157.73,151.51 159.13,152.91 159.13,156.11 158.78,156.46 157.98,156.46 157.48,156.97 157.09,156.97 156.7,156.57 U5E1.2 155.68,156.57 155.19,156.08 C5E5.1 ; R7B32.2 R7B33.2 81.78,245.24 v1(81.66,245.11) ; C5E5.1 R5E4.2 154.94,157.1 154.73,157.31 151.87,157.31 151.18,156.61 v1(150.87,156.61) ; C5E5.1 R5E7.2
  LAY5 w0.125: v1(150.87,156.61) 143.99,156.61 137.08,163.53 137.08,171.83 136.77,172.14 136.77,179.37 135.63,180.51 135.63,186.91 136.52,187.8 136.52,192.4 136.14,192.78 136.14,205.22 135.13,206.23 135.13,211.52 128.88,217.77 121.55,217.77 116.72,212.93 99.33,212.93 97.28,214.98 97.28,219.07 96.88,219.46 88.06,219.46 82.73,224.79 v1(81.53,224.79)
  LAY6 w0.125: v1(81.66,245.11) 81.66,243.58 80.26,242.19 80.26,232.2 83.05,229.41 83.05,226.31 v1(81.53,224.79)
VCCIO_1_2_FB: length 4.8
  TOP w0.2: R5D23.2 151.25,176.27 151.25,176.91 R5D19.1 R5D20.1 152.78,176.4 153.68,175.49 EU5D2.13
VCCIO_1_2_G0: length 3.9
  TOP w0.2: R5D22.1 R5D17.2 156.59,176.78 156.21,176.4 155.29,176.4 154.88,176 EU5D2.10
VCCIO_1_2_G1: length 2.9
  TOP w0.2: R5D16.2 R5D21.1 155.06,176.64 154.48,176.06 154.48,175.05
VCCIO_1_2_LG: length 3.7
  TOP w0.2: EU5D2.8 156.33,175.05
  TOP w0.5: 156.33,175.05 158.83,175.05 R5D26.2
VCCIO_1_2_LG_R: length 6.3
  TOP w0.5: R5D26.1 159.25,167.85 159.63,167.47 EU5D3.5
VCCIO_1_2_LPM_N: length 5.6
  TOP w0.1: R5D30.1 154.94,170.94 154.94,168.78 R5D42.2
  TOP w0.2: 154.48,173.1 154.48,172.66 154.55,172.59 154.55,171.83 R5D30.1
VCCIO_1_2_MODE: length 2.4
  TOP w0.2: EU5D2.1 153.28,172.82 152.93,172.46 R5D28.1 152.01,172.08 R5D32.2
VCCIO_1_2_PWRGD: length 49
  TOP w0.1: v1(152.78,169.01) R5D35.2 R5D33.1 ; v1(151.1,161.16) 152.27,161.16 152.38,161.27 Q5E1.2 ; R5C71.1 151.89,200.91 v1(152.52,200.28)
  LAY5 w0.125: v1(151.1,161.16) 151.51,161.57 151.51,162.3 152.27,163.07 152.27,165.23 152.78,165.73 v1(152.78,169.01) 151.5,170.29 151.5,176.52 153.56,178.58 153.56,192.07 154.68,193.19 154.68,196.59 155.32,197.23 155.32,197.74 154.94,198.12 153.87,198.12 152.52,199.46 v1(152.52,200.28)
VCCIO_1_2_PWRGD_R: length 1.9
  TOP w0.2: EU5D2.2 153.68,172.71 152.78,171.8 R5D33.2
VCCIO_1_2_SENSE: length 72.3
  TOP w0.127: 201.79,176.43 201.84,176.43 202.22,176.05 203.04,176.05 203.29,175.8 204.61,175.8 204.81,176 204.81,176.28 205.13,176.61 205.78,176.61 J3D1.AE4
  TOP w0.205: R5D20.2 152.78,178.56 154.05,179.83 156.33,179.83 157.86,178.31 169.41,178.31 170.88,176.84 175.07,176.84 177.03,174.88 177.03,168.92 179.39,166.56 179.39,165.26 180.17,164.48 182.88,164.48 185.27,166.87 185.27,168.07 194.02,176.82 201.4,176.82 201.79,176.43
VCCIO_1_2_SNB: length 1.4
  TOP w0.5: R5D36.1 164.84,166.37 C5D28.2
VCCIO_1_2_UG: length 2.3
  TOP w0.2: 155.99,172.25 155.79,172.25 155.28,172.75 EU5D2.6
  TOP w0.5: R5D25.2 156.8,172.25 155.99,172.25
VCCIO_1_2_UG_R: length 6.8
  TOP w0.5: EU5D3.3 161.09,172.92 160.27,173.73 157.09,173.73 R5D25.1
VCCIO_1_2_VIN: length 0.9
  TOP w0.5: R5D29.1 162.05,171.58
VCCIO_1_2_VSW: length 18.2
  TOP w0.2: 156.46,172.97 155.81,172.97 EU5D2.7
  TOP w0.5: 158.11,170.56 158.11,167.26 160.14,165.23 L5D1.1 163.19,165.23 165.22,163.19 ; 158.11,170.56 156.84,170.56 C5D22.1 ; 158.11,170.56 158.11,172.62 157.75,172.97 156.46,172.97
VCCIO_EN_DIODE: length 1.5
  TOP w0.1: R8D54.2 28.57,176.15 28.57,175
VCCIO_PWRGD: length 2.5
  TOP w0.1: R5C71.2 R5C57.1 R5C60.2 R5C70.2
VCCIO_PWRGD_R: length 43.2
  TOP w0.1: v1(149.73,178.18) 150.49,177.42 150.49,167.26 151.07,166.68 152.45,166.68 152.8,166.33 152.8,164.49 152.49,164.18 Q5D1.3 152.01,163.7 R5D39.2 152.27,163.19 151.73,162.66 Q5E1.3 ; v1(151.89,197.36) 151.89,198.12 152.01,198.25 R5C60.1
  LAY5 w0.125: v1(151.89,197.36) 148.92,194.39 148.79,194.39 148.58,194.18 148.58,191.54 148.2,191.15 148.2,189.82 151,187.01 151,180.32 149.98,179.3 149.98,178.43 v1(149.73,178.18)
VCCMPHY_SENSE: length 105.4
  TOP w0.089: 111.63,130.43 111.62,130.44 111.62,130.45 111.58,130.49 111.58,130.52 111.19,130.91 110.22,130.91 109.31,131.82 109.31,134.49 109.43,134.6 109.43,135.15 109.35,135.23 109.35,136.02 U6E1.K47
  TOP w0.1: 111.63,130.43 112.75,129.31 112.75,112.8 114.6,110.94 114.6,109.95 115.06,109.5 115.06,106.58 114.17,105.69 114.17,99.16 120.31,93.02 121.01,93.02 121.2,92.82 v1(121.2,92.77) ; R5G6.2 170.18,95.12 v1(170.81,94.49)
  LAY5 w0.115: v1(170.81,94.49) 170.54,94.75 170.42,94.75 167.99,97.18 148.17,97.18 147.41,96.42 142.27,96.42 140.11,98.57 133.57,98.57 128.61,93.62 124.42,93.62 123.85,93.05 121.49,93.05 v1(121.2,92.77)
VCCPDSW_3P3A_SENSE_EAC_NEG: length 3.2
  TOP w0.1: U4H1.D2 188.97,53.21 188.97,52.69 190.15,51.5 190.15,51.36 R4H42.2
VCCPDSW_3P3A_SENSE_EAC_POS: length 3.2
  TOP w0.1: U4H1.D3 189.17,53.19 189.17,52.77 190.35,51.59 190.35,51.43 R4H43.2
VCCPDSW_3P3A_SENSE_NEG: length 224.8
  TOP w0.1: R4H42.1 v1(189.72,49.27)
  LAY3 w0.1: v1(115.31,45.97) 115.62,46.28 117.05,46.28 118.32,47.55 121.03,47.55 121.46,47.12 149.6,47.12 149.86,47.37 183.38,47.37 185.8,49.78 189.92,49.78 190.19,49.52 190.19,49.37 190.09,49.27 v1(189.72,49.27)
  LAY8 w0.1: v1(96.52,25.78) 96.79,25.5 97,25.5 98.12,26.62 101.93,26.62 115.03,39.72 115.03,41.5 115.95,42.42 115.95,46.1 115.77,46.28 115.62,46.28 v1(115.31,45.97) 115.01,46.28 114.59,46.28 114.34,46.52 114.34,47.84 116.07,49.56 116.07,56.01 113.96,58.12 113.96,78.65 113.53,79.08 113.53,108.33 102.23,119.63 95.25,119.63 92.53,122.35 90.5,122.35 89.62,121.46 82.12,121.46 77.39,126.19 77.39,129.12 77.76,129.49 78.41,129.49 78.8,129.1 78.8,128.88 78.9,128.78 R7F1.4
VCCPDSW_3P3A_SENSE_POS: length 224.8
  TOP w0.1: R4H43.1 v1(190.86,49.27)
  LAY3 w0.1: v1(190.86,49.27) 190.49,49.27 190.39,49.37 190.39,49.6 190,49.99 185.71,49.99 183.3,47.57 149.77,47.57 149.52,47.32 121.54,47.32 121.11,47.75 118.23,47.75 116.96,46.48 115.62,46.48 v1(115.31,46.78)
  LAY8 w0.1: R7F1.3 78.49,128.78 78.59,128.88 78.59,129.02 78.33,129.28 77.85,129.28 77.59,129.03 77.59,126.27 82.2,121.66 89.53,121.66 90.42,122.55 92.61,122.55 95.33,119.84 102.32,119.84 113.74,108.41 113.74,79.17 114.17,78.74 114.17,58.2 116.28,56.09 116.28,49.48 114.55,47.75 114.55,46.61 114.68,46.48 115.01,46.48 v1(115.31,46.78) 115.62,46.48 115.86,46.48 116.15,46.18 116.15,42.33 115.23,41.41 115.23,39.64 102.01,26.41 98.2,26.41 97.08,25.3 96.79,25.3 v1(96.52,25.02)
VCCPGPPA_3P3_1P8_R: length 5.2
  BOTTOM w0.508: R7R46.2 R7R45.2 R7R44.2 R7R43.2 R7R48.1
VCCPGPPBC_3P3_1P8_R: length 5.2
  BOTTOM w0.508: 70.1,148.21 R7R37.1 64.89,148.21
VCCPGPPD_3P3_1P8_R: length 5.1
  BOTTOM w0.508: R7R36.1 72.39,148.21
VCCPGPPEF_3P3_1P8_R: length 5.1
  BOTTOM w0.5: R7T24.2 R7T23.2 R7T22.1 R7T21.2 R7T20.2
VCCPGPPHK_3P3_1P8_R: length 5.1
  BOTTOM w0.508: R6T16.2 R6T14.2 R6T12.1 R6T10.2 R6T8.2
VCCPRIM_1P8_SENSE_EAC_NEG: length 3.9
  TOP w0.1: U4H1.C1 188.2,53.85 187.9,53.55 187.88,53.55 186.87,52.53 186.87,51.5 R4H40.2
VCCPRIM_1P8_SENSE_EAC_POS: length 3.3
  TOP w0.1: R4H41.2 187.07,51.29 187.07,52.45 187.97,53.35 U4H1.D1
VCCPRIM_1P8_SENSE_NEG: length 337.5
  TOP w0.1: R4H40.1 v1(186.29,49.27)
  LAY8 w0.1: v1(186.29,49.27) 186.66,49.27 186.76,49.37 186.76,49.67 186.6,49.83 186.01,49.83 182.53,46.35 166.87,46.35 162.05,41.53 162.05,16.09 152.14,6.19 152.14,2.54 150.92,1.32 99.64,1.32 96.97,3.98 92.78,3.98 88.94,7.82 88.94,11.13 90.09,12.28 90.09,15.7 90.72,16.34 90.72,17.16 90.94,17.39 91.17,17.39 v1(91.44,17.65) 91.7,17.39 91.84,17.39 91.94,17.49 91.94,18 90.59,19.35 87.29,19.35 85.52,21.12 85.52,21.88 80.94,26.46 80.94,39.7 80.05,40.59 80.05,41.99 75.05,46.99 73.49,46.99 72.05,48.43 72.05,55.16 71.55,55.67 71.55,60.28 72.05,60.79 72.05,63.2 72.69,63.84 72.69,66.33 70.19,68.83 64.09,68.83 61.89,71.04 55.16,71.04 53.13,73.07 53.13,78.31 51.73,79.71 51.73,85.01 51.86,85.14 51.86,111.97 56.08,116.19 56.08,135.11 59.1,138.13 59.1,148.42 59.98,149.3 62.27,149.3 66.16,153.2 66.16,154.34 75.01,163.19 75.01,164.49 74.91,164.59 R7P10.4
VCCPRIM_1P8_SENSE_POS: length 337.5
  TOP w0.1: R4H41.1 v1(187.43,49.27)
  LAY8 w0.1: R7P10.3 75.32,164.59 75.22,164.49 75.22,163.11 66.37,154.25 66.37,153.11 62.35,149.1 60.07,149.1 59.3,148.33 59.3,138.05 56.28,135.02 56.28,116.1 52.07,111.89 52.07,85.05 51.94,84.93 51.94,79.79 53.34,78.39 53.34,73.15 55.24,71.25 61.97,71.25 64.18,69.04 70.28,69.04 72.89,66.42 72.89,63.75 72.26,63.12 72.26,60.7 71.75,60.2 71.75,55.75 72.26,55.24 72.26,48.51 73.58,47.19 75.14,47.19 80.26,42.07 80.26,40.67 81.15,39.79 81.15,26.54 85.72,21.97 85.72,21.21 87.37,19.56 90.67,19.56 92.15,18.08 92.15,17.4 91.93,17.18 91.7,17.18 v1(91.44,16.91) 91.17,17.18 91.03,17.18 90.93,17.08 90.93,16.25 90.29,15.62 90.29,12.19 89.15,11.05 89.15,7.91 92.87,4.19 97.06,4.19 99.73,1.52 150.83,1.52 151.94,2.63 151.94,6.27 161.84,16.18 161.84,41.61 166.79,46.56 182.45,46.56 185.92,50.04 186.69,50.04 186.96,49.76 186.96,49.37 187.06,49.27 v1(187.43,49.27)
VCCPSPI_PCH_3P3_1P8_R: length 77.5
  LAY5 w0.508: v1(72.99,163.19) 73.02,163.17 73.02,157.31 72.13,156.42 72.13,153.09 73.35,151.87 73.35,144.73 73.1,144.47 73.1,139.1 74.67,137.53 74.67,132.46 71.75,129.54 v1(71.75,129.31)
  LAY6 w0.5: v1(88.26,112.77) 85.59,112.77 83.3,115.07 82.68,115.07 81.29,116.46 81.29,117.48 77.73,121.03 75.18,121.03 74.24,121.97 74.24,127.05 72,129.28 71.78,129.28 v1(71.75,129.31)
  BOTTOM w0.508: 72.13,163.19 v1(72.99,163.19)
  BOTTOM w0.58: R7T2.2 R7T4.1 91.69,119.76 91.22,119.29 91.22,115.99 90.17,114.93 90.17,114.43 90.93,113.66 90.93,113.03 90.29,112.39 88.64,112.39 v1(88.26,112.77)
VCCSA_BG: length 10.6
  TOP w0.5: EU5B1.5 169.13,239.37 v1(169.03,239.27) ; v1(162.3,241.68) 161.67,241.04 R5B73.2
  LAY6 w0.5: v1(169.03,239.27) 169.03,240.54 168.27,241.3 162.68,241.3 v1(162.3,241.68)
VCCSA_BG_R: length 2.6
  TOP w0.2: 158.96,240.35 158.77,240.16 158.49,240.16 158.36,240.03 EU5B2.11
  TOP w0.508: 158.96,240.35 159.66,241.04 R5B73.1
VCCSA_BT: length 2.8
  TOP w0.2: 158.36,238.38 158.36,238.61 158.15,238.83 EU5B2.8
  TOP w0.508: 158.36,238.38 158.62,238.12 R5B88.2
VCCSA_BT_R: length 2.2
  TOP w0.508: R5B88.1 v1(162.3,238.12)
  BOTTOM w0.5: v1(162.3,238.12) 161.67,238.76 C5M3.1
VCCSA_COMP: length 4.4
  TOP w0.2: R5B70.2 151.51,242.12 C5B43.2 152.14,242.7 153.03,241.81 153.03,241.43 153.63,240.83 EU5B2.23
VCCSA_EN: length 4.6
  TOP w0.1: R5B24.2 157.85,236.22 R5B27.2 R5B91.2 C5B17.1 155.64,237.17 155.02,237.78 155.02,238.18
VCCSA_FB: length 7.7
  TOP w0.2: R5B71.2 149.73,242.31 R5B69.1 149.86,242.7 C5B43.1 150.36,242.44 R5B70.1 150.36,241.68 150.66,241.38 151.72,241.38 C5B42.2 152.19,241.81 153.57,240.43 EU5B2.24
VCCSA_IMON: length 2.6
  TOP w0.2: R5B65.1 154.74,243.71 155.82,242.62 EU5B2.18
VCCSA_ISENN: length 28.2
  TOP w0.2: ISO17528.2 173.8,243.67 v1(174.24,243.67) ; EU5B2.21 154.36,241.87 153.87,242.36 v1(153.87,242.62)
  BOTTOM w0.2: v1(153.87,242.62) 154.37,243.12 154.9,243.12 155.7,242.31 C5M1.1 156.84,242.31 157.22,242.7 ; 157.22,242.7 157.67,242.25 157.67,241.12 157.87,240.92 159.25,240.92 R5M4.1 ; 157.22,242.7 158.24,243.71 161.03,243.71 161.96,244.64 172.37,244.64 173.61,243.4 173.97,243.4 v1(174.24,243.67)
VCCSA_ISENP: length 21.5
  TOP w0.2: 155.02,241.87 155.02,242.23 v1(154.63,242.62) ; RT5B1.1 170.94,238.67 v1(170.68,238.42)
  BOTTOM w0.2: v1(154.63,242.62) 155.83,241.43 C5M1.2 156.71,241.43 R5M3.2 156.97,241.14 157.57,240.54 159.89,240.54 160.14,240.79 R5M5.1 160.48,241.38 160.82,241.38 161.88,240.32 163.48,240.32 166.06,237.74 170.02,237.74 170.68,238.41 v1(170.68,238.42)
VCCSA_ISENP_L: length 15.8
  TOP w0.2: ISO17599.2 173.76,242.95 174.19,242.95 v1(174.24,242.9)
  BOTTOM w0.2: v1(174.24,242.9) 174.07,243.08 173.48,243.08 172.24,244.32 162.14,244.32 160.78,242.95 R5M1.1
VCCSA_PG: length 3.8
  TOP w0.1: R5B80.1 159.25,236.85 157.92,238.18 157.02,238.18
VCCSA_PSYS: length 3.1
  TOP w0.2: 155.42,241.87 155.42,242.56 154.78,243.2 153.92,243.2 153.67,243.46 153.67,243.71
VCCSA_PVCC: length 4.4
  TOP w0.2: EU5B2.12 158.26,240.43 159,241.17 159,241.44
  TOP w0.508: C5B41.1 159.89,242.95 R5B72.2 159.39,242.19 159,241.8 159,241.44
VCCSA_RGND: length 5.9
  TOP w0.2: R5B60.1 R5B63.1 C5B39.1 ; C5B39.1 152.01,243.33 153.41,241.93 153.41,241.55 153.74,241.23 EU5B2.22 ; C5B39.1 C5B38.2
VCCSA_SENSE: length 207.5
  TOP w0.2: J3D1.C6 208.06,197.25 v1(207.61,197.71) ; R5B59.2 v1(150.11,246.02)
  LAY3 w0.1: v1(151.89,139.44) 151.89,140.08 152.78,140.97 154.55,140.97 155.7,142.11 155.7,150.83 164.74,159.87 164.74,164.6 174.63,174.49 174.63,179.01 179.41,183.79 182.46,183.79 188.94,190.28 188.94,191.04 189.83,191.92 190.59,191.92 199.45,200.79 205.35,200.79 206.75,199.39 206.75,198.57 v1(207.61,197.71)
  LAY5 w0.2: v1(207.61,197.71) 206.75,198.57 206.75,199.77 202.43,204.09 195.07,204.09 192.4,201.42 183.86,201.42 181.21,204.07 181.21,206.36 178.51,209.05 165.18,209.05 163.71,207.57 161.85,207.57 161.29,207.01 v1(161.29,206.75)
  LAY6 w0.2: v1(161.29,206.75) 161.29,207.01 161.93,207.65 161.93,208.71 162.32,209.1 163.13,209.1 164.28,210.26 164.28,215.75 161.39,218.64 160.53,218.64 159.56,219.61 159.56,227.2 160.64,228.29 160.64,230.5 161.92,231.77 161.92,235.58 161.11,236.39 158.53,236.39 156.8,238.12 156.8,242.4 157.48,243.08 157.48,244.47 157.09,244.85 156.21,244.85 155.19,245.87 154.17,245.87 153.28,244.98 151.15,244.98 v1(150.11,246.02)
