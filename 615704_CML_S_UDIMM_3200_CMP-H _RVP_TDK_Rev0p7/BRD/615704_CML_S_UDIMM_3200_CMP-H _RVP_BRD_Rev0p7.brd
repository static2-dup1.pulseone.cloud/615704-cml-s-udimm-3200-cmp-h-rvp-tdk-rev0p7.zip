# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_THERM_IN: length 7.5
  TOP w0.1: R8G2.1 38.48,97.03 37.33,98.17 37.33,98.8 36.64,99.49 35.56,99.49 34.77,100.29 U8F6.117
DDR_THERM_IN_R: length 268.6
  TOP w0.2: R8G7.1 177.29,95.88 v1(176.53,96.65) ; v1(40.13,94.74) 40.25,94.74 R8G5.2 C8G2.1 R8G2.2
  LAY5 w0.2: v1(46.35,39.24) 46.35,39.33 46.55,39.53 50.13,39.53 52.45,37.21 63.78,37.21 64.26,37.69 64.86,37.69 65.68,38.5 67.78,38.5 68.12,38.16 75.12,38.16 75.69,37.59 79.28,37.59 80.01,36.86 89.38,36.86 90.24,37.72 90.24,38.42 93.87,42.05 123.63,42.05 124.65,41.04 126.23,41.04 126.56,41.36 155.58,41.36 156.9,42.68 161.34,47.12 165.23,47.12 167.38,49.27 174.75,49.27 175.76,50.29 180.34,50.29 v1(180.97,50.93)
  LAY6 w0.2: v1(46.35,39.24) 46.22,39.24 45.46,40 45.46,48.64 47.62,50.8 47.62,54.77 46.95,55.44 46.95,59.17 46.35,59.77 46.35,67.03 46.06,67.32 46.06,67.88 44.91,69.03 44.91,72.53 43.14,74.3 43.14,80.92 42.53,81.53 42.32,81.75 42.32,88.36 41.4,89.28 41.4,90.04 39.62,91.82 39.62,94.23 v1(40.13,94.74)
  BOTTOM w0.2: v1(176.53,96.65) 176.53,94.23 179.83,90.93 179.83,84.45 181.73,82.55 181.73,81.02 179.45,78.74 179.45,77.34 177.06,74.95 177.06,72.39 174.87,70.21 174.87,68.07 178.81,64.13 178.81,59.82 180.21,58.42 183.38,58.42 183.89,57.91 183.89,56.64 185.03,55.5 185.03,54.23 182.49,51.69 181.73,51.69 v1(180.97,50.93)
DDR_VTT_CNTL: length 173.1
  TOP w0.088: J3D1.AC33 v1(235.41,177.52)
  TOP w0.1: R2G39.1 251.71,72.9 v1(251.71,72.77)
  LAY5 w0.125: v1(279.01,147.95) 280.51,146.46 280.51,143.1 283.79,139.83 283.79,137.75 285.89,135.65 285.89,97.44 284.08,95.64 284.08,94.81 283.14,93.86 282.3,93.86 277.74,89.3 277.74,83.56 272.92,78.74 271.92,78.74 266.46,73.28 252.22,73.28 v1(251.71,72.77)
  LAY6 w0.1: 242.79,180.46 242.62,180.28 240.24,180.28 239.52,179.56 239.52,178.13 239.36,177.98 235.87,177.98 v1(235.41,177.52)
  LAY6 w0.125: v1(279.01,147.95) 279.01,149.3 276.6,151.71 276.6,155.32 267.9,164.02 267.9,165.19 266.47,166.62 266.47,172.99 264.23,175.22 261.68,175.22 260.91,175.99 260.91,177.35 255.93,182.33 244.67,182.33 242.79,180.46
DDSP_3_AUX_DN: length 111.9
  TOP w0.1: v1(290.28,240.38) 290.52,240.14 290.81,240.14 R1B48.1 291.39,240.1 291.54,240.1 292.1,239.55 292.46,239.55 292.6,239.69 C1B11.1 ; v1(213.09,191.23) 212.64,190.78 J3D1.K11
  LAY6 w0.089: v1(213.09,191.23) 213.35,191.49 213.35,193.54 213.45,193.64 213.45,194.44 213.76,194.75 213.76,195.3
  LAY6 w0.115: v1(290.28,240.38) 289.96,240.05 289.76,240.05 289.07,239.36 289.07,237.72 289.35,237.44 289.35,231.87 286.99,229.51 277.7,229.51 262.31,214.12 256.72,214.12 253.39,210.79 250.45,210.79 248.16,208.51 246.15,208.51 245.14,207.49 243.23,207.49 241.58,205.84 218.34,205.84 213.76,201.26 213.76,195.3
DDSP_3_AUX_DP: length 111.9
  TOP w0.1: v1(290.28,239.55) 290.38,239.65 R1B49.1 291.33,239.9 291.46,239.9 292.01,239.35 292.27,239.35 C1B12.1 ; v1(213.09,190.32) 213.55,190.78 J3D1.K12
  LAY6 w0.089: 213.99,195.2 213.96,195.17 213.96,194.66 213.65,194.35 213.65,193.55 213.56,193.46 213.56,190.78 v1(213.09,190.32)
  LAY6 w0.115: 213.99,195.2 213.99,201.17 218.44,205.61 241.68,205.61 243.33,207.26 245.23,207.26 246.25,208.28 248.26,208.28 250.54,210.56 253.49,210.56 256.81,213.89 262.4,213.89 277.79,229.28 287.09,229.28 289.58,231.77 289.58,237.53 289.3,237.81 289.3,239.27 289.85,239.82 290.02,239.82 v1(290.28,239.55)
DDSP_HPD_2_PCON: length 97.5
  TOP w0.1: 243.21,265.59 243.55,265.59 v1(244.15,264.98) ; v1(156.97,258.06) 156.46,258.06 R5B1.2
  LAY5 w0.125: v1(244.15,264.98) 242.37,264.98 242.06,264.66 235.86,264.66 235.47,264.28 233.63,264.28 232.23,265.68 228.95,265.68 228.72,265.46 221.96,265.46 221.49,264.98 216.53,264.98 214.38,267.13 210.5,267.13 207.67,264.3 201.02,264.3 199.36,265.96 196.5,265.96 196.12,265.57 192.04,265.57 191.71,265.25 179.61,265.25 178.52,264.16 175.26,264.16 171.58,260.48 162.96,260.48 162.59,260.11 159.38,260.11 157.33,258.06 v1(156.97,258.06)
DDSP_HPD_2_TR: length 5.8
  TOP w0.089: 160.65,262.37 160.65,262.76 161.06,263.17 161.53,263.17 U5A2.AA2
  TOP w0.1: R5B2.2 158.87,259.21 159.76,260.09 159.76,261.24 160.65,262.13 160.65,262.37
DEVICE_DET_G3: length 204.1
  TOP w0.1: R9F9.2 R9F7.2 23.24,114.04 v1(23.36,114.17) ; v1(127.38,37.84) 126.49,36.96 R6H38.1 126.49,36.07 127.12,35.43 R6H39.1
  LAY5 w0.125: v1(127.38,37.84) 127.88,37.34 127.88,35.3 126.23,33.65 122.49,33.65 121.78,34.36 112.97,34.36 112.76,34.15 106.86,34.15 105.97,35.05 102.54,35.05 101.51,34.02 63.34,34.02 62.06,32.75 50.56,32.75 50.14,33.17 47.67,33.17 45.67,35.18 39.37,35.18 38.86,34.66 34.61,34.66 33.46,33.51 30.24,33.51 28.57,35.18 27.81,35.18 27.55,35.43 25.59,35.43 25.34,35.18 21.59,35.18 v1(21.33,35.43)
  LAY6 w0.125: v1(21.33,35.43) 22.09,36.19 22.09,37.34 21.71,37.72 21.71,43.46 22.47,44.22 22.47,46.48 24.72,48.73 24.72,50.93 24,51.65 24,53.34 25.03,54.37 25.03,56.84 25.68,57.48 25.68,63.4 23.74,65.34 23.74,69.71 24.6,70.58 24.6,75.09 25.07,75.56 25.07,80.59 23.5,82.16 23.5,83.94 23.23,84.21 23.23,85.31 23.67,85.75 23.67,88.68 23.23,89.12 23.23,94.11 22.98,94.36 22.98,109.09 24,110.11 24,113.54 v1(23.36,114.17)
DEVICE_DET_G3_AIC: length 8.5
  TOP w0.1: 126.36,29.62 127.15,28.83 128.27,28.83 128.52,29.08 128.52,31.24 127.38,32.38 R6H39.2
DEVICE_DET_G3_BP: length 293.3
  TOP w0.1: v1(145.38,271.4) 145.38,271.4 145.28,271.3 145.28,270.41 EU5A1.42 ; R6H38.2 v1(127.38,37.08)
  LAY5 w0.125: v1(117.47,90.55) 114.39,93.63 114.39,105.37 115.32,106.3 115.32,107.31 114.81,107.82 114.81,113.07 119.86,118.12 128.75,118.12 134.6,123.97 134.6,131.7 140.51,137.62 140.51,157.02 133.89,163.65 133.89,167.75 134.7,168.56 134.7,170.86 133.58,171.99 133.58,175.77 132.58,176.77 132.58,178.03 131.95,178.66 131.95,180.24 133.12,181.41 133.12,185.36 132.2,186.28 132.2,189.17 132.64,189.61 132.64,191.86 133.35,192.56 133.35,196.48 132.96,196.87 132.96,202.8 132.2,203.56 132.2,210.87 127.93,215.14 127.02,215.14 126.94,215.22 122.5,215.22 122.29,215.01 121.48,215.01 v1(121.28,215.21)
  LAY6 w0.125: v1(145.38,271.4) 144.01,270.03 144.01,264.16 143.51,263.65 138.68,263.65 137.66,262.63 137.66,261.49 134.74,258.57 134.74,257.47 126.12,248.84 126.12,247.27 118.78,239.94 118.78,238.79 117.65,237.66 117.65,232.69 116.84,231.88 116.84,222.53 117.7,221.66 117.7,218.79 v1(121.28,215.21) ; v1(127.38,37.08) 128.01,37.72 128.01,39.75 130.3,42.04 130.3,54.86 122.42,62.73 122.42,64.51 122.78,64.87 122.78,69.83 123.66,70.72 123.66,77.78 121.34,80.1 121.34,83.63 120.77,84.2 120.77,86.28 119.99,87.06 119.99,88.28 117.72,90.55 v1(117.47,90.55)
DEVICE_DET_G3_EC: length 243.5
  TOP w0.1: U8F6.16 25.62,106.9 25.9,107.19 25.9,107.68 25.38,108.2 24.63,108.2 24.25,108.58 24.25,110.34 23.31,111.28 v1(23.31,111.86) 22.91,112.27 R9F9.1 ; R5J20.1 136.77,7.75 v1(136.65,7.62)
  LAY3 w0.1: v1(77.59,38.86) 77.83,38.63 80.43,38.63 81.21,39.4 88.02,39.4 88.97,40.35 89.6,40.35 90.2,40.95 95.53,40.95 96.42,40.06 97.25,40.06 98.13,40.95 103.92,40.95 105.06,39.8 108.88,39.8 109.59,39.09 114.82,39.09 115.58,38.33 122.44,38.33 124.38,36.39 124.38,35.85 124.97,35.26 147.26,35.26 154.28,28.24 154.28,23.12 155.8,21.6 155.8,9.5 151.63,5.33 149.14,5.33 145.56,1.75 139.09,1.75 136.65,4.2 v1(136.65,7.62)
  LAY8 w0.1: v1(23.31,111.86) 26.06,109.12 34.04,109.12 37.19,105.96 37.68,105.96 38.27,105.37 38.27,98.45 41.32,95.4 41.32,85.65 43.09,83.87 43.09,82.6 45.13,80.57 45.13,79.52 46.04,78.61 46.04,70.86 48.23,68.67 48.23,65.88 49.31,64.8 50.7,64.8 55.73,59.77 55.73,56.13 59.4,52.45 61.88,52.45 71.25,43.08 72.74,43.08 76.15,39.67 76.78,39.67 v1(77.59,38.86)
DEVICE_DET_G3_PCH: length 211.6
  TOP w0.089: U6E1.R46 107.34,136.37 107.44,136.26 107.44,135.88 107.34,135.77 107.34,135.73 107.34,130.96 109.93,128.37 109.93,127.77
  TOP w0.1: 109.93,127.77 109.93,110.18 109.04,109.29 109.04,107.95 109.36,107.63 109.36,106.84 v1(108.81,106.3) ; R9F7.1 v1(23.36,114.93)
  LAY5 w0.125: v1(24.51,55.62) 24.76,55.37 27.91,55.37 28.17,55.11 33.19,55.11 33.45,55.37 41.41,55.37 44.84,58.81 46.61,58.81 47.62,59.82 47.62,60.86 49.02,62.25 51.63,62.25 52.07,61.81 65.27,61.81 67.22,63.76 68.87,63.76 69.5,64.4 70.9,64.4 71.15,64.65 72.57,64.65 75.73,67.81 81.98,67.81 86.73,72.56 86.73,75.48 89.69,78.43 90.88,78.43 92.57,80.13 94.69,80.13 108.58,94.01 108.58,98.68 109.6,99.69 109.6,105.51 v1(108.81,106.3)
  LAY6 w0.125: v1(23.36,114.93) 22.73,114.3 22.73,94.26 22.98,94.01 22.98,87.88 22.6,87.51 22.6,85.98 22.7,85.88 22.7,84.37 23.25,83.83 23.25,82.06 24.82,80.49 24.82,75.67 24.35,75.2 24.35,70.68 23.49,69.82 23.49,65.23 25.42,63.3 25.42,57.59 24.51,56.67 v1(24.51,55.62)
DG_DEV_DIS_N: length 11.4
  TOP w0.1: R7B26.2 90.66,247.9 89.94,248.62 89.94,250.16 89.66,250.44 ; EU7A3.2 92.28,256.28 91.9,255.9 91.56,255.9 91.05,255.4 91.05,254.56 89.78,253.29 R7B10.2 90.29,252.73 90.29,252.09 90.17,251.97 90.17,251.31 89.66,250.8 89.66,250.44 ; 89.66,250.44 R7B22.2
DG_GPIO0: length 6.1
  TOP w0.089: 160.27,263.2 160.93,263.86 U5A2.W1
  TOP w0.1: 160.27,263.2 159.5,262.43 159.2,262.13 R5A50.1 158.36,261.62 156.84,261.62 R5A49.1
DG_GPIO1: length 6.3
  TOP w0.089: 160,263.22 160.87,264.09 161.54,264.09 U5A2.W2
  TOP w0.1: 160,263.22 159.42,262.63 156.84,262.63 R5A48.1
DG_GRN1_LED_N: length 5.8
  TOP w0.1: R7A2.2 C7A2.2 64.88,283.71 J7A1.17
DG_GRN_LED_N: length 12.4
  TOP w0.1: J7A1.20 87.63,282.59 87.63,278 C7A3.1 R7A3.2
DG_GRN_LED_P: length 5.9
  TOP w0.1: R7A1.2 C7A1.1 68.05,285.37 J7A1.18
DG_JTAG_EN: length 2.5
  TOP w0.1: J7A2.2 94.36,272.79 R7A5.2
DG_JTAG_TCK: length 9.9
  TOP w0.1: J7A2.5 99.69,268.22 98.29,268.22 97.53,267.46 R6A72.2 97.53,265.56 97.71,265.38 97.71,263.83 97.26,263.38 EU7A3.29
DG_JTAG_TDI: length 28.1
  TOP w0.1: J7A2.1 97.79,269.11 99.82,269.11 100.2,269.49 100.2,270.51 100.96,271.27 102.36,271.27 102.74,270.89 102.74,270.25 104.04,268.96 104.04,263.37 104.19,263.22 104.19,259.38 103.5,258.7 103.12,258.7 102.92,258.49 101.52,258.49 101.21,258.19 R6B2.2 100.83,257.68 100.33,257.68 99.05,258.96 98.43,258.96 98.29,259.09 EU7A3.19
DG_JTAG_TDO: length 22
  TOP w0.1: J7A2.7 104.26,263.46 104.41,263.31 104.41,256.63 103.43,255.65 102.74,255.65 R6B6.1 102.1,256.16 R6B5.2 100.81,257.45 100.23,257.45 98.99,258.69 EU7A3.18
DG_JTAG_TMS: length 30.4
  TOP w0.1: J7A2.3 100.71,271.78 102.87,271.78 103.34,271.3 104.95,271.3 105.28,270.98 105.28,269.44 104.49,268.65 104.49,263.56 104.64,263.41 104.64,256.54 103.53,255.42 102.13,255.42 R6B9.2 100.27,257.23 100.14,257.23 99.07,258.29 EU7A3.17
DG_LINK_1000: length 15.6
  TOP w0.1: R7A4.1 90.29,273.56 90.93,273.56 v1(91.56,272.92) ; EU7A3.32 95.88,264 96.67,264.79 96.67,266.32 94.99,268 94.99,271.78 v1(94.61,272.16)
  BOTTOM w0.1: v1(91.56,272.92) 93.85,272.92 v1(94.61,272.16)
DG_LINK_2500: length 17.3
  TOP w0.1: v1(95.37,272.16) 95.22,272.01 95.22,268.09 96.9,266.41 96.9,264.69 96.28,264.08 EU7A3.31 ; v1(91.31,274.4) 91.31,275.08 90.55,275.84 R7A3.1
  BOTTOM w0.1: v1(91.31,274.4) 93.14,274.4 v1(95.37,272.16)
DG_LINK_ACT: length 52.9
  TOP w0.1: EU7A3.30 96.68,263.79 97.18,264.29 v1(97.25,264.29) ; R7A2.1 62.99,283.72 v1(62.99,275.33)
  LAY5 w0.125: v1(67.69,267.59) 67.98,267.89 79.76,267.89 81.71,265.94 88.86,265.94 89.13,266.21 91.94,266.21 92.58,265.57 92.58,264.54 93.33,263.79 96.76,263.79 v1(97.25,264.29)
  BOTTOM w0.1: v1(62.99,275.33) 63.88,275.33 67.69,271.52 v1(67.69,267.59)
DG_NVM_CLK: length 10
  TOP w0.1: R6B16.2 99.47,249.84 R6B35.1 99.79,249.3 99.31,249.3 99.06,249.05 99.06,247.39 95.79,244.13 U6B2.6
DG_NVM_CS_N: length 14.4
  TOP w0.1: R6B23.2 104.21,241.68 104.11,241.57 U6B1.1 99.92,241.57 98.93,242.57 98.93,245.87 100.45,247.39 101.21,247.39 101.72,247.9 R7B84.1 101.09,248.78 R6B17.2
DG_NVM_HOLD_N: length 3.6
  TOP w0.1: R7B39.2 92.58,243.33 93.07,242.84 U6B1.7
DG_NVM_SI: length 131.4
  TOP w0.1: v1(27.81,273.94) 26.03,275.72 13.42,275.72 8.34,280.8 4.31,280.8 3.68,280.16 3.68,275.84 J9A2.1 ; U6B1.5 93.61,245.38 92.45,244.22 R7B34.2 ; R7B34.2 92.45,245.74 v1(93.09,245.74) ; R7B34.2 90.8,244.22 90.29,244.73 90.29,245.74 R6B15.2
  LAY5 w0.125: v1(93.09,245.74) 92.39,246.44 87.41,246.44 84.95,248.9 83.3,248.9 82.64,249.55 79.83,249.55 79.5,249.88 79.5,250.42 79.08,250.84 72.74,250.84 71.07,252.51 70.63,252.51 69.26,253.88 66.73,253.88 65.71,252.86 52.04,252.86 51.68,252.51 51.2,252.51 50.6,253.1 48.96,253.1 48.11,252.25 42.63,252.25 42.03,252.86 41.27,252.86 39.87,251.46 35.81,251.46 34.79,252.47 34.79,256.41 32.38,258.82 32.38,270.13 28.57,273.94 v1(27.81,273.94)
DG_NVM_SI_PD: length 3.5
  TOP w0.1: 7.49,274.57 7.74,274.57 9.65,272.67 R9A3.1
DG_NVM_SO: length 13.1
  TOP w0.1: R6B18.2 R6B19.2 102.61,248.03 100.96,246.38 100.2,246.38 99.56,245.74 99.56,244.85 100.33,244.09 100.33,243.08 100.56,242.84 U6B1.2 103.65,242.84 103.75,242.95 R6B22.2
DG_NVM_WP_N: length 3.4
  TOP w0.1: U6B1.3 102.72,244.11 102.99,243.84 104.26,243.84 R6B21.2
DG_PG: length 7.6
  TOP w0.1: R7B9.2 87.75,254.51 87.75,255.78 88.41,256.44 91.51,256.44 EU7A3.1
DG_SDP0: length 34.6
  TOP w0.1: J7A2.8 105.28,272.79 106.29,271.78 107.56,271.78 107.82,271.52 107.82,269.37 107.56,269.11 106.29,269.11 105.44,268.26 105.44,263.95 105.59,263.8 105.59,255.92 103.06,253.4 101.69,253.4 101.6,253.49 100.83,253.49 R6B11.2 100.33,254.13 100.99,254.79 100.99,255.11 99.82,256.28 99.69,256.28 98.67,257.3 98.42,257.3 98.23,257.49 EU7A3.15
DG_SPI_CLK: length 23.7
  TOP w0.1: EU7A3.35 94.68,263.85 94.71,263.88 94.71,264.91 95.36,265.56 v1(95.37,265.56) ; R6B16.1 98.67,249.81 99.21,250.34 v1(99.21,250.77)
  BOTTOM w0.1: v1(95.37,265.56) 95.5,265.43 96.52,265.43 96.79,265.16 96.79,263.8 97.55,263.03 98.57,263.03 98.74,262.86 99.25,262.86 99.94,262.16 99.94,260.07 99,259.13 99,257.08 100.7,255.39 100.7,254.37 99.69,253.36 99.69,251.26 v1(99.21,250.77)
DG_SPI_CS_N: length 29.5
  TOP w0.1: EU7A3.37 93.88,263.81 94.26,264.19 94.26,265.25 v1(94.13,265.38) ; v1(100.07,250.77) 100.53,250.32 100.83,250.32 101.09,250.06 R6B17.1
  BOTTOM w0.1: v1(94.13,265.38) 94.56,265.81 94.97,265.81 95.53,266.37 99.46,266.37 100.63,265.2 100.63,264.49 100.65,264.47 100.65,259.78 99.71,258.84 99.71,257.37 102.08,254.99 102.08,250.57 101.83,250.32 100.53,250.32 v1(100.07,250.77)
DG_SPI_MISO: length 25.2
  TOP w0.1: R6B18.1 101.85,249.86 100.93,250.77 v1(100.83,250.77) ; EU7A3.36 94.28,263.87 94.49,264.07 94.49,265.01 94.86,265.38 94.86,265.7 95.23,266.06 95.75,266.06 95.91,265.91 v1(96.16,265.91)
  BOTTOM w0.1: v1(100.83,250.77) 101.83,251.77 101.83,254.92 99.48,257.28 99.48,258.93 100.42,259.87 100.42,262.36 99.45,263.33 98.94,263.33 98.76,263.51 98.29,263.51 97.79,264.02 97.79,264.99 96.87,265.91 v1(96.16,265.91)
DG_SPI_MOSI: length 31.3
  TOP w0.1: EU7A3.34 95.08,264.07 94.94,264.21 94.94,264.82 95.09,264.97 v1(95.93,264.97) ; R6B15.1 91.46,246.28 96.23,246.28 98.55,248.6 v1(98.55,248.66)
  BOTTOM w0.1: v1(95.93,264.97) 95.93,264.74 96.31,264.36 96.31,263.6 97.35,262.56 98.37,262.56 98.55,262.38 99.06,262.38 99.47,261.97 99.47,260.26 98.53,259.32 98.53,256.03 98.26,255.76 98.26,255.66 97.91,255.32 97.91,253.85 99.18,252.58 99.18,252.01 98.67,251.5 98.67,248.79 v1(98.55,248.66)
DG_TEST_PWR_GOOD: length 1.7
  TOP w0.1: U5A2.W5 163.12,263.83 162.76,263.48 v2(162.76,263.49)
  BOTTOM w0.1: R5L19.1 162.76,262.59 v2(162.76,263.49)
DG_TRSTN: length 34.7
  TOP w0.1: EU7A3.16 98.21,257.89 98.29,257.81 98.88,257.81 99.94,256.75 100.07,256.75 101.47,255.36 101.47,254.38 101.98,253.87 102.87,253.87 105.12,256.12 105.12,263.6 104.96,263.75 104.96,268.45 105.81,269.3 105.81,271.12 105.15,271.78 103.63,271.78 102.99,272.41 102.99,273.43 102.61,273.81 100.2,273.81 J7A2.4
DG_VQPS: length 5.9
  TOP w0.2: v1(94.1,254.45) 94.3,254.45 94.68,254.83 94.68,255.27 94.58,255.37 94.58,256.19 94.68,256.28 EU7A3.8
  BOTTOM w0.2: R7M1.1 95.88,255.9 94.43,254.45 v1(94.1,254.45)
DG_YLW_LED_N: length 11.7
  TOP w0.1: R7A4.2 C7A4.2 87.12,276.73 87.12,280.56 J7A1.19
DGPU_PWR_EN_N: length 197.6
  LAY5 w0.125: v1(99.84,214.88) 99.06,215.67 99.06,216.53 99.44,216.91 101.98,216.91 103.69,215.2 115.58,215.2 125.24,224.87 129.97,224.87 130.74,225.64 134.6,225.64 136.6,223.65 137.41,223.65 138.43,224.66 139.7,224.66 140.71,225.68 143.38,225.68 143.78,226.08 J5B2.A19 ; v1(117.37,189.1) 118.35,188.12 118.35,185.17 119.44,184.08 119.44,173.27 117.09,170.92 117.09,164 116.46,163.37 116.46,161.7 117.98,160.17 117.98,152 116.33,150.34 116.33,139.72 118.61,137.43 118.61,130.87 110.38,122.64 110.38,121.41 104.14,115.16 104.14,112.52 103.63,112.01 103.63,111 102.25,109.62 102.25,109.37 100.56,107.67 95.42,107.67 v1(95.4,107.69)
  LAY6 w0.125: v1(117.37,189.1) 117.37,189.71 115.93,191.15 114.08,191.15 99.84,205.39 v1(99.84,214.88)
  BOTTOM w0.1: R7T11.2 95.25,116.46 95.75,115.95 95.75,114.63 96.39,113.99 96.39,108.33 95.75,107.69 v1(95.4,107.69)
DGPU_PWR_OK: length 157.1
  TOP w0.1: v1(120.21,210.18) 120.21,210.39 120.43,210.6 125.62,210.6 126.77,209.46 129.19,209.46 130.3,210.56 R5C23.2 ; R7F26.2 R7F37.1 92.73,115.84 92.73,112.87 91.44,111.58 91.44,110.12 91.12,109.81 91.12,107.08 v1(91.11,107.06)
  LAY5 w0.125: v1(120.21,210.18) 120.21,208.48 119.25,207.52 119.25,186.43 121.51,184.17 121.51,174.97 122.42,174.06 122.42,168.02 119.76,165.35 119.76,161.05 120.08,160.72 120.08,159.71 119.76,159.38 119.76,155.45 120.01,155.19 120.01,152.5 118.04,150.52 118.04,144.85 121.53,141.35 121.53,138.48 122.55,137.46 122.55,136.78 119.63,133.86 119.63,129.92 111.62,121.92 111.62,121.41 106.8,116.59 106.8,114.5 106.43,114.13 106.43,111.45 103.79,108.81 102.59,108.81 100.46,106.69 92.04,106.69 91.66,107.06 v1(91.11,107.06)
DGPU_SEL_N: length 159.4
  TOP w0.1: v1(119.5,210.18) 120.33,211.01 125.71,211.01 126.91,209.81 128.66,209.81 130.17,211.33 137.03,211.33 137.54,211.83 137.54,213.9 J5B2.B30 ; R7F28.2 95.25,116.46 95.73,115.97 95.73,114.64 95.38,114.29 94.96,114.29 92.42,111.76 92.42,110.46 92.64,110.24 v1(92.64,107.95)
  LAY5 w0.125: v1(92.64,107.95) 93.4,107.19 100.43,107.19 102.43,109.19 103.64,109.19 104.64,110.19 104.64,111.89 105.53,112.77 105.53,115.85 110.63,120.95 110.63,122.13 119.25,130.75 119.25,137.15 116.58,139.82 116.58,150.24 118.23,151.89 118.23,160.28 116.71,161.8 116.71,163.27 117.34,163.9 117.34,170.81 119.69,173.17 119.69,184.59 118.87,185.41 118.87,207.67 119.5,208.3 v1(119.5,210.18)
DIMM0_CHA_VREF_CA: length 33.4
  TOP w0.254: C1E13.1 283.38,133.43 283.38,132.61 283.56,132.43 283.56,130.84 282.7,129.98 282.7,128.93 281.92,128.15 281.92,126.27 J1E5.146
  TOP w0.38: R1F9.1 286.51,116.58 290.7,120.78 R1F4.2 290.95,121.79 ; 290.95,121.79 290.32,121.79 284.35,127.76 284.35,133.44 C1E14.1 C1E13.1 ; 290.95,121.79 v1(291.71,121.79)
DIMM0_CHB_VREF_CA: length 14.1
  TOP w0.305: J1F2.146 281.94,108.06 C1F8.1 282.57,106.93 283.97,106.93 284.48,106.42 C1F9.1 R1F33.1 285.36,106.63 285.67,106.93 289.56,106.93 290.32,106.17 R1F31.2
  TOP w0.38: R1F31.2 290.95,105.28 291.08,105.15 v1(291.97,105.15)
DIMM1_CHA_VREF_CA: length 14.8
  TOP w0.38: v1(291.97,111.5) 291.84,111.63 291.46,111.63 291.21,111.89 290.95,111.89 R1F16.2 289.17,113.16 286.63,115.7 284.48,115.7 283.59,116.58 C1F3.1 C1F2.1 281.94,116.59 281.94,118.45 J1F1.146
DIMM1_CHB_VREF_CA: length 21.6
  TOP w0.38: 290.95,102.23 R1F42.2 290.7,101.22 286.51,97.03 C1G2.1 C1G1.1 281.68,98.44 J1F3.146 ; 290.95,102.23 v1(291.97,102.23) ; 290.95,102.23 290.44,102.23 286.38,106.3 R1F33.2
DIS_LATCH_BFCN: length 3.9
  TOP w0.1: Q8C13.1 43.48,197.86 43.68,197.66 43.68,196.72 43.53,196.56 Q8C13.3 42.92,196.09 42.79,195.96 R8D3.2
DISP_UTIL: length 1.9
  TOP w0.1: R1B5.1 290.6,250.16 U1B2.4
DISP_UTIL_CPU: length 99.1
  TOP w0.089: 245.99,191.9 244.78,191.9 242.23,189.34 241.77,189.34 241.59,189.52 239.74,189.52 239.59,189.36 239.03,189.36 J3D1.L37
  TOP w0.1: R1B9.2 R1B10.1 288.29,247.91 v1(288.93,247.91) 289.67,247.91 289.95,247.63 U1B2.2 ; v1(258.57,198.37) 258,197.8 255.87,197.8 249.97,191.9 245.99,191.9
  BOTTOM w0.1: v1(288.93,247.91) 290.06,246.77 290.06,245.24 290.57,244.73 290.57,242.82 294.25,239.14 294.25,229.74 293.46,228.95 293.46,225.08 292.18,223.8 289.08,223.8 280.28,215.01 275.9,215.01 264.79,203.89 263.71,203.89 258.57,198.74 v1(258.57,198.37)
DMI_IT_MR_0_DN: length 123.1
  TOP w0.089: J3D1.AD5 v1(207.61,178.37)
  TOP w0.1: U6E1.C33 113.05,142.59 113.73,143.26 114.38,143.26 114.65,143 119.28,143 122.89,139.39 123.68,139.39 124.65,138.41 124.65,137.71 v1(124.87,137.5)
  BOTTOM w0.089: 205.61,179.07 205.72,179.07 205.74,179.05 206.21,179.05 206.45,178.81 206.88,178.81 207.32,178.37 v1(207.61,178.37)
  BOTTOM w0.1: v1(124.87,137.5) 124.66,137.28 124.66,136.45 125.78,135.33 137.02,135.33 142.25,140.56 147.16,140.56 154.29,147.7 154.29,148.48 157.73,151.92 157.73,153.02 160.11,155.39 161.05,155.39 166.06,160.4 166.06,165.31 168.72,167.97 169.74,167.97 171.18,169.4 J4R1.15 172.57,169.14 178.87,169.14 180.45,170.73 185.84,170.73 192.88,177.77 195.74,177.77 197.24,179.27 202.23,179.27 202.48,179.52 203.28,179.52 203.74,179.07 205.61,179.07
DMI_IT_MR_0_DP: length 123.2
  TOP w0.089: v1(206.69,178.37) 206.38,178.39 206.26,178.29 J3D1.AD4
  TOP w0.1: v1(124.04,137.5) 124.25,137.5 124.45,137.7 124.45,138.33 123.59,139.19 122.81,139.19 119.2,142.8 114.56,142.8 114.3,143.06 113.82,143.06 113.46,142.71 U6E1.B33
  BOTTOM w0.089: v1(206.69,178.37) 206.62,178.37 206.37,178.62 206.24,178.75 206.13,178.86 205.61,178.86 205.61,178.86 205.61,178.87
  BOTTOM w0.1: v1(124.04,137.5) 124.26,137.5 124.46,137.3 124.46,136.37 125.7,135.13 137.1,135.13 142.34,140.36 147.24,140.36 154.49,147.61 154.49,148.4 157.93,151.84 157.93,152.94 160.19,155.19 161.14,155.19 166.26,160.32 166.26,165.23 168.8,167.77 169.82,167.77 171.1,169.05 171.26,169.2 171.8,169.2 171.94,169.07 171.94,168.5 172.04,168.4 J4R1.13 172.61,168.4 172.71,168.5 172.71,168.84 172.82,168.94 178.95,168.94 180.54,170.53 185.92,170.53 192.96,177.57 195.82,177.57 197.32,179.07 202.31,179.07 202.56,179.32 203.2,179.32 203.65,178.87 205.61,178.87
DMI_IT_MR_1_DN: length 126.6
  TOP w0.089: J3D1.AD8 v1(210.35,178.43)
  TOP w0.1: U6E1.C32 112.94,143.3 113.39,143.74 114.71,143.74 114.95,143.51 119.65,143.51 123.05,140.11 123.95,140.11 126.31,137.75 126.31,137.29 126.43,137.16 126.43,136.92 v1(126.65,136.7)
  BOTTOM w0.089: v1(210.35,178.43) 209.93,178.86 209.19,178.86 209.06,178.98 207.42,178.98 207.01,179.4 206.56,179.4 206.37,179.58 205.76,179.58 205.75,179.58 205.74,179.58
  BOTTOM w0.1: v1(126.65,136.7) 126.43,136.49 126.43,136.2 126.62,136.01 136.74,136.01 142.02,141.3 146.93,141.3 153.59,147.96 153.59,148.75 157.02,152.18 157.02,153.35 159.88,156.21 160.9,156.21 165.38,160.69 165.38,165.59 167.81,168.02 167.81,169.28 168.08,169.54 168.77,169.54 J4R1.14 170.31,169.68 171.02,170.39 172.7,170.39 173.22,169.88 178.65,169.88 180.18,171.41 185.56,171.41 192.64,178.48 195.49,178.48 196.86,179.86 202.05,179.86 202.22,180.03 203.53,180.03 203.99,179.58 205.74,179.58
DMI_IT_MR_1_DP: length 126.7
  TOP w0.089: J3D1.AD7 v1(209.44,178.43)
  TOP w0.1: U6E1.B32 113.57,143.54 114.63,143.54 114.86,143.31 119.57,143.31 122.97,139.91 123.87,139.91 126.11,137.67 126.11,137.2 126.23,137.08 126.23,136.9 126.03,136.7 v1(125.82,136.7)
  BOTTOM w0.089: 205.74,179.38 205.82,179.38 205.84,179.39 206.29,179.39 206.48,179.21 206.93,179.21 207.34,178.8 208.98,178.8 209.34,178.43 v1(209.44,178.43)
  BOTTOM w0.1: 205.74,179.38 203.9,179.38 203.45,179.83 202.31,179.83 202.14,179.66 196.95,179.66 195.57,178.28 192.72,178.28 185.64,171.21 180.26,171.21 178.73,169.68 173.13,169.68 172.62,170.19 171.1,170.19 170.39,169.48 169.4,169.48 169.3,169.38 169.3,168.78 169.2,168.68 J4R1.12 168.63,168.68 168.53,168.78 168.53,169.22 168.41,169.34 168.16,169.34 168.01,169.19 168.01,167.94 165.58,165.5 165.58,160.6 160.99,156.01 159.97,156.01 157.22,153.26 157.22,152.09 153.79,148.66 153.79,147.88 147.01,141.1 142.1,141.1 136.82,135.81 126.53,135.81 126.23,136.11 126.23,136.5 126.03,136.7 v1(125.82,136.7)
DMI_IT_MR_2_DN: length 127.7
  TOP w0.089: J3D1.AC6 v1(208.52,179.41)
  TOP w0.1: v1(128.42,137.74) 128.18,137.98 128.18,138.41 125.73,140.87 123.01,140.87 119.86,144.02 115.19,144.02 114.91,144.3 113.2,144.3 U6E1.C31
  BOTTOM w0.089: v1(208.52,179.41) 208.25,179.41 207.83,179.84 207.34,179.84 207.07,180.11 206.5,180.11 206.5,180.11
  BOTTOM w0.1: v1(128.42,137.74) 128.21,137.53 128.21,137.09 128.52,136.78 132.46,136.78 132.83,137.16 136.84,137.16 141.76,142.07 146.74,142.07 152.91,148.24 152.91,149.03 155.65,151.77 155.65,155.56 156,155.9 157.9,155.9 159.71,157.71 161.44,157.71 164.69,160.97 164.69,165.92 166.87,168.1 166.87,169.83 167.82,170.77 167.82,171.96 168.35,172.5 168.72,172.5 J4R1.20 170.09,172.68 171.36,171.41 173.2,171.41 173.92,172.13 185.31,172.13 192.49,179.3 195.17,179.3 196.3,180.43 201.73,180.43 201.84,180.54 203.79,180.54 204.22,180.11 206.5,180.11
DMI_IT_MR_2_DP: length 127.7
  TOP w0.089: J3D1.AC5 v1(207.61,179.41)
  TOP w0.1: v1(127.6,137.74) 127.81,137.74 127.98,137.92 127.98,138.33 125.64,140.67 122.93,140.67 119.78,143.82 115.11,143.82 114.83,144.1 113.28,144.1 113.25,144.06 U6E1.B31
  BOTTOM w0.089: v1(207.61,179.41) 207.31,179.41 207.09,179.63 207.09,179.83 206.99,179.93 206.62,179.93 206.61,179.91 206.5,179.91
  BOTTOM w0.1: 206.5,179.91 204.13,179.91 203.7,180.34 201.93,180.34 201.82,180.23 196.38,180.23 195.26,179.1 192.57,179.1 185.39,171.93 174.01,171.93 173.29,171.21 171.27,171.21 170,172.48 169.4,172.48 169.3,172.38 169.3,171.78 169.2,171.68 J4R1.18 168.76,171.68 168.66,171.78 168.66,172.2 168.56,172.3 168.43,172.3 168.02,171.88 168.02,170.69 167.07,169.74 167.07,168.02 164.89,165.84 164.89,160.88 161.52,157.51 159.79,157.51 157.98,155.7 156.08,155.7 155.85,155.47 155.85,151.69 153.11,148.94 153.11,148.16 146.82,141.87 141.84,141.87 136.93,136.96 132.92,136.96 132.54,136.58 128.44,136.58 128.01,137 128.01,137.54 127.81,137.74 v1(127.6,137.74)
DMI_IT_MR_3_DN: length 128.9
  TOP w0.089: J3D1.AB7 v1(209.44,180.26)
  TOP w0.1: v1(129.96,137.26) 130.22,137.52 130.22,137.84 130.09,137.97 129.35,137.97 125.98,141.35 122.96,141.35 119.99,144.32 115.34,144.32 115.14,144.52 113.22,144.52 U6E1.C29
  BOTTOM w0.089: 200.3,180.98 200.32,180.98 200.33,180.97 203.83,180.97 204.2,181.34 204.78,181.34 205.47,180.65 207.05,180.65 207.38,180.98 208.72,180.98 v1(209.44,180.26)
  BOTTOM w0.1: 200.3,180.98 195.71,180.98 194.81,180.09 192.31,180.09 185.07,172.85 180.61,172.85 179.18,174.28 176.45,174.28 175.13,172.95 J4R1.19 171.9,172.54 171.37,172.54 170.36,173.55 168.44,173.55 165.66,170.77 165.66,167.98 164.01,166.32 164.01,162.26 160.76,159.02 160,159.02 158.15,157.17 155.97,157.17 154.98,156.17 154.98,152.06 152.22,149.31 152.22,148.52 146.54,142.84 141.51,142.84 136.64,137.96 130.54,137.96 130.32,137.75 130.32,137.62 v1(129.96,137.26)
DMI_IT_MR_3_DP: length 128.9
  TOP w0.089: v1(208.52,180.31) 208.06,179.85 J3D1.AB6
  TOP w0.1: U6E1.B29 113.56,144.72 115.22,144.72 115.42,144.52 120.07,144.52 123.04,141.55 126.06,141.55 129.44,138.17 130.17,138.17 130.42,137.92 130.42,137.62 v1(130.79,137.26)
  BOTTOM w0.089: v1(208.52,180.31) 208.6,180.24 208.81,180.24 208.91,180.34 208.91,180.52 208.64,180.79 207.46,180.79 207.13,180.47 205.39,180.47 204.71,181.15 204.27,181.15 203.91,180.78 200.38,180.78 200.38,180.78 200.33,180.78 200.32,180.78 200.3,180.78
  BOTTOM w0.1: 200.3,180.78 195.79,180.78 194.9,179.89 192.39,179.89 185.15,172.65 180.52,172.65 179.09,174.08 176.54,174.08 175.21,172.75 172.81,172.75 172.71,172.65 172.71,172.2 172.46,171.95 J4R1.17 171.92,172.34 171.29,172.34 170.27,173.35 168.52,173.35 165.86,170.69 165.86,167.89 164.21,166.24 164.21,162.18 160.85,158.82 160.08,158.82 158.24,156.97 156.06,156.97 155.18,156.09 155.18,151.98 152.42,149.22 152.42,148.44 146.62,142.64 141.59,142.64 136.72,137.76 130.62,137.76 130.52,137.66 130.52,137.52 v1(130.79,137.26)
DMI_MT_IR_0_DN: length 123.8
  TOP w0.1: v1(181.69,165.75) 181.39,165.45 181.39,165.31 181.49,165.21 182.58,165.21 184.55,167.18 184.55,169.06 192.97,177.49 201.67,177.49 202.5,176.65 203.22,176.65 203.25,176.68 203.88,176.68 204.17,176.39 J3D1.AF2 ; v1(109.36,141.49) U6E1.K34
  BOTTOM w0.089: 111.63,139.75 111.61,139.75 111.61,139.76 111.55,139.76 111.54,139.76 111.3,139.76 110.98,140.08 110.72,140.08 110.22,140.59 109.83,140.59 109.47,140.95 109.47,141.38 v1(109.36,141.49)
  BOTTOM w0.1: 111.63,139.75 112.46,139.75 119.83,132.38 138.32,132.38 143.1,137.16 148.71,137.16 153.41,141.86 154.17,141.86 157.24,144.92 157.24,147.28 159.69,149.73 160.4,149.73 161.54,150.87 161.54,151.73 170.81,161 170.81,161.38 171.63,162.2 172.13,162.2 172.31,162.03 J4R1.3 172.71,162.25 174.06,162.25 175.83,164.02 179.53,164.02 180.08,164.57 180.87,164.57 181.38,165.08 181.38,165.44 v1(181.69,165.75)
DMI_MT_IR_0_DP: length 123.8
  TOP w0.1: J3D1.AF1 203.58,176.06 203.87,176.06 203.97,176.16 203.97,176.3 203.79,176.48 203.33,176.48 203.31,176.45 202.42,176.45 201.59,177.29 193.06,177.29 184.75,168.98 184.75,167.09 182.66,165.01 181.41,165.01 181.19,165.22 181.19,165.44 v1(180.89,165.75) ; U6E1.J35 v1(110.1,141.25)
  BOTTOM w0.089: 111.63,139.95 111.37,139.95 111.06,140.27 110.8,140.27 110.29,140.78 109.91,140.78 109.67,141.02 109.67,141.17 109.75,141.25 v1(110.1,141.25)
  BOTTOM w0.1: 111.63,139.95 112.55,139.95 119.92,132.58 138.24,132.58 143.02,137.36 148.63,137.36 153.33,142.06 154.09,142.06 157.04,145 157.04,147.37 159.6,149.93 160.31,149.93 161.34,150.96 161.34,151.82 170.61,161.09 170.61,161.47 171.54,162.4 172.16,162.4 172.31,162.55 J4R1.5 172.71,162.45 173.97,162.45 175.74,164.22 179.44,164.22 180,164.77 180.79,164.77 181.18,165.17 181.18,165.45 v1(180.89,165.75)
DMI_MT_IR_1_DN: length 123.9
  TOP w0.1: U6E1.G33 110.78,142.33 110.95,142.16 v1(110.95,141.98) ; v1(181.88,167.02) 181.57,166.71 181.57,166.58 181.73,166.43 182.74,166.43 183.85,167.55 183.85,169.33 192.69,178.16 201.92,178.16 202.33,177.74 203.13,177.74 203.27,177.6 204.78,177.6 J3D1.AE3
  BOTTOM w0.089: 112.39,140.46 112.37,140.46 112.37,140.47 112.31,140.47 112.3,140.47 112.09,140.47 111.52,141.05 111.3,141.05 111,141.34 111,141.92 v1(110.95,141.98)
  BOTTOM w0.1: 112.39,140.46 112.88,140.46 120.27,133.07 138.02,133.07 142.87,137.92 147.7,137.92 156.56,146.79 156.56,147.57 159.48,150.49 160.14,150.49 160.81,151.17 160.81,151.98 168.32,159.48 168.32,162.4 168.44,162.52 168.74,162.52 168.91,162.36 J4R1.2 169.2,162.41 170.57,162.41 171.53,163.37 174.2,163.37 177.09,166.27 181.36,166.27 181.57,166.49 181.57,166.71 v1(181.88,167.02)
DMI_MT_IR_1_DP: length 123.9
  TOP w0.1: v1(181.08,167.02) 181.37,166.73 181.37,166.5 181.64,166.23 182.82,166.23 184.05,167.46 184.05,169.24 192.77,177.96 201.83,177.96 202.25,177.54 203.05,177.54 203.18,177.4 204.7,177.4 204.92,177.18 204.92,177.01 204.82,176.91 204.56,176.91 J3D1.AE2 ; U6E1.F34 111.5,142.4 111.5,141.79 111.6,141.69 v1(111.61,141.69)
  BOTTOM w0.089: 112.39,140.66 112.17,140.66 111.6,141.23 111.37,141.23 111.19,141.42 111.19,141.55 111.33,141.69 v1(111.61,141.69)
  BOTTOM w0.1: v1(181.08,167.02) 181.37,166.73 181.37,166.57 181.27,166.47 177.01,166.47 174.11,163.57 171.45,163.57 170.48,162.61 169.42,162.61 J4R1.4 168.91,162.82 168.81,162.72 168.36,162.72 168.12,162.48 168.12,159.56 160.61,152.06 160.61,151.25 160.06,150.69 159.4,150.69 156.36,147.66 156.36,146.87 147.61,138.12 142.79,138.12 137.94,133.27 120.35,133.27 112.96,140.66 112.39,140.66
DMI_MT_IR_2_DN: length 126.4
  TOP w0.1: v1(109.32,142.88) 109.32,143.43 ; v1(181.93,168.42) 181.63,168.12 181.63,167.86 181.76,167.73 182.58,167.73 183.11,168.25 183.11,169.67 185.34,171.91 185.58,171.91 192.48,178.81 202.06,178.81 202.47,178.4 203.08,178.4 203.2,178.51 203.87,178.51 J3D1.AD2
  BOTTOM w0.1: v1(109.32,142.88) 109.32,142.64 109.78,142.18 110.25,142.18 110.51,142.44 111.42,142.44 111.76,142.11 112.23,142.11 120.59,133.76 137.72,133.76 142.57,138.61 147.42,138.61 155.86,147.05 155.86,147.84 159.33,151.3 159.33,152.34 160.32,153.34 161.21,153.34 167.64,159.76 167.64,162.69 168.02,163.07 168.02,165.02 168.52,165.53 168.81,165.53 168.91,165.43 J4R1.8 169.31,165.53 170.06,165.53 171.03,164.56 174.15,164.56 177.08,167.49 181.24,167.49 181.62,167.86 181.62,168.1 v1(181.93,168.42)
DMI_MT_IR_2_DP: length 126.4
  TOP w0.1: v1(181.13,168.42) 181.43,168.12 181.43,167.77 181.68,167.53 182.67,167.53 183.31,168.17 183.31,169.59 185.43,171.71 185.66,171.71 192.57,178.61 201.98,178.61 202.39,178.2 203.17,178.2 203.28,178.31 203.79,178.31 204,178.1 204,177.92 203.9,177.82 203.65,177.82 J3D1.AD1 ; v1(110.06,142.62) U6E1.J32
  BOTTOM w0.1: v1(110.06,142.62) 109.83,142.85 109.83,143.04 109.95,143.16 110.15,143.16 110.66,142.64 111.51,142.64 111.84,142.31 112.32,142.31 120.67,133.96 137.64,133.96 142.49,138.81 147.34,138.81 155.66,147.13 155.66,147.92 159.13,151.39 159.13,152.43 160.24,153.54 161.13,153.54 167.44,159.85 167.44,162.77 167.82,163.15 167.82,165.1 168.44,165.73 168.81,165.73 168.91,165.83 J4R1.10 169.31,165.73 170.14,165.73 171.11,164.76 174.07,164.76 177,167.69 181.16,167.69 181.42,167.94 181.42,168.14 v1(181.13,168.42)
DMI_MT_IR_3_DN: length 129.3
  TOP w0.1: U6E1.G30 110.8,143.7 v1(110.61,143.51) ; v1(181.89,169.69) 181.89,169.53 181.32,168.96 180.12,168.96 179.66,169.42 179.66,170.41 181.89,172.64 185.42,172.64 192.27,179.49 201.81,179.49 201.9,179.58 203.53,179.58 203.67,179.43 204.54,179.43 205.08,178.89 J3D1.AC3
  BOTTOM w0.1: v1(181.89,169.69) 181.65,169.45 181.65,169.2 181.41,168.96 179.92,168.96 179.12,168.16 175.68,168.16 173.25,165.73 172.64,165.73 J4R1.7 172.01,165.7 171.4,165.7 170.35,166.75 168.75,166.75 166.95,164.95 166.95,160.04 161.39,154.48 160.45,154.48 158.62,152.65 158.62,151.56 155.18,148.12 155.18,147.33 147.22,139.38 142.33,139.38 137.39,134.44 120.95,134.44 112.67,142.72 111.75,142.72 111.62,142.85 111.27,142.85 v1(110.61,143.51)
DMI_MT_IR_3_DP: length 129.2
  TOP w0.1: v1(111.37,143.38) 111.32,143.38 111,143.7 111,144.05 111.14,144.18 111.14,144.58 111.25,144.7 111.61,144.7 111.76,144.55 111.76,144.21 111.65,144.1 U6E1.F30 ; v1(181.09,169.69) 181.33,169.69 181.43,169.59 181.43,169.35 181.24,169.16 180.2,169.16 179.86,169.5 179.86,170.33 181.97,172.44 185.5,172.44 192.35,179.29 201.89,179.29 201.98,179.38 203.44,179.38 203.59,179.23 204.46,179.23 204.56,179.12 204.56,178.98 204.47,178.89 J3D1.AC2
  BOTTOM w0.1: v1(181.09,169.69) 181.31,169.69 181.45,169.55 181.45,169.29 181.33,169.16 179.84,169.16 179.04,168.36 175.6,168.36 173.17,165.93 172.78,165.93 J4R1.9 172.31,166 172.21,165.9 171.48,165.9 170.44,166.95 168.67,166.95 167.71,165.99 166.75,165.03 166.75,160.12 161.31,154.68 160.37,154.68 158.42,152.74 158.42,151.64 154.98,148.2 154.98,147.42 147.14,139.58 142.24,139.58 137.3,134.64 121.03,134.64 112.75,142.92 111.83,142.92 111.71,143.05 111.47,143.05 111.37,143.15 v1(111.37,143.38)
DMIC0_SDW4_CLK_HDR: length 10.5
  TOP w0.1: R8B4.2 26.03,257.3 26.28,257.05 C8B3.1 25.9,256.67 25.67,256.43 25.67,255.52 25.42,255.27 24.76,255.27 24.25,254.76 21.08,254.76 19.68,253.36 J9B1.1
DMIC0_SDW4_DATA_HDR: length 4.9
  TOP w0.1: R8B11.2 C8B5.1 24.89,253.36 23.11,253.36 J9B1.2
DMIC1_SDW3_CLK_HDR: length 9
  TOP w0.1: R8B17.2 25.65,242.95 25.27,243.33 22.09,243.33 21.08,244.35 21.08,246 J9B1.5
DMIC1_SDW3_DATA_HDR: length 2.8
  TOP w0.1: J9B1.6 22.47,247.65 R8B13.2
DMIC_CLK_0: length 9.2
  TOP w0.089: U6E1.BD16 92.72,151.49 92.34,151.49 92.23,151.38 90.26,151.38 90.17,151.48 88.78,151.48 88.25,152 87.06,152 86.92,152.14
  TOP w0.1: R7E18.1 84.7,152.53 86.54,152.53 86.92,152.14
DMIC_CLK_1: length 8.1
  TOP w0.089: v1(95.19,152.13) U6E1.AW15
  BOTTOM w0.089: 92.83,152.73 93.27,152.73 93.6,152.4 93.98,152.4 94.33,152.05 94.69,152.05 94.77,152.13 v1(95.19,152.13)
  BOTTOM w0.1: R7R16.1 90.04,153.8 91.11,152.73 92.83,152.73
DMIC_DATA_0: length 8.2
  TOP w0.089: U6E1.BF15 91.91,151.62 91.87,151.57 90.34,151.57 90.24,151.67 88.86,151.67 88.33,152.19 87.15,152.19 86.56,152.78 86.36,152.78
  TOP w0.1: R7E17.1 85.21,152.78 86.36,152.78
DMIC_DATA_1: length 9.2
  TOP w0.089: U6E1.AV16 v1(95.93,151.89)
  BOTTOM w0.089: v1(95.93,151.89) 95.56,151.89 95.37,151.7 95,151.7 94.85,151.86 94.25,151.86 93.96,152.14 93.57,152.14 93.19,151.76 92.73,151.76
  BOTTOM w0.1: 92.73,151.76 91.18,151.76 89.91,153.03 R7R19.1
DPSRC_TBT_HPD: length 2.6
  TOP w0.1: U5A2.R5 v2(163.44,265.45)
  BOTTOM w0.089: 162.29,266.06 162.57,265.78 U5A2.R5 v2(163.44,265.45)
  BOTTOM w0.1: R5L8.1 162.05,266.31 162.29,266.06
DPWROK_IC: length 4.8
  TOP w0.1: C8D7.1 R8D25.1 R8D31.2 R8D38.2 43.3,183.01 43.24,182.95 Q8D10.3
DRAM_PWROK_RR: length 2.7
  TOP w0.1: Q8C13.5 46.46,197.21 R8C76.1 R8C73.2
DRAM_RESET_N: length 30.2
  TOP w0.089: 90.87,132.08 91.07,132.08 93.68,134.69 93.68,135.14 93.64,135.18 93.64,135.74 U6E1.BB46
  TOP w0.1: R7F30.1 74.67,118.24 74.67,119.51 R7F16.2 75.21,120.05 75.21,122.88 78.32,125.98 80.53,125.98 83.05,128.5 87.12,128.5 90.69,132.08 90.87,132.08
DRVEN: length 231.8
  TOP w0.2: v1(288.54,169.67) 288.54,173.1 286.13,175.51 286.13,176.78 v1(285.75,177.16) 289.9,177.16 291.26,178.53 291.26,190.66 288.01,193.91 282.13,193.91 277.55,198.49 277.55,208.67 286.89,218.01 286.89,219.36 288.34,220.81 288.34,226.78 289.54,227.98 289.54,230.43 288.9,231.06 v1(287.78,231.06) 286.93,231.06 286.28,230.41 EU1B1.48 ; R2B12.1 269.36,246.63 v1(269.36,246.89) 269.49,247.01 280.67,247.01 281.53,246.15 281.53,245.69 v1(282.11,245.11)
  LAY5 w0.2: v1(187.07,245.74) 188.08,245.74 188.72,245.11 190.5,245.11 190.88,245.49 192.27,245.49 193.09,244.67 195.11,244.67 195.49,245.05 199.99,245.05 v1(200.55,245.62) 201.04,245.62 201.93,246.51 206.12,246.51 207.26,245.36 209.67,245.36 v1(210.05,245.74) 210.43,245.74 211.2,244.98 214.24,244.98 214.88,245.62 215.64,245.62 216.78,244.47 217.9,244.47 218.77,245.34 223.49,245.34 v1(223.77,245.62) 224.4,245.62 225.29,246.51 228.98,246.51 230.12,245.36 233.04,245.36 v1(233.42,245.74) 233.8,245.36 238.88,245.36 239.64,244.6 241.42,244.6 242.18,245.36 246.76,245.36 v1(247.01,245.62) 247.26,245.36 247.69,245.36 248.65,246.32 251.39,246.32 252.41,245.31 256.23,245.31 v1(256.66,245.74) 261.74,245.74 262.89,246.89 v1(269.36,246.89)
  LAY6 w0.2: v1(287.78,231.06) 288.8,232.09 288.8,235.19 287.27,236.73 287.27,238.38 285.49,240.16 285.49,242.23 282.62,245.11 v1(282.11,245.11)
  BOTTOM w0.2: R1P4.1 283.84,167.64 286.76,167.64 288.54,169.42 v1(288.54,169.67) ; v1(256.66,245.74) R2M6.1 R2M7.1 ; v1(247.01,245.62) 247.01,246.18 246.43,246.76 R2M4.1 ; R3M21.1 R3M19.1 v1(233.42,245.74) ; v1(285.75,177.16) 283.46,179.45 283.46,181.99 284.37,182.9 R1P1.1 ; R3M22.1 R3M20.1 v1(210.05,245.74) ; R4M12.1 199.97,246.89 200.4,246.45 200.4,245.77 v1(200.55,245.62) ; R3M16.1 223.08,246.76 223.77,246.07 v1(223.77,245.62) ; R4M15.1 R4M14.1 v1(187.07,245.74)
DSW_LED_DRV: length 3.1
  TOP w0.203: DS8H6.2 56.51,44.7 56.26,44.96 55.63,44.96 55.12,45.46 55.11,45.46 54.86,45.72 EU8H1.12
DSW_PWROK: length 12.7
  TOP w0.1: U6E1.AW41 v1(94.52,138.87)
  BOTTOM w0.1: v1(94.52,138.87) 94.16,138.87 93.65,138.36 93.24,138.36 92.9,138.02 91.67,138.02 90.95,137.31 90.95,136.45 90.38,135.88 90.38,135.38 88.86,133.86 87.37,133.86 C7R2.1 R7R58.2
DSWPG_PIN1: length 3.9
  TOP w0.1: R8D26.2 47.11,186.05 47.11,187.2 C8D6.1 47.75,187.83 Q8D9.1
DSWPG_PIN3: length 8.3
  TOP w0.1: R8D33.2 49.91,185.16 50.29,185.55 50.29,186.56 50.6,186.88 Q8D9.3 51.43,188.09 52.32,188.97 52.32,190.37 52.13,190.56 U8D1.2
DSWPG_PIN4: length 2.4
  TOP w0.1: U8D1.4 49.52,191.51 50.16,192.15 R8D8.1
DUMMY_LOAD_G: length 15
  TOP w0.508: 229.74,75.82 218.31,75.82 218.31,77.72 219.2,78.61 Q3G2.6
EC_5VDUAL_MONITOR: length 7.3
  TOP w0.1: R6J9.1 R6J2.2 117.34,22.35 117.34,17.05 J6J2.44
EC_12VS_MONITOR: length 5.8
  TOP w0.1: J6J2.62 120.47,13.5 121.15,12.83 121.15,10.16 R6J28.2 R6J17.1
EC_DS3: length 191.9
  TOP w0.1: R5J21.1 137.54,7.75 v1(137.41,7.62) ; v1(22.32,88.77) 22.32,89.23 23.22,90.12 U8F6.75 ; J6J2.61 v1(119.96,14.68)
  LAY3 w0.1: v1(22.32,88.77) 23.74,87.35 23.74,85.98 23.18,85.41 23.18,84.61 20.34,81.78 20.34,69.67 19.05,68.37 19.05,47.62 21.08,45.59 21.84,45.59 22.09,45.34 22.09,43.81 23.26,42.64 23.26,36.11 26.49,32.89 29.94,32.89 35.27,27.56 46.86,27.56 47.11,27.81 50.67,27.81 50.92,27.56 53.87,27.56 57.24,24.19 59.34,24.19 61.06,22.47 62.22,22.47 62.7,21.99 64.68,21.99 64.92,21.75 75.64,21.75 75.99,22.1 81.07,22.1 81.99,23.02 88.14,23.02 88.87,22.28 97.4,22.28 98,21.68 99.17,21.68 99.89,22.4 101.08,22.4 103.65,19.84 109.57,19.84 111.37,18.04 112.52,18.04 112.9,17.65 112.9,16.64 114.42,15.11 119.53,15.11 v1(119.96,14.68)
  LAY6 w0.125: v1(119.96,14.68) 120.65,15.37 128.85,15.37 129.8,14.41 129.8,12.79 131.57,11.02 134.64,11.02 135,10.67 135,10.03 v1(137.41,7.62)
EC_EEPROM_WP: length 3.7
  BOTTOM w0.1: R7L1.2 R8L5.1 57.91,265.81
EC_FAN_PWR_DISABLE_N: length 634.3
  TOP w0.1: J6J2.74 v1(122.5,19.51) ; R1E46.1 v1(296.79,138.56) ; U8F6.119 32.35,101.09 31.87,100.61 v1(31.87,100.38)
  LAY3 w0.1: v1(115.49,31.88) 114.12,33.25 111.88,33.25 110.74,32.1 102.97,32.1 101.28,33.79 67.66,33.79 67.42,34.03 64.84,34.03 61.32,37.55 54.88,37.55 51.89,40.54 46.72,40.54 46.07,41.19 45.65,41.19 44.57,40.1 42.97,40.1 42.31,40.77 39.7,40.77 38.37,42.1 38.37,43.31 37.33,44.35 37.33,45.31 33.58,49.06 31.32,49.06 30.48,49.91 29.41,49.91 28.65,50.67 28.65,55.09 27.98,55.76 27.98,60.33 30.17,62.52 30.17,65.46 31.69,66.98 31.69,69.08 32.48,69.87 32.48,70.63 33.94,72.08 33.94,89.25 32.99,90.2 32.99,99.85 32.46,100.38 v1(31.87,100.38)
  LAY5 w0.125: v1(33.52,24.13) 33.92,23.73 39.02,23.73 39.41,23.34 46.66,23.34 47.13,22.87 50.05,22.87 51.94,24.76 61.59,24.76 62.06,24.29 66.38,24.29 67.1,25.02 84.71,25.02 87.13,22.6 87.88,22.6 88.77,21.72 98.93,21.72 99.69,22.48 101.21,22.48 101.47,22.23 106.27,22.23 107.67,23.62 109.45,23.62 110.97,25.14 121.66,25.14 122.68,24.13 124.96,24.13 125.98,25.14 129.48,25.14 131.32,26.98 133.05,26.98 136.93,30.86 149.35,30.86 163.26,44.77 165.99,44.77 168.28,47.06 182.18,47.06 185.39,50.27 192.74,50.27 193.33,50.86 194.9,50.86 197.33,53.28 197.33,54.11 198.25,55.03 198.25,57.87 198.94,58.56 200.97,58.56 201.44,59.03 210.99,59.03 213.76,56.26 216.69,56.26 218.05,54.89 218.05,53.9 223.05,48.9 231.63,48.9 233.37,50.64 235.01,50.64 237.2,52.83 250.08,52.83 252.13,54.88 262.06,54.88 264.08,56.9 268.83,56.9 270.38,58.45 273.48,58.45 279.98,64.95 281.54,64.95 284.35,67.76 287.87,67.76 289.83,69.72 289.83,70.49 295.91,76.56 295.91,81.26 298.05,83.4 298.05,122.62 295.2,125.46 295.2,128.75 297.3,130.86 297.3,138.05 v1(296.79,138.56)
  LAY6 w0.125: v1(31.87,100.38) 31.29,100.38 30.48,99.57 30.48,94.36 30.98,93.85 30.98,92.91 31.62,92.28 31.62,89.79 30.75,88.92 30.75,80.76 30.69,80.69 30.69,76.15 32.8,74.03 32.8,72.46 32.12,71.79 32.12,69.23 31.35,68.45 31.35,66.91 32.8,65.46 32.8,59.22 32.51,58.93 32.51,57.91 32.68,57.74 32.68,54.44 32.89,54.23 32.89,51.68 32.38,51.17 32.38,48.13 30.84,46.59 30.84,43.08 30.2,42.44 30.2,40.02 30.59,39.64 30.59,37.42 31.87,36.14 31.87,33.27 33.27,31.88 33.27,24.38 v1(33.52,24.13)
  LAY8 w0.1: v1(122.5,19.51) 122.8,19.81 122.8,21.33 122.3,21.84 122.3,25.53 124.58,27.81 127.5,27.81 128.65,28.95 128.65,31.4 126.9,33.15 118.11,33.15 116.84,31.88 v1(115.49,31.88)
EC_GP102_CR_STRAP: length 204.6
  TOP w0.1: R5J14.2 146.43,8.13 148.39,8.13 148.85,7.67 150.42,7.67 151.04,8.3 151.04,9.5 152.37,10.83 152.37,11.78 151.76,12.38 v1(151.76,12.95) ; R9G15.2 19.05,88.52 20.42,89.89 U8F6.68 20.42,92.3 21.61,93.5 v1(21.99,93.5)
  LAY3 w0.1: v1(151.76,12.95) 152.24,13.43 152.24,27.4 146.42,33.22 121.23,33.22 118.16,36.29 108.46,36.29 107.61,37.14 103.34,37.14 102.31,38.17 93.12,38.17 91.81,36.86 90.17,36.86 89.75,36.44 87.81,36.44 87.22,37.04 76.21,37.04 75.05,35.87 72.33,35.87 v1(72,36.19)
  LAY8 w0.1: v1(72,36.19) 67.81,40.38 67.81,40.64 66.44,42.01 61.43,42.01 55.98,47.46 55.98,47.91 54.65,49.23 54.65,51.51 53.81,52.35 53.81,53.31 51.72,55.4 51.72,56.29 48.92,59.09 48.92,60.22 46.05,63.09 42.51,63.09 37.41,68.19 37.41,77.06 36.09,78.39 31.78,78.39 27.58,82.59 27.58,87.41 23.26,91.73 23.26,92.23 v1(21.99,93.5)
EC_M.2_SSD_PLN_D_N: length 2
  TOP w0.1: R8H52.1 36.95,41.81 CR8H3.2
EC_M.2_SSD_PLN_N: length 221.6
  TOP w0.1: v1(150.87,10.92) 150.74,10.92 150.59,10.77 150.59,8.61 150.11,8.13 149.35,8.13 148.97,8.51 R5J16.2 ; CR8H3.1 34.67,40.64 v1(33.52,39.5) ; U8F6.72 22.02,92.02 21.99,92.05 v1(21.99,92.07)
  LAY3 w0.1: v1(150.87,10.92) 150.87,11.17 151.63,11.94 152.01,11.94 152.47,12.39 152.47,27.49 146.51,33.45 121.32,33.45 118.26,36.51 108.55,36.51 107.7,37.37 103.43,37.37 102.41,38.39 93.02,38.39 91.71,37.08 90.08,37.08 89.66,36.67 87.91,36.67 87.31,37.26 76.12,37.26 74.95,36.1 72.84,36.1 72.23,36.7 69.21,36.7 66.32,39.6 60.26,39.6 59.43,40.42 55.69,40.42 53.22,42.9 51.05,42.9 49.93,44.02 47.92,44.02 47.75,44.19 42.41,44.19 41.6,43.38 40.97,43.38 v1(40.51,42.92)
  LAY5 w0.125: v1(33.52,39.5) 31.24,39.5 28.21,42.52 23.52,42.52 21.71,44.32 v1(20.57,44.32)
  LAY6 w0.125: v1(20.57,44.32) 20.57,48.39 21.25,49.06 21.25,51.46 22.2,52.42 22.2,57.05 21.25,58.01 21.25,65.77 20.7,66.31 20.7,70.49 20.42,70.78 20.42,76.73 22.74,79.06 22.74,83.62 21.46,84.91 21.46,86.87 20.88,87.45 20.88,90.96 v1(21.99,92.07)
  BOTTOM w0.1: v1(33.52,39.5) 35.68,41.65 38.1,41.65 39.37,42.92 v1(40.51,42.92)
EC_PCH_SPI_OE_N: length 287.9
  TOP w0.1: v1(25.14,99.44) 23.59,97.89 U8F6.50 ; R5J12.2 v1(144.14,8.63) ; J6J2.132 v1(132.42,15.95)
  LAY3 w0.1: v1(132.42,15.95) 131.71,15.24 123.95,15.24 122.68,13.97 118.77,13.97 118.23,13.43 117.95,13.43 117.18,12.67 113.45,12.67 113.16,12.96 113.16,13.33 112.39,14.1 112.01,14.1 111.63,14.48 111.63,14.86 111.25,15.24 110.41,15.24 107.29,18.36 106.1,18.36 105.53,17.79 99.97,17.79 98.45,19.31 88.02,19.31 87.63,18.92 85.59,18.92 84.71,19.81 84.39,19.81 83.64,20.55 81.86,20.55 81.12,19.81 72.52,19.81 71.97,19.25 65.08,19.25 63.99,20.34 62.02,20.34 61.54,20.82 60.33,20.82 59.2,21.94 58.51,21.94 58.19,22.26 56.83,22.26 55.62,23.47 54.13,23.47 53.56,22.9 32.59,22.9 28.44,27.05 27.61,27.05 23.16,31.51 23.16,33.03 21.78,34.41 21.08,34.41 20.6,34.9 20.6,38.48 19.05,40.03 19.05,43.43 18.16,44.32 15.24,44.32 14.03,45.53 14.03,49.59 11.81,51.8 11.81,58.23 15.17,61.58 15.17,71.18 18.08,74.09 18.08,82.82 20.1,84.83 20.1,93.14 25.14,98.19 v1(25.14,99.44)
  LAY6 w0.125: v1(144.14,8.63) 141.85,8.63 139.57,10.92 139.57,12.19 135.81,15.95 v1(132.42,15.95)
  BOTTOM w0.1: R7U32.1 69.21,87.25 66.03,84.07 57.91,84.07 57.29,83.46 39.22,83.46 38.1,84.58 28.82,84.58 27.79,85.62 27.79,90.19 27.17,90.8 27.17,94.29 25.14,96.32 v1(25.14,99.44)
EC_SHD_CS_AIC_N: length 167
  TOP w0.1: J6J2.164 v1(137.5,16.97)
  LAY3 w0.1: v1(137.5,16.97) 136.8,17.67 136.03,17.67 134.64,19.05 128.65,19.05 127.47,17.87 122.02,17.87 121.83,17.68 117.54,17.68 116.3,18.92 114.8,18.92 114.3,19.43 114.3,19.7 113.58,20.41 111.33,20.41 110.25,21.49 104.33,21.49 101.76,24.05 98.36,24.05 98.24,23.93 89.56,23.93 88.82,24.67 85.41,24.67 84.94,25.13 81.77,25.13 80.39,23.75 75.31,23.75 74.96,23.4 67.37,23.4 66.83,23.94 64.07,23.94 63.47,24.54 62.36,24.54 59.6,27.3 57.39,27.3 53.48,31.21 52.08,31.21 50.58,32.71 46.2,32.71 45.97,32.48 37.51,32.48 34.54,35.45 31.6,35.45 29.15,37.9 29.15,40.84 26.94,43.05 25.01,43.05 24.91,43.15 24.91,45.06 22.47,47.5 22.47,48.28 21.55,49.2 21.55,57.45 20.7,58.31 20.7,63.89 23.11,66.31 23.11,74.42 v1(20.95,76.58)
  BOTTOM w0.1: v1(20.95,76.58) 20.06,76.58 R9U13.1
EC_SHD_CS_N: length 38.1
  TOP w0.1: R9F14.2 19.3,108.96 21.22,107.05 U8F6.27 21.22,104.41 20.7,103.88 v1(20.32,103.88)
  BOTTOM w0.1: v1(20.32,103.88) 20.32,103.64 19.62,102.95 19.62,97.08 16.41,93.87 16.41,92.74 14.35,90.68 14.35,82.68 18.16,78.87 R9U14.1
EC_SHD_CS_N_R: length 48.2
  TOP w0.1: R9F11.1 v1(19.3,111.38) ; v1(18.92,78.36) 18.92,80.9 20.95,82.93 22.6,82.93 23.11,83.44 v1(25.58,83.44)
  BOTTOM w0.1: v1(18.92,78.36) 18.86,78.3 18.86,78.16 19.05,77.98 R9U13.2 ; v1(19.3,111.38) 19.3,110.13 20.81,108.62 22.29,108.62 24.65,106.26 24.65,94.36 25.01,94 25.01,89.78 25.78,89.02 25.78,83.64 v1(25.58,83.44) R9U8.1
EC_SHD_IO0: length 39.7
  TOP w0.1: U8F6.28 20.82,104.64 20.57,104.39 19.81,104.39 v1(19.3,103.88)
  BOTTOM w0.1: v1(19.3,103.88) 18.92,103.5 18.92,101.09 15.33,97.5 15.33,93.95 11.74,90.36 11.74,83.26 16.76,78.25 16.76,74.68 R9U18.1
EC_SHD_IO0_AIC: length 163.2
  TOP w0.1: J6J2.148 v1(134.96,16.97)
  LAY3 w0.1: v1(134.96,16.97) 134.28,17.65 130.72,17.65 129.45,16.38 120.3,16.38 119.7,16.98 117.25,16.98 116.01,18.22 113.74,18.22 112.97,18.99 111.77,18.99 109.96,20.79 104.04,20.79 101.48,23.35 99.5,23.35 98.78,22.63 98.4,22.63 97.79,23.23 89.27,23.23 88.53,23.97 85.12,23.97 84.65,24.43 82.06,24.43 80.68,23.05 75.6,23.05 75.25,22.7 67.08,22.7 66.54,23.24 63.78,23.24 63.18,23.84 62.07,23.84 59.31,26.6 56.17,26.6 53.6,29.18 52.26,29.18 51.09,30.35 47.15,30.35 46.86,30.06 34.95,30.06 31.18,33.84 29.06,33.84 27.83,35.07 26.3,35.07 25.11,36.26 25.11,39.95 24.21,40.84 24.21,43.04 23.04,44.21 23.04,45.73 21.71,47.06 21.71,47.88 20,49.59 20,67.98 21.29,69.28 21.29,70.38 21.89,70.97 21.89,72.21 20.95,73.15 v1(20.95,73.28)
  BOTTOM w0.1: R9U17.1 v1(20.95,73.28)
EC_SHD_IO0_R: length 10.6
  TOP w0.1: v1(20.95,74.04) 21.81,74.9 21.81,76.92 21.49,77.24 21.49,78.73 v1(21.25,78.97)
  BOTTOM w0.1: v1(21.25,78.97) 21.07,78.97 20.57,79.46 20.57,80.72 R9U11.1 ; R9U17.2 19.81,74.04 v1(20.95,74.04)
EC_SHD_IO1: length 37.3
  TOP w0.1: v1(20.32,104.9) 20.42,105 U8F6.29
  BOTTOM w0.1: v1(20.32,104.9) 19.81,104.39 19.81,103.63 19.27,103.09 19.27,97.22 16.06,94.01 16.06,93.15 12.09,89.18 12.09,83.41 17.11,78.39 17.11,75.85 R9U16.1
EC_SHD_IO1_AIC: length 165.1
  TOP w0.1: J6J2.156 v1(136.23,16.97)
  LAY3 w0.1: v1(21.71,74.04) 22.76,72.99 22.76,66.45 20.35,64.04 20.35,58.16 21.2,57.31 21.2,49.05 22.06,48.19 22.06,47.21 23.39,45.88 23.39,44.35 24.56,43.18 24.56,42.22 26.4,40.38 26.4,37.98 29.28,35.11 34.34,35.11 37.32,32.13 46.11,32.13 46.35,32.36 50.44,32.36 51.94,30.86 53.34,30.86 57.25,26.95 59.46,26.95 62.21,24.19 63.33,24.19 63.93,23.59 66.69,23.59 67.23,23.05 75.1,23.05 75.45,23.4 80.53,23.4 81.92,24.78 84.8,24.78 85.26,24.32 88.67,24.32 89.41,23.58 98.38,23.58 98.5,23.7 101.62,23.7 104.19,21.14 110.11,21.14 111.18,20.06 112.77,20.06 113.15,19.68 113.15,19.3 113.88,18.57 116.16,18.57 117.39,17.33 121.97,17.33 122.17,17.52 124.04,17.52 124.84,16.73 127.47,16.73 128.39,17.65 129.03,17.65 130.07,18.7 134.5,18.7 v1(136.23,16.97)
  BOTTOM w0.1: v1(21.71,74.04) 20.95,74.8 R9U15.1
EC_SHD_IO1_R: length 12.9
  TOP w0.1: v1(14.85,82.93) v1(13.33,82.93)
  BOTTOM w0.1: R9U6.1 15.06,83.13 v1(14.85,82.93) ; R9U15.2 17.46,76.39 17.46,78.8 v1(13.33,82.93)
