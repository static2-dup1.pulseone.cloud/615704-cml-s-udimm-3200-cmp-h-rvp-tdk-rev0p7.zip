# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VR_SVID_CLK: length 6.1
  TOP w0.1: R2B28.2 276.22,238.19 276.98,237.43 276.98,234.93 277.5,234.41 EU1B1.18
VR_SVID_CLK_R: length 371.4
  TOP w0.1: v1(162.68,236.3) 162.22,235.84 161.41,235.84 161.16,236.09 ; J1G5.3 296.73,65.66 R1H2.2 ; R2B28.1 276.22,240.41 277.01,241.2 v1(277.01,243.84)
  LAY6 w0.125: J1G5.3 297.21,67.15 297.21,78.97 300.27,82.03 300.27,117.03 292.4,124.9 292.4,137.59 293.25,138.44 293.25,140.84 293.46,141.05 293.46,157.95 293.25,158.16 293.25,164.08 292.48,164.85 292.48,172.75 294.51,174.78 294.51,178.6 293.25,179.85 293.25,192.47 291.71,194.02 291.71,195.58 287.92,199.37 287.92,212.23 291.5,215.81 293.64,215.81 294.31,216.47 294.31,217.49 296.24,219.42 296.24,237.08 290.76,242.56 287.64,242.56 283.7,246.51 279.67,246.51 v1(277.01,243.84)
  LAY8 w0.1: v1(162.68,236.3) 162.18,236.8 159.02,236.8 157.03,238.79 157.03,241.14 157.25,241.37 158.95,241.37 159.89,242.3 159.89,246.25 164.08,250.44 175.64,250.44 177.41,252.22 180.59,252.22 182.11,253.74 189.1,253.74 190.11,254.76 190.11,255.52 190.75,256.16 193.54,256.16 193.92,255.78 196.97,255.78 198.12,256.92 207.77,256.92 210.31,259.46 213.36,259.46 215.77,257.05 223.64,257.05 225.55,258.95 227.71,258.95 228.34,258.32 228.34,256.03 230.25,254.13 239.52,254.13 240.53,253.11 273.3,253.11 274.32,252.09 274.32,246.72 275.3,245.74 275.3,245.01 275.71,244.6 276.25,244.6 v1(277.01,243.84)
VR_SVID_DATA: length 7.7
  TOP w0.1: R2B26.2 274.44,238.76 276.09,237.11 276.09,234.82 277.31,233.61 EU1B1.20
VR_SVID_DATA_R: length 366.9
  TOP w0.1: R2B26.1 274.44,240.66 273.68,241.43 273.68,244.47 275.2,246 276.86,246 276.93,246.07 v1(276.98,246.07) ; J1G3.3 298.32,78.36 296.86,76.9 R1G5.2 ; v1(164.21,236.3) R5B87.2
  LAY6 w0.125: J1G3.3 298.7,79.05 301.27,81.62 301.27,117.44 293.62,125.09 293.62,129.03 294.13,129.54 294.13,135.51 293.67,135.96 293.67,136.96 294.46,137.74 294.46,158.42 294.25,158.63 294.25,164.5 293.75,165 293.75,172.6 295.51,174.36 295.51,179.01 294.25,180.27 294.25,192.89 292.71,194.44 292.71,196 288.92,199.79 288.92,211.82 291.91,214.81 294.06,214.81 295.37,216.13 295.37,217.14 297.24,219.01 297.24,237.52 291.2,243.56 288.05,243.56 284.11,247.51 278.87,247.51 277.49,246.12 277.03,246.12 v1(276.98,246.07)
  LAY8 w0.1: v1(276.98,246.07) 276.31,246.07 275.26,247.12 275.26,252.49 273.69,254.06 240.93,254.06 239.91,255.07 230.64,255.07 229.29,256.42 229.29,258.71 228.1,259.9 225.15,259.9 223.25,257.99 216.16,257.99 213.75,260.41 209.91,260.41 207.37,257.87 197.72,257.87 196.58,256.72 194.32,256.72 193.94,257.11 190.36,257.11 189.17,255.92 189.17,255.15 188.71,254.69 181.72,254.69 180.2,253.17 177.02,253.17 175.24,251.39 163.69,251.39 158.94,246.64 158.94,242.7 158.56,242.31 156.86,242.31 156.08,241.53 156.08,238.4 158.63,235.85 161.75,235.85 162.23,235.36 163.27,235.36 v1(164.21,236.3)
VR_TEMP_V_1P05_PCH_EC: length 7.7
  TOP w0.1: J6J2.37 115.95,14.47 115.95,13.71 115.57,13.33 115.31,13.33 114.8,12.83 114.8,11.3 114.04,10.54 R6J25.2 R6J24.2
VR_THERM_IN: length 196.4
  TOP w0.1: v1(31.87,99.68) 32.08,99.89 U8F6.116 34.85,99.89 35.47,99.27 36.55,99.27 37.11,98.71 37.11,98.08 37.97,97.21 37.97,96.01 R8G4.1 ; R6J25.1 114.04,8 v1(114.17,7.87)
  LAY3 w0.1: v1(111.5,30.61) 111.5,31.01 111.27,31.24 102.61,31.24 100.92,32.93 67.3,32.93 67.06,33.17 64.48,33.17 60.97,36.69 53.35,36.69 50.36,39.67 47.61,39.67 46.39,38.45 38.76,38.45 34.41,42.8 34.41,45.46 31.68,48.2 29.65,48.2 27.65,50.2 27.65,52.67 26.48,53.84 26.48,54.55 27.12,55.18 27.12,60.69 29.31,62.87 29.31,65.82 30.83,67.34 30.83,69.44 31.62,70.23 31.62,70.98 33.08,72.44 33.08,88.52 32.76,88.83 32.76,98.79 v1(31.87,99.68)
  LAY6 w0.125: v1(111.5,30.61) 111.5,30.45 108.2,27.15 108.2,25.78 108.45,25.53 108.45,23.9 106.02,21.46 105.26,21.46 103.62,19.83 103.62,8.74 104.44,7.93 108.02,7.93 109.72,6.22 111.05,6.22 112.39,7.57 113.86,7.57 v1(114.17,7.87)
VR_THERM_IN_R: length 348.2
  TOP w0.2: v1(40.13,95.5) R8G4.2 R8G6.2 C8G4.1 ; v1(226.69,238) RT8G1.1
  LAY3 w0.2: v1(33.4,146.94) 34.79,146.94 37.21,149.35 43.18,149.35 44.57,150.75 44.57,167.26 45.72,168.4 45.72,172.72 47.11,174.12 47.11,181.1 48,181.99 48.51,181.99 52.95,186.43 59.18,186.43 59.56,186.82 71.5,186.82 73.91,189.23 73.91,217.3 80.26,223.65 80.26,225.17 84.45,229.36 99.06,229.36 101.72,232.03 104.01,232.03 106.42,234.44 116.58,234.44 120.01,237.87 126.49,237.87 129.28,240.66 139.82,240.66 140.84,239.65 144.01,239.65 145.03,240.66 145.92,240.66 146.87,239.71 146.87,238.7 147.39,238.18 147.39,235.39 151.32,231.45 151.32,227.9 153.6,225.62 166.94,225.62 168.14,226.82 168.14,229.49 168.78,230.12 169.79,230.12 170.81,231.14 170.81,232.41 171.45,233.04 181.48,233.04 181.99,233.55 201.67,233.55 203.2,235.08 213.1,235.08 213.86,235.84 215.51,235.84 216.28,235.08 223.77,235.08 v1(226.69,238)
  LAY5 w0.2: v1(40.13,95.5) 39.58,96.05 39.58,100.07 39.2,100.46 39.2,104.98 40.22,106 40.22,108.22 38.22,110.22 38.22,113.14 39.08,114 39.08,121.62 34.88,125.81 34.88,128.44 33.85,129.48 33.85,130.74 33.14,131.44 32.63,131.44 31.96,132.11 31.96,135.55 29.97,137.55 29.97,140.46 33.4,143.89 v1(33.4,146.94)
VR_VCCSFR_OC_EN_R: length 334.4
  TOP w0.1: v1(48.13,187.2) 49.91,187.2 50.16,187.45 50.16,189.61 49.4,190.37 48.35,190.37 47.59,191.13 47.59,191.93 48.09,192.43 48.6,192.43 49.5,193.33 49.5,197.71 R8C72.2 50.16,199.13 51.05,200.02 51.43,200.02 52.19,200.79 R8C60.2 R8C58.2 v1(52.95,201.93) ; R8D96.2 46.99,175.77 v1(46.45,175.77)
  TOP w0.2: v1(177.73,212.85) 177.52,212.65 U4C1.2
  TOP w0.25: v1(160.4,214.5) C5C23.1 160.78,211.2 161.54,210.44 EU5C2.1
  LAY5 w0.125: v1(177.73,212.85) 175.44,215.14 166.24,215.14 165.6,214.5 v1(160.4,214.5) 160.4,213.74 159.89,213.23 155.31,213.23 151.7,209.61 151.7,203.64 150.24,202.18 150.24,199.77 152.52,197.48 152.52,195.96 151.51,194.94 151,194.94 150.62,194.56 150.62,192.91 150.24,192.53 150.24,191.01 150.36,190.88 150.87,190.88 151.25,190.5 151.25,180.21 150.23,179.19 150.23,167.64 148.84,166.24 148.84,164.87 146.52,162.56 144.27,162.56 143.25,163.57 140.46,163.57 139.57,164.46 138.7,164.46 138.1,165.07 138.1,194.54 137.84,194.8 137.84,210.23 129.39,218.68 129.39,221.76 128.27,222.89 125.03,222.89 116.1,213.95 99.73,213.95 98.55,215.13 98.55,219.22 97.3,220.47 88.47,220.47 82.93,226.02 82.93,229.59 81.13,231.39 72.95,231.39 68.13,236.21 67.33,236.21 64.92,238.63 64.34,238.63 63.07,239.9 61.67,239.9 61.33,240.24 61.33,242.93 60.88,243.38 59.51,243.38 58.42,244.47 57.27,244.47 v1(56.26,245.49) ; v1(46.45,175.77) 46.45,183.74 47.62,184.91 47.62,186.69 v1(48.13,187.2)
  BOTTOM w0.1: v1(52.95,201.93) 52.95,202.44 56.51,205.99 56.51,245.24 v1(56.26,245.49)
VR_VCCSFR_OC_PWRGD_R: length 3
  TOP w0.25: C5C27.1 R5C33.2 R5C25.1 164.59,208.91 164.06,209.44 EU5C2.6
VREF_ADC_SENSE_SMC: length 3.1
  TOP w0.1: EU8F1.8 22.22,118.87 R9F3.1 R9F5.2
VREG_5VDUAL_NCH: length 2.6
  TOP w0.508: C4G16.1 R4G15.2 193.92,81.02 EU4G2.4
VREG_5VDUAL_PCH_EC: length 8.5
  TOP w0.1: J6J2.125 v1(130.12,15.7) ; R6J13.1 v1(127.63,21.72)
  LAY8 w0.1: v1(130.12,15.7) 129.44,16.39 129.44,19.92 v1(127.63,21.72)
VREG_HD_ACT_LED_R: length 3
  TOP w0.38: CR9G4.1 12.82,69.59 R9G33.2
VREG_NGFF_NCH: length 22.6
  TOP w0.28: EU7B1.4 73.23,256.16 v1(72.87,256.16) ; 62.61,258.44 63.53,257.52 Q7B1.3 64.38,257.36 65.3,256.44 65.3,255.62 v1(65.4,255.52) 65.66,255.27 Q7B3.3
  TOP w0.38: EU7B2.4 72,258.53 72,260.6 v1(71.88,260.73) 71.62,260.98 C7A11.2
  LAY5 w0.5: v1(72.87,256.16) 71.12,256.16 70.48,255.52 v1(65.4,255.52)
  BOTTOM w0.38: v1(71.88,260.73) 72.13,260.48 72.13,256.89 v1(72.87,256.16)
VREG_NGFF_PCH: length 7.9
  TOP w0.28: v1(70.99,253.49) 70.99,253.01 70.61,252.63 69.94,252.63 69.59,252.98 C7B3.1 R7B8.2 ; Q7B4.4 v1(73.53,251.97)
  BOTTOM w0.5: v1(70.99,253.49) 70.99,252.98 72,251.97 v1(73.53,251.97)
VSW_TYPEC_HV: length 3.6
  TOP w0.2: L6A1.1 116.96,263.02
  TOP w0.5: 116.96,263.02 C6A36.2
VTT_EN: length 15.5
  TOP w0.1: R2G24.2 253.11,77.98 R2G19.2 252.22,79.5 v1(252.47,79.75) ; v1(262.89,76.1) R2G28.1
  BOTTOM w0.1: v1(262.89,76.1) 262.15,76.83 260.47,76.83 260.09,76.45 255.77,76.45 v1(252.47,79.75)
VTT_EN_L: length 1.5
  TOP w0.1: U2G2.5 251.38,77.27 251.84,77.72 R2G24.1
VTT_RAIL_SENSE: length 2.4
  TOP w0.203: R2G14.1 260.49,81.79 260.85,81.42 EU2G1.2
WAKE_SLTA_L: length 254.4
  TOP w0.1: R5B52.1 150.49,230 149.35,228.85 148.33,228.85 v1(147.57,228.09) ; 113.15,39.24 113.15,38.53 v1(113.03,38.4) ; v1(137.92,40) 137.54,39.62 137.54,31.62 138.17,30.99 J5J1.5
  LAY5 w0.125: v1(113.03,38.4) 115.46,38.4 115.65,38.22 120.07,38.22 120.84,38.99 126.01,38.99 126.23,39.21 131.94,39.21 132.17,38.99 136.9,38.99 v1(137.92,40)
  LAY6 w0.125: v1(137.92,40) 137.92,41.02 144.65,47.75 144.65,50.83 146.3,52.48 146.3,57.75 145.54,58.52 145.54,68.24 137.71,76.07 135,76.07 133.98,77.09 133.98,80.32 130.38,83.93 130.38,93.72 126.31,97.79 126.31,114.19 130.9,118.78 130.9,120.33 135,124.43 135,131.08 140.13,136.21 140.13,138.3 141.25,139.41 141.25,144.65 147.47,150.88 147.47,154.16 147.71,154.4 147.71,156.44 147.47,156.67 147.47,159.74 146.68,160.52 146.68,165.71 147.93,166.96 147.93,186.64 148.08,186.79 148.08,189.09 147.57,189.6 147.57,191.14 147.93,191.5 147.93,196.32 148.08,196.48 148.08,197.09 147.7,197.48 147.7,198.35 148.14,198.79 148.14,227.52 v1(147.57,228.09)
  BOTTOM w0.1: R5V8.2 v1(137.92,40)
WAKE_SLTA_PEG_L: length 14.7
  TOP w0.1: J5B2.B11 140.71,236.08 140.71,234.95 140.84,234.82 140.84,234.57 140.97,234.44 140.97,234.06 141.73,233.3 143.38,233.3 144.65,234.57 145.92,234.57 147.19,233.3 148.33,233.3 R5B52.2
WAKE_SLTB_L: length 51.5
  TOP w0.1: R6H3.2 v1(114.8,56.51) ; R5H13.2 v1(143.12,40) 142.62,40.51 139.44,40.51 139.31,40.38 139.31,39.11 138.17,37.97 J5J1.6
  BOTTOM w0.1: v1(114.8,56.51) 115.31,57.02 117.09,57.02 117.5,57.44 120.41,57.44 121.3,56.55 121.3,52.72 125.64,48.39 132.13,48.39 139.62,40.89 142.24,40.89 v1(143.12,40) R5H13.2
WAKE_SLTC_L: length 6
  TOP w0.1: J5J1.13 143.25,27.05 144.01,26.29 R5J4.2 R5J3.1
WAKE_SLTD_L: length 4.5
  TOP w0.1: R5H13.1 143.25,38.23 J5J1.14
WIFI_RF_KILL_N: length 294.1
  TOP w0.1: R7B42.2 82.55,243.33 84.45,245.24 85.09,245.24 85.34,245.49 v1(85.34,246.89) Q7B7.2 R7B31.2
  LAY5 w0.125: v1(85.34,246.89) 84.09,248.14 82.99,248.14 82.33,248.8 78.87,248.8 77.86,249.81 72.7,249.81 70.76,251.75 69.91,251.75 69.56,252.1 52.35,252.1 52,251.75 50.88,251.75 50.29,252.35 49.27,252.35 48.42,251.5 44.87,251.5 v1(44.19,250.82)
  LAY6 w0.125: J8H5.1 40.51,36.07 39.75,36.83 39.75,37.97 40,38.23 40,44.42 41.31,45.73 41.92,45.73 47.33,51.14 47.33,54.64 45.33,56.65 45.33,60.24 45.84,60.75 45.84,65.28 45.69,65.43 45.69,67.84 45.21,68.32 44.62,68.32 43.04,69.9 43.04,73.31 42.35,74 42.35,76.39 42.67,76.71 42.67,80.9 42.29,81.28 41.14,81.28 39.75,82.67 39.75,90.8 38.98,91.57 38.98,94.87 39.23,95.13 39.23,97.9 38.72,98.41 38.72,105.94 39.23,106.45 39.23,108.08 38.47,108.84 38.47,111.17 39.49,112.19 39.49,124.46 39.11,124.84 39.11,132.44 38.33,133.22 38.33,137.39 38.59,137.66 38.59,141.46 37.45,142.6 37.45,149.22 37.99,149.75 37.99,166.09 38.35,166.45 38.35,169.16 38.73,169.55 38.73,171.73 38.22,172.24 38.22,173.48 38.93,174.19 38.93,187.17 39.44,187.69 39.44,193.98 39.38,194.04 39.38,197.35 38.98,197.74 38.98,201.55 38.35,202.18 38.35,207.09 33.41,212.03 33.41,216.9 32.63,217.68 32.63,218.57 33.02,218.95 33.02,222.49 31.62,223.88 31.62,225.55 33.03,226.96 33.03,228.46 32,229.49 32,234.99 33.66,236.65 33.66,238.69 34.17,239.2 34.17,242.37 36.83,245.03 36.83,245.87 41.78,250.82 v1(44.19,250.82)
WIFI_RF_KILL_N_HDR: length 5.4
  TOP w0.1: R8H68.1 41.52,35.94 41.52,32.13 40.51,31.11
WIFI_RF_KILL_R_N: length 123.8
  TOP w0.089: v1(98.6,154.6) U6E1.AL9
  TOP w0.1: R7B31.1 89.4,246.51 96.13,246.51 97.25,247.62 97.25,248.82 98.01,249.59 98.01,250.16 98.14,250.29 98.47,250.29 98.67,250.49 98.67,251.33 99.06,251.71 99.78,251.71 100.21,251.29 102.11,251.29 103.06,250.34 103.06,247.04 v1(104.64,245.46)
  BOTTOM w0.089: 98.1,160.33 98.1,158.31 98.38,158.02 98.38,156.42 98.51,156.29 98.51,155.67 98.68,155.5 98.68,155.11 98.6,155.03 v1(98.6,154.6)
  BOTTOM w0.1: 98.1,160.33 98.1,170.32 96.04,172.38 96.04,183.33 96.8,184.09 96.8,185.62 99.47,188.29 99.47,189.97 97.4,192.04 97.4,203.16 97.94,203.71 97.94,210.7 100.33,213.08 100.33,217.93 99.98,218.28 99.98,220.92 102.81,223.75 102.81,229.94 106.76,233.89 106.76,240.54 105.53,241.77 105.53,244.57 v1(104.64,245.46)
WLAN_LED1: length 7.5
  TOP w0.1: 74.16,222.5 74.04,222.62 74.04,226.95 74.66,227.57 J7C1.6
WLAN_LED1_R: length 2.1
  TOP w0.5: CR7C1.1 77.34,221.23 R7C10.1
WLAN_LED2: length 12.1
  TOP w0.1: 74.16,220.72 73.27,221.61 73.27,228.24 75.1,230.07 J7C1.16
WLAN_LED2_R: length 3
  TOP w0.5: CR7C4.1 76.45,220.34 77.85,220.34 78.35,220.84 R7C11.1
WLAN_PERST0_N: length 2.8
  TOP w0.1: R7B48.1 78.64,239.9 77.82,239.07 J7C1.52
WLAN_PEWAKE_N: length 10.9
  TOP w0.1: R7B27.1 R7B28.2 71.24,247.27 71.62,246.89 72.03,246.89 72.13,246.79 72.13,240.16 71.8,239.82 J7C1.55
WLAN_RST_N: length 179.9
  TOP w0.1: R7B48.2 v1(80.89,239.9) ; v1(26.21,136.7) 27.55,135.36 R8E52.1 R8E58.2 R8E59.2
  LAY5 w0.125: v1(29.71,244.47) 31.62,246.38 32.63,246.38 33.78,247.52 44.61,247.52 45.69,246.43 52.21,246.43 52.56,246.78 52.56,247.49 53.21,248.14 53.49,248.14 53.84,248.5 66.59,248.5 67.43,247.65 68.55,247.65 70.86,245.34 70.86,244.35 70.99,244.22 71.62,244.22 72.13,243.71 72.13,243.08 72.89,242.31 77.34,242.31 79.76,239.9 v1(80.89,239.9)
  LAY6 w0.125: v1(29.71,244.47) 29.47,244.23 29.47,242.48 26.45,239.45 26.45,237.81 27.04,237.22 27.04,235.86 24.99,233.81 24.99,229.87 27.34,227.52 27.34,223.08 27.94,222.48 27.94,216.15 29.29,214.8 29.29,212.6 29.05,212.35 29.05,209.13 30.74,207.44 30.74,206.44 31.75,205.43 31.75,203.46 31.49,203.2 31.49,194.56 30.09,193.16 30.09,188.6 30.35,188.34 30.35,187.58 30.09,187.32 29.84,187.32 29.35,186.84 29.35,185.27 27.17,183.09 27.17,179.78 26.13,178.73 26.13,158.12 25.61,157.6 25.61,137.3 v1(26.21,136.7)
WLAN_RST_R_N: length 1.7
  TOP w0.25: R8E59.1 28.44,131.52 U8F1.4
XCLK_RBIAS: length 9.7
  TOP w0.088: 106.58,160.43 106.93,160.08 106.93,159.75 107.04,159.64 107.04,157.81 U6E1.T3
  TOP w0.1: 106.58,160.43 106.5,160.43 106.14,160.79 106.14,161.59 106.34,161.8 106.34,166.23 R6D65.2
XDP_BMP0_N: length 4
  TOP w0.1: J1C1.21 294.73,203.74 295.4,203.07 296.03,203.07 R1C79.2
XDP_BMP1_N: length 3.8
  TOP w0.1: R1C74.2 296.82,203.3 295.55,203.3 294.61,204.24 J1C1.23
XDP_BOOT_HALT_N_SYS_PWROK: length 9.8
  TOP w0.1: R1C36.2 299.84,213.87 299.84,213.84 299.74,213.74 299.08,213.74 298.83,213.49 297.43,213.49 C1C11.1 296.92,213.74 296.41,213.23 296.41,213.03 295.02,211.63 295.02,210.34 294.92,210.24 J1C1.47
XDP_FN0: length 3.7
  TOP w0.1: J6H2.9 110.58,42.89 110.23,42.54 109.72,42.54 R6H24.2
XDP_FN1: length 3.1
  TOP w0.1: J6H2.11 111.08,42.76 R6H25.2
XDP_FN2: length 3.1
  TOP w0.1: J6H2.15 112.08,42.61 R6H26.2
XDP_FN3: length 2.8
  TOP w0.1: J6H2.17 112.58,42.73 112.26,42.42 R6H27.2
XDP_FN4: length 3.7
  TOP w0.1: J6H2.27 115.08,42.82 114.8,42.54 114.3,42.54 R6H28.2
XDP_FN5: length 3.1
  TOP w0.1: J6H2.29 115.58,42.69 R6H29.2
XDP_FN6: length 3
  TOP w0.1: R6H30.2 115.69,42.04 116.58,42.92 J6H2.33
XDP_FN7: length 2.8
  TOP w0.1: J6H2.35 117.08,42.79 116.84,42.54 R6H31.2
XDP_FN8: length 2.8
  TOP w0.1: J6H2.10 110.58,51.59 R6H10.2
XDP_FN9: length 2.6
  TOP w0.1: R6H11.2 110.74,51.81 111.08,51.47 J6H2.12
XDP_FN10: length 2.6
  TOP w0.1: J6H2.16 112.08,52.12 R6H12.2
XDP_FN11: length 2.5
  TOP w0.1: J6H2.18 112.58,51.75 112.77,51.94 R6H18.1
XDP_FN12: length 2.5
  TOP w0.1: R6H14.2 114.8,51.69 115.08,51.41 J6H2.28
XDP_FN13: length 2.5
  TOP w0.1: J6H2.30 115.58,51.7 115.82,51.94 R6H15.2
XDP_FN14: length 2.5
  TOP w0.1: R6H16.2 116.84,51.81 116.58,51.56 J6H2.34
XDP_FN15: length 2.7
  TOP w0.1: R6H17.2 117.85,52.07 117.08,51.3 J6H2.36
XDP_FN_CLK1: length 2.6
  TOP w0.1: R6H9.2 109.08,52.08 J6H2.4
XDP_FN_CLK2: length 2.5
  TOP w0.1: J6H2.24 114.08,51.52 113.79,51.81 R6H13.2
XDP_HOOK2_EAR_N: length 21.5
  TOP w0.1: R1C38.2 296.92,212.87 v1(296.15,212.1) 296.02,211.96 296.02,210.64 295.12,209.74 J1C1.45 ; R1C94.2 298.45,198.63 v1(298.57,198.5)
  LAY6 w0.125: v1(296.15,212.1) 296.5,212.1 296.78,211.82 296.78,199.65 297.94,198.5 v1(298.57,198.5)
XDP_PM_RSMRSTN_VCCSTPWRGD: length 7.8
  TOP w0.1: J1C1.39 295.28,208.24 297.02,209.97 297.85,209.97 298.34,210.46 299.69,210.46 R1C46.2
XDP_PMODE_PLTRST_N: length 4
  TOP w0.1: J1C1.46 285.81,209.74 285.36,210.18 284.73,210.18 R1C44.2
XDP_POWER_BTN_N: length 6.7
  TOP w0.1: R1C43.2 C1C14.1 297.31,210.45 296.82,210.45 295.11,208.74 J1C1.41
XDP_PRDY_N: length 5.1
  TOP w0.1: J1C1.5 294.62,199.74 296.62,197.74 R1C97.2 R1C99.1
XDP_PREQ_N: length 6.2
  TOP w0.1: J1C1.3 294.61,199.24 295.4,198.45 295.4,197.48 R1C101.2 R1C102.1
XDP_PRESENT1_N: length 530.8
  TOP w0.1: J1C1.60 286.51,213.24 285.87,212.6 v1(285.87,211.45) ; v1(297.18,192.66) 297.18,192.84 297.81,193.47 R1D3.1 298.06,193.8 298.95,193.8 300.73,192.02 300.73,189.23 302.92,187.04 302.92,162.21 302,161.29 301.11,161.29 J1D4.1 ; C1D14.1 60.19,79.75 R7G18.1 60.57,78.36 60.57,77.6 60.75,77.42 60.75,73.99 58.59,71.83 55.67,71.83 v1(55.6,71.76)
  LAY5 w0.125: v1(298.57,156.34) 298.95,155.95 298.95,132.15 295.45,128.65 295.45,125.57 298.3,122.72 298.3,83.29 296.16,81.15 296.16,75.56 293.62,73.02 v1(293.11,73.02) ; v1(294.64,64.9) 294.25,64.9 292.85,63.49 288.93,63.49 285.16,59.71 283.2,59.71 280.86,57.37 280.86,55.51 275.68,50.33 273.62,50.33 273.36,50.59 254.21,50.59 251.74,48.13 234.41,48.13 232.67,46.4 220.05,46.4 216.4,50.04 216.4,51.82 214.47,53.75 212.72,53.75 211.05,55.42 202.86,55.42 201.54,54.1 201.54,53.67 194.73,46.86 185.92,46.86 183.61,44.54 170.69,44.54 153.72,27.58 150.53,27.58 149.84,26.89 148.35,26.89 147.39,27.85 138.18,27.85 136.27,25.93 136.27,21.84 132.08,17.65 127,17.65 126.87,17.78 121.79,17.78 120.53,19.04 117.84,19.04 117.22,18.41 110.44,18.41 109.62,17.59 107.01,17.59 105.35,15.93 87.17,15.93 83.62,19.49 83.62,20.25 83.16,20.71 80.48,20.71 79.58,19.81 77.13,19.81 76.22,20.72 69.23,20.72 68.32,19.81 68.32,18.14 63.89,13.71 56.64,13.71 54.22,16.13 v1(54.22,17.02)
  LAY6 w0.125: v1(295.55,210.82) 295.55,207.03 294.76,206.25 294.76,199.9 297,197.66 297,192.84 v1(297.18,192.66) ; v1(54.22,17.02) 53.97,17.27 53.97,20.57 51.73,22.81 51.73,40.46 52.83,41.55 52.83,45.72 52.57,45.97 52.57,48 52.17,48.41 52.17,51.66 52.45,51.94 52.45,53.21 53.21,53.97 53.21,63.22 53.31,63.32 53.31,68.3 53.84,68.83 54.86,68.83 55.46,69.43 55.46,71.62 v1(55.6,71.76) ; J1D4.1 298.57,158.75 v1(298.57,156.34)
  BOTTOM w0.1: v1(295.55,210.82) 295.02,210.82 294.27,210.07 287.26,210.07 v1(285.87,211.45) ; v1(294.64,64.9) 294.64,67.56 293.43,68.77 293.17,68.77 292.6,69.34 292.6,72.52 v1(293.11,73.02)
XDP_PRESENT2_N: length 6.4
  TOP w0.1: J1C1.1 294.52,198.74 295.02,198.25 295.02,196.21 R1D1.2
XDP_PRS_BJT: length 1.7
  TOP w0.1: Q7G2.2 61.1,77.96 R7G18.2
XDP_RESET_BTN_N: length 4.7
  TOP w0.1: J1C1.48 286.58,210.24 286.38,210.44 286.38,210.82 286.25,210.95 285.62,210.95 285.11,211.45 C1C13.1 R1C40.1
XDP_SPI0_IO2: length 78.3
  TOP w0.1: R7F34.1 86.24,117.23 86.24,115.43 86.36,115.31 86.36,113.92 85.69,113.26 85.69,109.95 83.59,107.85 83.59,106.79 84.32,106.06 84.32,101.7 v1(84.45,101.57) ; C1D14.2 63.52,79.86 v1(64.13,79.25)
  LAY6 w0.125: v1(84.45,101.57) 85.2,100.82 85.2,99.43 88.54,96.09 88.54,90.36 87.92,89.74 87.92,81.24 88.83,80.33 88.83,76.79 89.68,75.94 v1(89.68,75.94)
  BOTTOM w0.1: v1(64.13,79.25) 64.13,78.87 65.62,77.38 71.73,77.38 72.31,76.79 73.8,76.79 74.25,77.25 79.1,77.25 83.36,72.99 86.96,72.99 88.13,74.17 88.13,75.94 88.39,76.2 89.43,76.2 v1(89.68,75.94)
XDP_SPI0_MOSI: length 497.5
  TOP w0.1: R1C36.1 v1(299.33,215.01)
  LAY5 w0.125: v1(89.38,20.5) 90.3,19.58 102.23,19.58 104.63,21.98 106.38,21.98 107.77,23.37 109.55,23.37 111.07,24.89 121.28,24.89 122.81,23.36 129.76,23.36 130.17,23.77 130.17,24.4 130.61,24.84 131.74,25.97 133.47,25.97 137.35,29.85 152.43,29.85 159.22,36.63 159.22,40.02 163.46,44.27 166.2,44.27 168.49,46.55 182.39,46.55 185.6,49.76 192.95,49.76 193.54,50.36 195.11,50.36 197.83,53.08 197.83,53.9 198.76,54.83 198.76,57.67 199.15,58.05 201.18,58.05 201.65,58.52 210.78,58.52 213.55,55.75 216.48,55.75 217.55,54.69 217.55,53.7 222.84,48.4 231.84,48.4 233.58,50.14 235.22,50.14 237.41,52.32 250.29,52.32 252.34,54.38 262.27,54.38 262.63,54.74 269.24,54.74 269.74,55.24 269.74,55.88 271.01,57.15 272.97,57.15 275.99,60.17 277.59,60.17 278,60.58 278,61.47 278.25,61.72 279.27,61.72 280.29,62.74 280.29,63.86 280.82,64.38 283.46,64.38 284.35,65.28 287.78,65.28 290.45,67.95 290.45,68.35 296.41,74.32 296.41,81.05 298.55,83.19 298.55,108.28 300.1,109.83 300.1,116.63 299.21,117.52 299.21,122.19 295.7,125.7 295.7,128.54 301.14,133.98 301.14,155.19 298.08,158.26 298.08,190.9 299.33,192.15 299.33,193.8 299.97,194.44 299.97,196.47 299.33,197.1 v1(299.33,215.01)
  LAY6 w0.125: v1(88.9,99.44) 89.29,99.04 89.29,89.99 88.67,89.37 88.67,81.55 89.59,80.64 89.59,77.84 90.67,76.76 90.67,63.01 90.29,62.63 90.29,54.72 89.25,53.67 89.25,43.17 88.52,42.44 88.52,39.37 87.63,38.48 87.63,32.19 88.01,31.81 88.01,24.76 89.38,23.39 v1(89.38,20.5)
  BOTTOM w0.1: R7T14.1 85.85,116.84 85.85,105.69 87.91,103.63 87.91,100.43 v1(88.9,99.44)
XDP_TCLK: length 7.6
  TOP w0.1: J1C1.57 294.78,212.74 295.02,212.98 295.02,215.52 295.65,216.15 296.67,216.15 R1C34.1 R1C32.2
XDP_TCLK1: length 4.9
  TOP w0.1: J1C1.55 295.04,212.24 296.41,213.61 296.41,214.37 R1C35.1
XDP_TDI: length 8.6
  TOP w0.1: R1C23.2 R1C28.1 290.95,215.34 289.91,214.3 289.91,213.14 289.01,212.24 J1C1.56
XDP_TDO: length 10.7
  TOP w0.1: J1C1.52 289.35,211.24 290.88,212.76 290.88,213.92 292.63,215.67 292.63,216.94 R1C30.1 R1C25.2
XDP_TMS: length 7.4
  TOP w0.1: R1C27.1 R1C22.2 289.3,217.8 289.3,213.1 288.94,212.74 J1C1.58
XDP_TRST_N: length 9.5
  TOP w0.1: J1C1.54 289.18,211.74 290.39,212.94 290.39,214.1 291.84,215.55 R1C24.2 R1C29.1
XDP_VCCST_OVERRIDE: length 279.8
  TOP w0.1: v1(151.15,192.84) 151.15,192.79 151.25,192.69 U5D1.2 ; U7G5.2 64.66,78.64 Q7G2.6 64.63,80.38 65.15,80.9 R7G15.2 v1(66.16,81.66)
  LAY5 w0.125: v1(63.24,52.12) 72.59,52.12 73.02,51.69 75.56,51.69 75.94,51.31 77.8,51.31 78.18,51.69 81.73,51.69 83.97,53.93 86.33,53.93 86.87,53.39 89.88,53.39 91.94,55.45 91.94,55.85 96.16,60.07 v1(146.68,60.07)
  LAY6 w0.125: v1(146.68,60.07) 146.68,68.18 137.66,77.19 137.66,78.07 131.39,84.34 131.39,95.17 127.58,98.98 127.58,113.67 132.16,118.26 132.16,119.81 136.27,123.91 136.27,130.55 141.47,135.76 141.47,137.86 143.15,139.53 143.15,144.68 148.74,150.27 148.74,153.65 148.97,153.88 148.97,156.96 148.73,157.2 148.73,163.67 150.49,165.42 150.49,166.82 150.99,167.32 150.99,187.26 151.89,188.16 151.89,192.05 151.15,192.78 v1(151.15,192.84) ; v1(66.16,81.66) 66.3,81.53 66.3,75.14 65.24,74.08 65.24,69.78 61.36,65.9 61.36,65.08 60.21,63.93 60.21,62.34 61.97,60.58 61.97,59.18 62.48,58.67 62.48,52.88 v1(63.24,52.12)
XTAL1_32K_R: length 3.5
  TOP w0.1: R8F45.2 36.19,102.61 33.98,102.61 33.9,102.69 U8F6.123
XTAL2_32K_R: length 4.6
  TOP w0.1: U8F6.125 33.9,103.49 34.05,103.63 34.41,103.63 35.17,102.87 35.68,102.87 36.44,103.63 R8F42.2
XTAL_32K_C: length 7.1
  TOP w0.1: R8F43.1 C8F15.1 38.35,103.86 38.6,103.6 40.41,103.6 40.55,103.74 40.55,104.39 40.78,104.62 40.99,104.62 41.14,104.77 41.14,105.64 41.24,105.74 Y8F1.2
XTAL_32K_EC: length 7.1
  TOP w0.1: R8F45.1 C8F17.1 38.35,103.12 38.6,103.38 40.51,103.38 40.77,103.64 40.77,104.29 40.87,104.39 41.02,104.39 41.14,104.27 41.14,103.38 41.27,103.25 Y8F1.1
XTAL_IN_D: length 46.9
  TOP w0.1: R6D59.2 107.56,172.21 107.56,173.1 v1(107.06,173.61) ; R6D62.2 110.61,172.72 v1(110.61,173.23)
  LAY3 w0.1: v1(107.06,173.61) 107.06,174.5 106.17,175.39 106.17,176.53 104.39,178.31 100.45,178.31 97.4,181.35 97.4,185.42 95.63,187.2 95.63,196.72 98.67,199.77 v1(103.88,199.77)
  LAY6 w0.125: v1(107.06,173.61) 107.31,173.35 110.49,173.35 v1(110.61,173.23)
XTAL_IN_PCON: length 6.5
  TOP w0.1: U3A5.E8 236.74,267.99 235.71,266.95 235.45,266.95 ; 235.45,266.95 C3A18.2 ; 235.45,266.95 235.33,267.08 233.04,267.08 232.39,266.43 232.24,266.43
XTAL_OUT_PCON: length 8.7
  TOP w0.1: Y3A1.3 230.53,268.67 232,267.21 232.53,267.21 232.79,267.46 235.33,267.46 235.45,267.59 C3A17.2 236.22,268.1 236.91,268.79 U3A5.F8
XTAL_PCH_24M_IN: length 19.4
  TOP w0.1: U6E1.U10 v1(106.45,153.87) ; R6D60.1 108.2,171.55 v1(107.82,171.17)
  BOTTOM w0.089: 106.64,156.51 106.5,156.37 106.5,155.7 106.42,155.62 106.42,154.98 106.25,154.81 106.25,154.42 106.45,154.22 v1(106.45,153.87)
  BOTTOM w0.1: v1(107.82,171.17) 107.82,170.64 107.36,169.03 107.36,158.8 106.64,158.08 106.64,156.51
XTAL_PCH_24M_IN_R: length 4.2
  TOP w0.1: 107.9,176.63 107.9,175.94 108.45,175.39 C6D21.1 108.45,173.99 R6D57.1 108.07,172.97 R6D60.2
XTAL_PCH_24M_OUT: length 18.7
  TOP w0.089: v1(106.68,154.6) U6E1.U9
  TOP w0.1: v1(108.71,171.17) 108.96,171.42 R6D61.1
  BOTTOM w0.089: v1(106.68,154.6) 106.61,154.68 106.61,155.53 106.69,155.61 106.69,156.28 106.88,156.47
  BOTTOM w0.1: v1(108.71,171.17) 107.74,168.38 107.74,158.77 106.88,157.91 106.88,156.47
XTAL_PCH_24M_OUT_R: length 5.9
  TOP w0.1: Y6D1.1 109.47,177.93 108.71,177.16 108.71,176.02 109.34,175.39 C6D22.1 108.96,174.37 R6D57.2 R6D61.2
XTAL_PCON_C: length 18.5
  TOP w0.2: C3A18.1 v1(233.8,266.57) ; C3A17.1 v1(233.8,268.1)
  TOP w0.38: v1(233.8,268.1) 233.8,269.11 233.17,269.75 229.99,269.75 229.61,269.37 229.61,265.68 229.99,265.3 232.79,265.3 233.17,265.68 233.17,265.94 v1(233.8,266.57)
  BOTTOM w0.5: v1(233.8,266.57) 234.31,267.08 R3L4.2 ; v1(233.8,268.1) 234.18,268.48 R3L1.2

## Copper pours and planes (outline as drawn)
+5VDUAL_PCH on TOP: 186.43,84.07 176.78,84.07 176.53,83.82 176.53,82.29 175.76,81.53 170.94,81.53 168.91,83.56 161.54,83.56 161.29,83.82 161.29,86.1 161.54,86.36 171.83,86.36 172.84,87.37 186.18,87.37 186.56,86.99 186.56,84.2
+V1P2_PCON_AVDD on BOTTOM: 239.52,265.56 240.53,265.56 240.66,265.43 240.66,263.52 240.41,263.27 239.52,263.27 239.39,263.4 239.39,264.03 239.14,264.29 239.14,265.17
+V1P2_PCON_AVDD on LAY6: 234.95,271.4 240.53,271.4 240.79,271.14 240.79,269.87 240.41,269.49 238.5,269.49 238.5,268.35 240.66,266.19 240.66,265.17 240.41,264.92 239.52,264.92 238.88,265.56 235.33,265.56 234.31,264.54 233.55,264.54 233.55,270
+V1P2_PCON_DVDD on TOP: 263.52,264.92 263.9,264.92 264.41,264.41 265.3,264.41 265.43,264.29 265.43,263.27 265.3,263.14 263.52,263.14 263.27,263.4 263.27,264.67
+V1P2_PCON_DVDD on BOTTOM: 238.63,266.19 239.14,266.19 239.26,266.06 239.26,265.56 239.01,265.3 239.01,263.9 239.14,263.78 239.14,263.4 238.88,263.14 237.49,263.14 237.36,263.27 237.36,264.67 238.63,265.94
+V1P2_PCON_DVDD on LAY6: 239.39,268.86 242.44,268.86 242.82,268.48 242.82,266.83 242.31,266.32 242.31,264.79 242.82,264.29 244.72,264.29 248.15,260.86 250.44,260.86 250.69,261.11 250.69,263.78 251.58,264.67 257.93,264.67 258.82,263.78 262.89,263.78 263.27,264.16 263.27,264.79 263.39,264.92 264.41,264.92 264.54,264.79 264.54,262.63 264.03,262.13 254.76,262.13 253.61,263.27 253.11,263.27 252.85,263.02 252.85,260.86 251.71,259.71 245.36,259.71 245.23,259.84 244.34,259.84 240.91,263.27 238.76,263.27 238.37,263.65 238.37,265.3 238.5,265.43 238.88,265.43 239.64,264.67 240.66,264.67 240.91,264.92 240.91,266.32 239.14,268.1 239.14,268.6
+V1P2S_ALS_D on TOP: 263.9,266.83 265.17,266.83 265.43,266.57 265.43,264.92 265.3,264.79 264.28,264.79 263.97,265.11 262.73,265.11 262.52,265.31 262.52,266.59 262.75,266.82 263.9,266.82
+V1P2S_ALS_D on BOTTOM: 253.49,270.25 257.68,270.25 258.06,269.87 258.06,269.11 259.71,267.46 260.09,267.46 260.47,267.08 265.3,267.08 265.43,266.95 265.43,265.17 264.79,264.54 258.95,264.54 258.82,264.67 258.82,266.83 257.04,268.6 254,268.6 253.36,267.97 253.36,265.43 253.74,265.05 254.63,265.05 254.76,264.92 254.76,264.16 254.63,264.03 252.22,264.03 251.96,264.29 251.96,268.73
+V1P2S_ALS_RX on BOTTOM: 253.74,263.52 254.76,263.52 255.01,263.27 258.44,263.27 258.69,263.02 258.69,262.25 258.31,261.87 254.12,261.87 253.74,262.25
+V1P2S_HDMI_VR on TOP: 266.06,265.81 267.46,265.81 268.35,264.92 268.35,262.89 268.47,262.76 269.87,262.76 270.12,262.51 270.12,261.11 270.48,260.76 270.48,260.63 270.61,260.49 271.11,260.49 271.14,260.46 271.14,260.22 271.11,260.19 266.6,260.19 265.93,260.86 265.93,265.68
+V1P05A on TOP: 186.18,202.69 186.18,203.71 184.65,205.23 183.13,205.23 182.37,204.47 182.37,202.82 182.62,202.56 186.05,202.56
+V1P05A on TOP: 132.96,106.68 132.58,107.06 128.01,107.06 127.63,106.68 127.63,102.11 128.14,101.6 132.33,101.6 132.96,102.23
+V1P05A on TOP: 180.72,202.44 178.68,202.44 178.43,202.69 178.43,205.61 178.56,205.74 180.34,205.74 180.84,205.23 180.84,202.56
+V1P05A on LAY5: 175.26,188.97 185.42,188.97 187.83,186.56 187.83,185.93 188.59,185.16 188.59,184.4 188.15,183.96 187.45,183.96 187.45,183.89 187.07,183.51 185.42,183.51 185.42,174.24 178.81,167.64 178.43,167.64 174.11,163.32 172.33,163.32 168.59,159.57 168.59,158.94 163.83,154.18 163.83,150.75 161.79,148.72 159.38,148.72 157.6,146.94 157.6,144.27 158.36,143.51 158.36,134.36 157.22,133.22 155.44,133.22 154.94,132.71 154.94,118.49 153.16,116.71 153.16,108.84 147.63,103.31 146.74,103.31 143.38,99.95 133.35,99.95 132.71,100.58 131.82,100.58 130.04,102.36 130.04,108.08 130.42,108.46 135.63,108.46 136.9,109.73 136.9,111.89 137.54,112.52 140.71,112.52 140.84,112.65 140.84,119 146.55,124.71 146.55,129.54 145.54,130.55 145.54,145.54 154.94,154.94 154.94,158.11 157.98,161.16 157.98,164.72 170.18,176.91 173.6,176.91 174.62,177.93 174.62,188.34 ; 3 cut-outs
+V1P05A on LAY6: 179.57,200.28 180.02,199.83 182.11,199.83 184.27,197.67 184.27,196.59 179.32,191.64 179.32,184.02 179.57,183.77 184.91,183.77 185.8,184.66 188.72,184.66 189.48,185.42 189.48,191.13 189.86,191.51 189.86,191.64 191.38,193.17 191.38,201.93 189.86,203.45 186.3,203.45 184.4,205.36 179.83,205.36 179.57,205.1
+V1P05A_OUT on TOP: 143.76,100.07 143.76,95.76 140.71,92.71 140.71,86.87 140.33,86.49 129.79,86.49 129.41,86.87 129.41,99.69 129.79,100.07 131.44,100.07 131.57,99.95 142.36,99.95 142.62,100.2 143.63,100.2
+V1P05A_VAL on TOP: 136.14,109.22 135,109.22 134.74,109.47 134.74,112.14 135,112.39 136.52,112.39 136.77,112.14 136.77,109.85
+V1P05A_VAL on TOP: 77.21,103.25 80.64,103.25 80.89,103 80.89,101.6 80.51,101.22 77.21,101.22 76.96,101.47 76.96,103
+V1P05A_VAL on TOP: 52.73,138.14 54.5,138.14 56,136.64 56,133.22 57.78,131.44 57.78,116.08 57.27,115.57 56.26,115.57 55.49,116.33 55.49,128.9 53.59,130.81 53.59,135.15 52.6,136.14 52.6,138.02
+V1P05A_VAL on TOP: 116.96,112.77 119.38,112.77 119.5,112.65 119.5,112.01 119.38,111.89 119.12,111.89 118.74,111.5 116.96,111.5 116.84,111.63 116.84,112.65
+V1P05A_VAL on TOP: 102.74,175.89 101.85,175.89 101.72,175.77 101.72,173.48 101.85,173.35 102.61,173.35 102.87,173.61 102.87,175.77
+V1P05A_VAL on BOTTOM: 125.98,51.81 127.88,51.81 128.27,51.43 128.27,50.67 128.01,50.42 127,50.42 126.49,50.93 125.98,50.93 125.85,51.05 125.85,51.69
+V1P05A_VAL on BOTTOM: 118.23,86.49 119.25,86.49 119.63,86.1 119.63,83.85 119.5,83.72 118.16,83.72 117.85,84.02 117.85,86.1
+V1P05A_VAL on LAY3: 182.75,197.74 178.68,197.74 176.91,195.96 176.91,195.45 178.68,193.67 178.68,190.12 179.32,189.48 181.22,189.48 182.11,190.37 182.11,194.44 182.88,195.2 182.88,197.61
+V1P05A_VAL on LAY5: 122.17,126.62 123.57,126.62 123.82,126.87 123.82,127.38 123.44,127.76 122.04,127.76 121.79,127.51 121.79,127
+V1P05A_VAL on LAY5: 105.53,182.24 106.8,180.97 106.8,179.45 106.55,179.2 106.55,173.99 105.91,173.35 101.98,173.35 101.72,173.61 101.72,174.75 103.69,176.72 103.69,181.8 104.14,182.24
+V1P05A_VAL on LAY5: 124.58,114.55 134.36,114.55 136.52,112.39 136.52,109.6 135.63,108.71 121.79,108.71 121.03,107.95 118.99,107.95 118.3,108.65 118.3,110.93 117.72,111.5 117.72,112.9 117.98,113.16 123.19,113.16 ; 11 cut-outs
+V1P05A_VAL on LAY5: 123.44,165.48 124.33,165.48 124.71,165.1 124.71,164.08 124.58,163.96 123.44,163.96 122.93,164.46 122.93,164.97
+V1P05A_VAL on LAY6: 121.92,127.51 123.44,127.51 123.82,127.13 123.82,125.86 123.57,125.6 122.04,125.6 121.79,125.86 121.79,127.38
+V1P05A_VAL on LAY6: 117.09,89.15 116.58,88.64 116.58,88.14 117.72,86.99 117.72,85.72 118.61,84.83 118.99,84.83 119.63,85.47 119.63,86.36 119.25,86.74 119.25,88.14 118.23,89.15
+V1P05A_VAL on LAY6: 126.74,51.56 128.14,51.56 128.27,51.43 128.27,50.04 128.01,49.78 127.38,49.78 126.36,50.8 126.36,51.18
+V1P05A_VAL on LAY6: 119.38,114.93 120.01,114.93 120.26,114.68 120.26,112.14 119.88,111.76 119.12,111.76 118.87,111.5 118.87,109.73 115.82,106.68 108.71,106.68 105.91,103.88 87.24,103.88 86.36,103 84.45,103 82.55,101.09 79.37,101.09 79.12,101.34 79.12,102.87 79.37,103.12 81.02,103.12 85.72,107.82 104.39,107.82 109.85,113.28 118.74,113.28 119.12,113.66 119.12,114.68 ; 1 cut-out
+V1P05A_VAL on LAY6: 122.93,166.37 123.82,166.37 124.2,165.99 124.2,164.46 123.95,164.21 123.19,164.21 122.8,164.59 122.8,166.24
+V1P05A_VAL on LAY8: 179.19,191.77 180.59,191.77 181.1,191.26 181.1,189.74 175.26,183.89 172.46,183.89 167.38,178.81 167.38,174.24 163.06,169.92 160.4,169.92 160.02,169.54 160.02,162.56 154.43,156.97 154.43,151.26 145.54,142.37 145.54,132.21 146.05,131.7 146.05,122.93 143,119.89 143,111.89 138.93,107.82 136.14,107.82 135.76,108.2 135.76,114.68 136.9,115.82 136.9,137.79 149.86,150.75 149.86,156.97 152.65,159.76 152.65,160.15 156.33,163.83 156.33,164.97 157.73,166.37 157.73,171.07 169.92,183.26 169.92,184.66 173.35,188.09 176.78,188.09 178.56,189.86 178.56,191.13 ; 1 cut-out
+V1P05A_VAL_OUT on TOP: 49.42,138.14 51.96,138.14 52.09,138.02 52.09,135.86 52.47,135.48 52.47,134.59 52.34,134.46 49.3,134.46 49.17,134.59 49.17,137.89
+V1P8_AUDIO on TOP: 131.19,275.08 132.08,275.08 132.33,274.83 132.33,272.79 131.95,272.41 131.57,272.41 131.06,271.91 131.06,271.14 130.81,270.89 130.17,270.89 130.04,271.02 130.04,272.79 130.81,273.56 130.81,274.7
+V1P8_AUDIO on TOP: 114.42,280.92 115.95,280.92 116.07,280.8 116.07,279.53 115.95,279.4 114.42,279.4 114.3,279.53 114.3,280.8
+V1P8_AUDIO on BOTTOM: 31.36,280.92 34.79,280.92 35.17,280.54 35.17,277.49 34.79,277.11 32.89,277.11 32.63,277.37 32.63,278.76 31.24,280.16 31.24,280.8
+V1P8_AUDIO on BOTTOM: 115.06,280.92 115.69,280.92 115.95,280.67 115.95,272.41 116.58,271.78 119.63,271.78 122.68,274.83 131.95,274.83 132.08,274.7 132.08,273.05 131.82,272.79 130.55,272.79 129.92,272.16 125.09,272.16 123.57,270.64 120.52,270.64 120.45,270.7 116.14,270.7 114.55,272.29 114.55,280.41
+V1P8_AUDIO on BOTTOM, LAY5: 44.83,279.78 46.48,279.78 46.73,279.53 46.73,278.76 46.48,278.51 44.83,278.51 44.57,278.76 44.57,279.53
+V1P8_AUDIO on LAY5: 115.95,280.92 115.31,280.92 115.06,280.67 115.06,280.03 114.8,279.78 113.91,279.78 113.79,279.65 113.79,278.89 113.91,278.76 115.82,278.76 116.2,279.14 116.2,280.67
+V1P8_AUDIO_R on TOP: 111.25,282.07 113.15,282.07 113.66,281.56 113.66,279.91 113.41,279.65 111.37,279.65 111.12,279.91 111.12,281.94
+V1P8A on TOP: 31.62,71.12 31.49,70.99 31.49,68.07 31.87,67.69 33.65,67.69 33.9,67.94 33.9,68.71 33.52,69.09 33.52,70.99 33.4,71.12
+V1P8A on TOP: 54.48,175.26 54.61,175.13 54.61,174.5 54.35,174.24 53.46,174.24 53.34,174.12 53.34,173.73 53.21,173.61 52.19,173.61 51.94,173.86 51.94,175.13 52.07,175.26
+V1P8A on TOP: 52.95,182.37 53.08,182.24 54.48,182.24 54.61,182.37 54.61,183.64 54.48,183.77 53.08,183.77 52.95,183.64
+V1P8A on TOP: 27.68,186.31 26.54,186.31 26.28,186.05 26.28,184.28 26.92,183.64 27.68,183.64 27.81,183.77 27.81,186.18
+V1P8A on TOP: 62.99,107.69 63.11,107.69 69.97,100.84 69.97,99.06 69.59,98.68 66.29,98.68 65.27,99.69 65.27,101.47 60.32,106.42 59.43,106.42 59.3,106.55 59.3,107.57 58.03,108.84 58.03,109.6 58.16,109.73 59.43,109.73 59.94,109.22 61.46,109.22
+V1P8A on TOP: 108.07,281.81 109.09,281.81 109.34,282.07 110.74,282.07 110.87,281.94 110.87,280.03 111.12,279.78 111.12,279.02 110.87,278.76 110.1,278.76 109.72,279.14 108.07,279.14 107.95,279.27 107.95,281.68
+V1P8A on BOTTOM: 26.03,184.66 26.03,184.15 26.92,183.26 26.92,181.86 31.62,177.16 40,177.16 40.89,176.27 43.05,176.27 46.1,173.23 53.21,173.23 53.34,173.35 53.34,174.75 52.57,175.51 47.87,175.51 47.49,175.89 47.49,177.54 46.89,178.15 45.68,178.15 43.18,180.66 34.29,180.66 26.47,188.47 23.62,188.47 23.49,188.34 23.49,187.2
+V1P8A on BOTTOM: 66.29,188.09 64.77,188.09 64.26,187.58 64.26,182.24 65.91,180.59 66.8,180.59 66.92,180.72 66.92,181.86 66.42,182.37 66.42,186.69 66.67,186.94 66.67,187.7
+V1P8A on LAY5: 66.67,102.61 67.18,102.11 68.07,102.11 68.45,102.49 68.45,114.3 68.19,114.55 68.19,118.74 65.91,121.03 65.91,122.17 68.45,124.71 68.45,133.09 69.72,134.36 69.72,140.84 71.12,142.24 71.12,142.75 70.73,143.13 69.46,143.13 67.18,140.84 67.18,134.24 65.15,132.21 65.15,127.38 63.5,125.73 63.5,113.41 66.67,110.23
+V1P8A on LAY5: 61.46,107.06 61.21,106.81 58.03,106.81 57.53,107.31 57.53,109.22 53.21,113.54 53.21,122.81 51.05,124.97 51.05,170.69 52.95,172.59 53.72,171.83 53.72,129.28 52.57,128.14 52.57,126.74 55.62,123.7 55.62,114.93 61.46,109.09
+V1P8A on LAY5: 51.81,169.8 52.83,169.8 53.34,170.31 53.34,174.88 52.95,175.26 52.7,175.26 52.57,175.39 52.57,181.99 52.95,182.37 53.46,182.37 53.53,182.43 63.18,182.43 67.05,186.31 67.05,187.32 66.29,188.09 53.72,188.09 50.41,184.78 50.41,172.85 51.05,172.21 51.05,170.56
+V1P8A on LAY5: 110.99,275.97 110.99,279.53 110.74,279.78 106.93,279.78 106.29,279.14 106.29,277.49 105.79,276.99 100.45,276.99 99.44,275.97 99.44,274.57 99.82,274.19 109.22,274.19
+V1P8A on LAY6: 79.88,100.71 78.23,100.71 78.1,100.58 78.1,99.69 78.35,99.44 79.88,99.44 80.13,99.69 80.13,100.46
+V1P8A on LAY6: 18.54,279.4 23.74,279.4 23.87,279.27 23.87,278.26 23.62,278 20.82,278 19.43,276.6 18.28,276.6 14.73,273.05 13.08,273.05 12.95,273.18 12.95,274.32 13.08,274.45 13.58,274.45
+V1P8A on LAY6: 86.48,79.88 85.21,79.88 84.83,79.5 84.83,72.13 84.96,72.01 86.23,72.01 86.86,72.64 86.86,79.5
+V1P8A_OUT on TOP: 60.32,105.79 63.5,102.61 63.5,99.31 63.11,98.93 58.92,98.93 58.67,99.19 58.67,102.87 57.78,103.76 55.75,103.76 55.49,104.01 55.49,105.54 55.75,105.79
+V1P8A_PCH_VAL on TOP: 76.07,166.11 77.47,166.11 77.85,165.73 77.85,164.84 77.47,164.46 74.29,164.46 73.15,165.61 72,165.61 69.72,167.89 69.72,168.78 70.1,169.16 72,169.16 74.04,167.13 75.05,167.13
+V1P8A_PCH_VAL on TOP: 57.65,162.81 58.16,163.32 58.16,164.84 57.78,165.23 56.38,165.23 56,164.84 56,163.19 56.38,162.81
+V1P8A_PCH_VAL on TOP: 52.73,156.58 54.5,156.58 54.76,156.33 54.76,154.3 54.5,154.04 52.85,154.04 52.6,154.3 52.6,156.46
+V1P8A_PCH_VAL on TOP: 77.85,105.66 80.13,105.66 80.26,105.79 80.26,106.42 80.13,106.55 77.85,106.55 77.59,106.3 77.59,105.92
+V1P8A_PCH_VAL on BOTTOM: 71.88,166.75 73.53,166.75 74.04,166.24 74.04,165.73 73.91,165.61 71.88,165.61 71.75,165.73 71.75,166.62
+V1P8A_PCH_VAL on LAY5: 73.02,166.62 74.29,166.62 74.67,166.24 74.67,163.57 75.18,163.07 75.18,157.99 75.05,157.86 73.78,157.86 73.4,158.24 73.4,163.19 73.27,163.32 72.51,163.32 72.26,163.57 72.26,165.86
+V1P8A_PCH_VAL on LAY5: 73.66,151.89 74.54,151.89 74.67,151.76 74.67,150.24 74.54,150.11 73.78,150.11 73.66,150.24
+V1P8A_PCH_VAL on LAY6: 52.95,154.3 53.34,153.92 54.73,153.92 55.37,154.56 55.37,155.45 55.75,155.83 55.75,161.42 57.15,162.81 57.15,164.59 56.89,164.84 54.61,164.84 53.72,163.96 53.72,159.64 52.95,158.88
+V1P8A_PCH_VAL on LAY6: 77.97,106.55 80.13,106.55 80.26,106.42 80.26,105.79 80.13,105.66 78.1,105.66 77.85,105.92 77.85,106.42
+V1P8A_PCH_VAL_OUT on TOP: 49.42,156.58 51.96,156.58 52.09,156.46 52.09,154.3 52.47,153.92 52.47,153.03 52.34,152.9 49.3,152.9 49.17,153.03 49.17,156.33
+V1P8A_TCH_PNL on TOP: 61.84,195.71 61.21,196.34 61.08,196.34 60.96,196.21 60.96,195.32 61.72,194.56 62.73,194.56 62.86,194.69 62.86,195.58 62.73,195.71
+V1P8S on TOP: 26.28,183.39 27.68,183.39 27.81,183.26 27.81,182.37 27.43,181.99 26.28,181.99 26.03,182.24 26.03,183.13
+V3P3_AUDIO on TOP: 32.25,279.91 32.25,278.13 32.13,278 30.98,278 30.73,278.26 30.73,278.76 31.11,279.14 31.11,280.03 31.24,280.16 32,280.16
+V3P3_AUDIO on BOTTOM: 32,279.14 32.38,278.76 32.38,278.26 31.24,277.11 29.84,277.11 29.33,277.62 29.33,278.76 29.71,279.14
+V3P3_AUDIO_R on TOP: 29.59,281.81 32,281.81 32.25,281.56 32.25,280.8 31.87,280.41 30.73,280.41 30.6,280.29 30.6,279.27 30.48,279.14 29.21,279.14 29.08,279.27 29.08,281.3
+V3P3_DUAL on TOP: 163.32,275.72 164.84,275.72 164.97,275.59 164.97,274.57 164.33,273.94 163.44,273.94 163.32,274.06
+V3P3_DUAL on TOP: 46.86,70.48 47.24,70.1 48.26,70.1 48.64,69.72 48.64,67.69 48.51,67.56 46.35,67.56 45.33,68.58 44.06,68.58 43.56,69.09 43.56,72.77 48,77.21 48,78.87 46.73,80.14 46.73,82.17 46.99,82.42 49.02,82.42 50.03,81.41 50.03,75.69 46.86,72.52
+V3P3_DUAL on BOTTOM: 34.67,267.71 34.67,266.44 34.54,266.32 30.6,266.32 30.22,266.7 30.22,269.75 31.11,270.64 32.76,270.64 33.02,270.38 33.02,268.1 33.27,267.84 34.54,267.84
+V3P3_DUAL on BOTTOM: 99.31,266.7 99.69,267.08 99.69,268.6 99.18,269.11 95.88,269.11 95.63,269.37 95.63,271.14 95.12,271.65 90.42,271.65 87.63,274.45 86.74,274.45 86.36,274.06 86.36,266.06 87.24,265.17 92.45,265.17 93.21,265.94 94.48,265.94 95.25,266.7 ; 1 cut-out
+V3P3_DUAL on BOTTOM: 40.76,69.21 47.49,69.21 47.87,68.83 47.87,66.29 46.35,64.77 44.06,64.77 43.3,65.53 38.1,65.53 36.57,64.01 31.49,64.01 26.79,59.31 26.79,48.64 21.71,43.56 21.71,39.88 21.84,39.75 22.86,39.75 23.49,39.11 26.28,39.11 26.67,39.5 31.75,39.5 32.13,39.11 36.06,39.11 39.49,42.54 41.91,42.54 42.29,42.92 46.6,42.92 52.07,48.39 57.53,48.39 64.77,55.62 64.77,60.07 68.32,63.63 86.36,63.63 87.24,62.74 87.24,60.83 86.74,60.32 83.43,60.32 82.04,61.72 76.07,61.72 75.31,60.96 72,60.96 71.24,61.72 68.83,61.72 67.56,60.45 67.56,54.61 65.27,52.32 64.64,52.32 64,51.69 64,51.05 58.29,45.34 52.45,45.34 47.87,40.77 47.87,40.64 47.43,40.19 40.95,40.19 34.79,34.03 24.13,34.03 19.68,38.48 19.68,45.46 23.36,49.15 23.36,59.05 31.24,66.93 38.48,66.93
+V3P3_DUAL on LAY5: 28.7,269.11 31.75,269.11 32,268.86 32,263.27 27.17,258.44 27.17,238.5 25.78,237.11 25.78,236.09 26.28,235.58 32.63,235.58 33.65,234.57 33.65,230.12 32.89,229.36 31.75,229.36 29.46,231.65 26.79,231.65 22.47,227.33 22.47,213.23 22.6,213.1 22.6,185.8 29.59,178.81 29.59,162.18 29.97,161.8 31.75,161.8 40.89,152.65 40.89,147.45 38.6,145.16 37.33,145.16 24.06,158.43 24.06,177.48 18.79,182.75 18.79,230.38 17.52,231.65 17.52,251.08 19.05,252.6 19.05,266.44 21.14,268.54 28.13,268.54
+V3P3_DUAL on LAY5: 120.14,75.44 119.38,75.44 119.12,75.18 119.12,74.04 119.38,73.79 120.14,73.79 120.26,73.91 120.26,75.31
+V3P3_DUAL on LAY5: 40.25,107.44 40.25,106.04 40,105.79 40,104.77 40.38,104.39 40.38,102.74 39.62,101.98 39.62,96.26 40.64,96.26 42.03,97.66 42.03,100.46 43.56,101.98 43.3,102.23 41.27,102.23 41.02,102.49 41.02,107.19 40.76,107.44
+V3P3_DUAL on LAY5: 85.85,63.75 85.85,61.34 86.36,60.83 87.37,60.83 88.01,61.47 88.01,63.75 87.75,64.01 86.1,64.01
+V3P3_DUAL on LAY5: 49.53,81.91 49.53,81.28 48.64,80.39 46.1,80.39 44.95,81.53 43.18,81.53 39.62,85.09 39.62,96.26 41.4,98.04 41.4,100.33 43.81,102.74 43.81,106.3 43.3,106.81 40.89,106.81 40.25,107.44 40.25,108.2 39.62,108.84 39.62,109.09 38.6,110.11 38.6,121.66 35.3,124.97 35.3,150.62 35.81,151.13 38.22,151.13 41.27,148.08 41.27,129.41 43.81,126.87 43.81,119.38 46.86,116.33 46.86,103 44.83,100.96 44.83,97.28 46.99,95.12 46.99,91.06 51.05,86.99 51.05,83.44 ; 2 cut-outs
+V3P3_DUAL on LAY5: 150.24,79.5 151.76,79.5 151.89,79.37 151.89,78.61 151.38,78.1 149.86,78.1 149.73,78.23 149.73,78.99
+V3P3_DUAL on LAY6: 119.25,75.94 119.88,75.94 120.14,75.69 120.14,73.91 119.88,73.66 119.25,73.66 118.99,73.91 118.99,75.69
+V3P3_DUAL on LAY6: 136.52,269.87 136.14,270.25 135,270.25 131.69,266.95 128.27,266.95 127.63,266.32 127.63,264.54 127.5,264.41 123.69,264.41 123.44,264.16 123.44,263.52 123.82,263.14 130.04,263.14 131.95,265.05 134.23,265.05 136.52,267.33
+V3P3_DUAL on LAY6: 165.1,275.59 165.1,274.57 164.84,274.32 164.59,274.32 163.7,273.43 162.94,273.43 162.68,273.68 162.68,274.19 163.19,274.7 163.32,274.7 164.46,275.84 164.84,275.84
+V3P3_DUAL on LAY6: 150.24,79.63 151.63,79.63 151.89,79.37 151.89,78.74 151.51,78.36 149.98,78.36 149.86,78.48 149.86,79.25
+V3P3_DUAL on LAY6: 100.96,268.1 98.29,268.1 98.17,267.97 98.17,267.21 98.42,266.95 100.83,266.95 101.09,267.21 101.09,267.97
+V3P3_DUAL on LAY6: 109.09,98.17 109.72,98.17 109.85,98.04 109.85,96.52 109.72,96.39 109.22,96.39 108.96,96.65 108.96,98.04
+V3P3_EC on TOP: 27.17,144.52 30.73,144.52 31.11,144.14 31.11,143 30.86,142.75 27.3,142.75 26.79,143.25 26.79,144.14
+V3P3_EC on TOP: 21.2,148.46 21.2,145.54 20.82,145.16 15.62,145.16 14.35,146.43 13.2,146.43 11.43,148.21 11.43,157.1 14.09,159.76 14.73,159.76 14.98,159.51 14.98,158.75 14.09,157.86 14.09,148.21 14.22,148.08 14.35,148.08 15.24,147.19 16,147.19 16.89,148.08 17.65,148.08 18.28,148.72 20.95,148.72
+V3P3_EC on TOP: 36.32,92.84 36.32,91.06 36.44,90.93 36.44,89.28 36.57,89.15 37.84,89.15 38.35,89.66 38.35,92.45 37.84,92.96 36.44,92.96
+V3P3_EC on TOP: 27.81,111 27.55,111.25 27.55,114.55 27.17,114.93 24.13,114.93 23.74,115.31 20.57,115.31 20.19,115.7 20.19,117.22 20.44,117.47 20.95,117.47 21.08,117.35 21.08,116.46 21.46,116.08 27.94,116.08 28.57,115.44 28.57,112.27 28.7,112.14 35.43,112.14 36.06,111.5 36.06,110.49 35.94,110.36 35.17,110.36 34.54,111
+V3P3_EC on BOTTOM: 8,107.31 9.9,107.31 14.22,103 14.22,96.01 13.84,95.63 13.08,95.63 12.19,96.52 12.19,101.47 11.17,102.49 4.57,102.49 4.31,102.74 4.31,103.63
+V3P3_EC on LAY5: 37.33,112.9 36.06,112.9 35.3,112.14 35.3,109.98 35.68,109.6 36.83,109.6 37.84,110.62 37.84,112.39
+V3P3_EC on LAY5: 31.36,143.13 30.86,142.62 28.95,142.62 28.57,143 28.57,143.89 29.71,145.03 31.11,145.03 31.36,144.78
+V3P3_EC_AIC on TOP: 111.25,20.06 111.37,19.94 115.57,19.94 115.69,20.06 115.69,22.86 115.44,23.11 112.39,23.11 112.26,22.99 112.26,21.46 111.25,20.45
+V3P3_EC_MIX on TOP: 37.33,87.5 35.05,87.5 34.54,88.01 34.54,90.04 34.79,90.3 35.68,90.3 36.06,89.91 36.06,89.03 36.19,88.9 37.33,88.9 37.46,88.77 37.46,87.63
+V3P3_LAN on TOP: 178.56,259.08 178.56,265.56 179.57,266.57 180.46,266.57 182.11,268.22 183.26,268.22 183.76,267.71 183.76,267.21 182.75,266.19 182.24,266.19 181.1,265.05 180.08,265.05 179.95,264.92 179.95,261.62 179.45,261.11 179.45,259.97 180.97,258.44 180.97,255.78 180.46,255.27 180.46,254.63 179.57,253.74 177.54,253.74 177.41,253.87 177.41,255.78 177.8,256.16 177.8,258.32
+V3P3_LAN on LAY6: 182.75,255.65 179.19,255.65 178.18,254.63 178.18,253.36 178.43,253.11 180.84,253.11 181.73,254 181.86,254 182.88,255.01 182.88,255.52
+V3P3_LAN on LAY6: 186.3,263.14 186.94,263.14 187.45,262.63 188.21,262.63 188.34,262.76 188.34,263.14 188.59,263.4 188.72,263.4 188.84,263.27 188.84,261.24 188.59,260.98 184.78,260.98 183.38,259.59 182.62,259.59 181.22,260.98 181.22,267.21 181.99,267.97 183.51,267.97 184.4,267.08 184.4,263.02 184.91,262.51 185.67,262.51
+V3P3_LAN_FOX on TOP: 32.13,233.42 33.4,233.42 33.65,233.17 33.65,232.79 32.89,232.03 32.89,231.14 32.76,231.01 31.87,231.01 31.75,231.14 31.75,233.04
+V3P3_LAN_FOX on TOP: 103.12,278.76 103.37,278.51 103.37,276.73 102.99,276.35 101.09,276.35 98.55,273.81 94.23,273.81 93.72,273.3 93.72,272.03 92.83,271.14 90.93,271.14 90.55,270.76 89.15,270.76 88.64,270.25 88.64,268.98 87.63,267.97 87.63,264.54 88.9,263.27 90.55,263.27 90.61,263.21 90.61,262.95 90.04,262.38 87.37,262.38 87.24,262.25 87.24,258.7 88.26,257.68 88.26,257.17 88.01,256.92 81.02,256.92 79.37,258.57 79.37,258.95 80.64,260.22 81.53,260.22 82.93,258.82 84.07,258.82 84.58,259.33 84.58,270.64 85.72,271.78 90.04,271.78 94.36,276.1 97.79,276.1 100.45,278.76
+V3P3_LAN_FOX on BOTTOM: 32,231.14 33.27,231.14 33.4,231.27 33.4,236.98 35.3,238.89 35.3,239.77 37.08,241.55 37.08,246 40.64,249.55 40.64,262.38 40.25,262.76 38.22,262.76 37.59,262.13 37.59,252.86 34.67,249.93 34.67,243.58 33.4,242.31 33.4,239.01 31.75,237.36 31.75,231.39
+V3P3_LAN_FOX on LAY5: 38.86,262.76 40.76,262.76 42.29,264.29 44.06,264.29 44.57,263.78 46.48,263.78 47.11,264.41 60.19,264.41 60.83,265.05 63.75,265.05 64.77,264.03 64.77,263.14 63.75,262.13 43.94,262.13 43.05,261.24 38.86,261.24 38.6,261.49 38.6,262.51
+V3P3_LAN_FOX on LAY5: 75.94,262.38 79.37,262.38 82.16,259.59 82.16,258.7 81.91,258.44 77.85,258.44 75.56,260.73 75.56,262
+V3P3_LAN_FOX on LAY6: 87.12,263.65 90.55,263.65 90.8,263.4 90.8,263.02 90.55,262.76 90.04,262.76 89.78,262.51 89.78,262.13 90.67,261.24 90.67,261.11 89.78,260.22 89.78,259.59 90.55,258.82 90.55,258.7 89.78,257.94 89.78,256.67 90.17,256.28 90.17,253.87 90.55,253.49 90.55,251.2 90.8,250.95 92.45,250.95 92.58,251.08 92.58,251.71 93.72,252.86 93.72,255.27 94.1,255.65 95.5,255.65 96.77,256.92 97.4,256.92 98.55,258.06 98.55,260.6 99.31,261.36 99.31,262.13 98.93,262.51 95.5,262.51 94.74,263.27 94.74,265.17 95.75,266.19 98.8,266.19 100.07,264.92 100.07,258.57 101.47,257.17 102.99,257.17 103.25,256.92 103.25,254.63 103.12,254.51 99.18,254.51 94.23,249.55 90.29,249.55 86.74,253.11 86.74,263.27
+V3P3_LAN_FOX_R on TOP: 106.55,277.24 104.01,277.24 103.88,277.37 103.88,278.26 104.01,278.38 106.55,278.38 106.68,278.26 106.68,277.37
+V3P3_LAN_R on TOP: 174.49,255.9 176.65,255.9 176.91,255.65 176.91,254.25 176.65,254 174.49,254 174.37,254.13 174.37,255.78
+V3P3_PMON on TOP: 284.86,148.21 286.13,148.21 286.51,148.59 286.51,150.24 288.16,151.89 288.16,155.57 287.65,156.08 286.63,156.08 286.51,156.21 286.51,156.84 286.25,157.1 284.48,157.1 284.22,157.35 284.22,157.73 284.48,157.99 287.9,157.99 289.17,156.72 289.17,148.97 288.03,147.83 288.03,146.68 287.9,146.56 287.14,146.56 286.38,147.32 284.86,147.32 284.73,147.45 284.73,148.08
+V3P3_SLOTE on TOP: 76.07,227.2 78.99,227.2 79.62,226.57 79.62,221.99 79.5,221.87 77.47,221.87 77.34,221.99 77.34,223.9 75.81,225.42 75.81,226.95
+V3P3_SLOTE on TOP: 76.96,248.54 81.28,248.54 81.78,248.03 81.78,246.89 81.28,246.38 79.75,246.38 79.5,246.12 79.5,244.09 79.37,243.97 76.07,243.97 75.94,244.09 75.94,246 76.7,246.76 76.7,248.28
+V3P3_SLOTE on BOTTOM: 82.29,231.9 80.77,233.42 80.77,238.76 81.02,239.01 83.18,239.01 83.56,239.39 83.56,243.71 83.94,244.09 83.94,245.87 82.29,247.52 78.61,247.52 77.97,246.89 77.97,236.73 78.48,236.22 78.48,232.41 79.37,231.52 79.37,228.22 77.72,226.57 77.72,224.03 78.61,223.14 81.78,223.14 82.29,223.65
