# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Nets (continued)
HDMIC_ALS_DATA0_R_DN: EU2A2.2 EU2A2.9 J2A1.B9 L2A3.3 R2A29.2(B)
HDMIC_ALS_DATA0_R_DP: EU2A2.1 EU2A2.10 J2A1.B7 L2A3.2 R2A28.2(B)
HDMIC_ALS_DATA1_DN: EU2A7.19 L2A2.4(OUT_2) R2A27.1
HDMIC_ALS_DATA1_DP: EU2A7.20 L2A2.1 R2A26.1
HDMIC_ALS_DATA1_R_DN: EU2A1.5 EU2A1.6 J2A1.B6 L2A2.3 R2A27.2(B)
HDMIC_ALS_DATA1_R_DP: EU2A1.4 EU2A1.7 J2A1.B4 L2A2.2 R2A26.2(B)
HDMIC_ALS_DATA2_DN: EU2A7.22 L2A1.4(OUT_2) R2A25.1
HDMIC_ALS_DATA2_DP: EU2A7.23 L2A1.1 R2A24.1
HDMIC_ALS_DATA2_R_DN: EU2A1.2 EU2A1.9 J2A1.B3 L2A1.3 R2A25.2(B)
HDMIC_ALS_DATA2_R_DP: EU2A1.1 EU2A1.10 J2A1.B1 L2A1.2 R2A24.2(B)
HDMIC_ALS_HPD: EU2A6.1 EU2A6.10 EU2A7.21 J2A1.B19 R2A9.1 R2A21.2(B)
HDMIC_ALS_SCL: EU2A6.2 EU2A6.9 EU2A7.7 J2A1.B15 R2A22.2(B)
HDMIC_ALS_SDA: EU2A6.4 EU2A6.7 EU2A7.8 J2A1.B16 R2A23.2(B)
HDMIC_I2C_ADDR: EU2A7.31 R2A41.2(B)
HDMIC_ID: EU2A7.32 R2A44.2(B)
HDMIC_PD: EU2A7.4 R2A52.2(B) R2A56.2(B) R2B2.2
HDMID_BP_CLK_DN: EU3A1.5 EU3A1.6 J3A2.12 R3A13.2(B) U3A3.3
HDMID_BP_CLK_DP: EU3A1.4 EU3A1.7 J3A2.10 R3A12.2(B) U3A3.2
HDMID_BP_DATA0_DN: EU3A1.2 EU3A1.9 J3A2.9 R3A11.2(B) U3A2.3
HDMID_BP_DATA0_DP: EU3A1.1 EU3A1.10 J3A2.7 R3A10.2(B) U3A2.2
HDMID_BP_DATA1_DN: CR3A2.5 CR3A2.6 J3A2.6 R3A9.2(B) U3A1.3
HDMID_BP_DATA1_DP: CR3A2.4 CR3A2.7 J3A2.4 R3A8.2(B) U3A1.2
HDMID_BP_DATA2_DN: CR3A2.2 CR3A2.9 J3A2.3 L3A1.3 R3A7.2(B)
HDMID_BP_DATA2_DP: CR3A2.1 CR3A2.10 J3A2.1 L3A1.2 R3A6.2(B)
HDMID_CLK_DN: R3A13.1 R3A21.2(B) U3A3.4(PIN4)
HDMID_CLK_DP: R3A12.1 R3A20.2(B) U3A3.1
HDMID_CLK_R_DN: C3A15.2(B) R3A21.1 U3A5.H1
HDMID_CLK_R_DP: C3A15.1 R3A20.1 U3A5.H2
HDMID_HPD: Q2A1.2(S) R2A2.1 U3A5.G1
HDMID_LS_CEXT: C3A16.1 U3A5.F7
HDMID_LS_REXT: R3A40.1 R3A44.2(B) U3A5.C6
HDMID_SCL: CR2A1.1 CR2A1.10 J3A2.15 R2A3.2(B) U3A5.E1
HDMID_SDA: C2A10.1 CR2A1.4 CR2A1.7 J3A2.16 R2A5.2(B) U3A5.F1
HDMID_SINK: CR2A1.2 CR2A1.9 J3A2.19 R2A4.2(B)
HDMID_SINK_R: Q2A1.3 R2A4.1
HDMID_TX0_DN: R3A11.1 R3A19.2(B) U3A2.4(PIN4)
HDMID_TX0_DP: R3A10.1 R3A18.2(B) U3A2.1
HDMID_TX0_R_DN: C3A14.2(B) R3A19.1 U3A5.H3
HDMID_TX0_R_DP: C3A14.1 R3A18.1 U3A5.H4
HDMID_TX1_DN: R3A9.1 R3A17.2(B) U3A1.4(PIN4)
HDMID_TX1_DP: R3A8.1 R3A16.2(B) U3A1.1
HDMID_TX1_R_DN: C3A13.2(B) R3A17.1 U3A5.H5
HDMID_TX1_R_DP: C3A13.1 R3A16.1 U3A5.H6
HDMID_TX2_DN: L3A1.4(PIN4) R3A7.1 R3A15.2(B)
HDMID_TX2_DP: L3A1.1 R3A6.1 R3A14.2(B)
HDMID_TX2_R_DN: C3A12.2(B) R3A15.1 U3A5.H7
HDMID_TX2_R_DP: C3A12.1 R3A14.1 U3A5.H8
HOME_BTN_EC_N: R8F40.2(B) U8F6.126
HOME_BTN_N: C8F9.1 CR8F3.2(C2) R8F27.2(B) R8F40.1 SW8F1.1 SW8F1.2
HOME_BTN_PCH_N: CR8F3.3 R8F28.2(B) U6E1.AF47
HP_CONN_FB_DCPL_L: C5A11.1 R5A13.2(B)
HP_CONN_FB_DCPL_R: C5A8.1 R5A10.2(B)
HP_CONN_FB_L: FB5A2.1 R5A8.2(B) R5A13.1
HP_CONN_FB_R: FB5A3.1 R5A10.1 R5A14.2(B)
HP_CONN_L: C5A5.1 FB5A2.2(B) J5A1.2
HP_CONN_R: C5A6.1 FB5A3.2(B) J5A1.3
HP_JD_CONN: C5A4.1 J5A1.5 R5A2.2(B) R5A6.2(B)
HV_BP_VSEL_R: C5A30.1 Q6L1.1 R5A52.2(B) R5A55.2(B) R5A56.1
HV_VSEL_D: Q6L1.3 R6A81.1
I2C0_SDA_TCH_PAD_ECAIC: J6J2.185
I2C1_PD_INT_N: EU5A1.29 R5A45.2(B) R5A46.2(B)
I2C1_PD_SCL: EU5A1.27 R5A61.2(B) R5B6.2(B)
I2C1_PD_SDA: EU5A1.28 R5A62.2(B) R5B7.2(B)
I2C2_PD_INT_N: EU5A1.34 R5A29.2(B) R5A47.2(B)
I2C2_PD_SCL: EU5A1.32 R5A37.2(B) R5A38.2(B)
I2C2_PD_SDA: EU5A1.33 R5A32.2(B) R5A33.2(B)
I2C3_PD_SCL: EU5A1.21 R5A59.2(B) R6D9.1
I2C3_PD_SDA: EU5A1.22 R5A60.2(B) R5D8.1
I2C_ALERT_AIC_P1: J6J1.7 R6U2.1 R9G37.1
I2C_ALERT_AIC_P2: J6J1.9(IO9) R6T21.1 R9G29.1
I2C_ALERT_AIC_P2_EC_N: J6J2.29 Q8G8.3 R8G56.1 U8F6.118
I2C_ALERT_AICP2_TYPEC_PCH_N: Q6T1.2(S) R6T22.1 U6E1.U48
I2C_ALERT_BP_AICP1_TYPEC_PCH_N: Q6T2.2(S) R6F25.1 U6E1.L47
I2C_ALERT_PD1_EC_REV: Q9G4.2(S) R8G71.2(B) R9G37.2(B)
I2C_ALERT_PD1_PCH_REV: Q6T2.3 R6U1.2(B) R6U2.2(B)
I2C_ALERT_PD2_EC_REV: Q8G8.2(S) R9G29.2(B)
I2C_ALERT_PD2_PCH_REV: Q6T1.3 R6T21.2(B)
I2C_ALERT_TI988_AICP1_EC_N: J6J2.7 Q9G4.3 R8G68.1 U8F6.92
I2C_ALERT_TR_PD_N: R5A29.1 U5A2.M4
I2C_ALERT_USBC_PD_N: R5A45.1 R6U1.1 R8G71.1
I2C_LT_DCI_EN: R7C41.2(B) R7C45.1 U7D1.7(VREFB) U7D1.8
I2C_MODE_SEL: R9D19.2(B) R9D21.2(B) R9D23.1
I2C_SCL_EDP_ALS_R: J1B2.41 Q6G1.2(S) R6F38.2(B)
I2C_SDA_EDP_ALS_R: J1B2.42 Q6G2.2(S) R6F39.2(B)
I2S1_SCLK: R9A10.2(B) R9B10.1
I2S1_SCLK_POST1_I2S_BCLK: J9A4.15 R9B8.2(B) R9B10.2(B)
I2S1_SFRM: R9A20.2(B) R9A22.1 R9A24.1
I2S1_SFRM_POST1_I2S_LRCLK: J9A5.9(IO9) R9A24.2(B)
I2S1_SFRM_SNDW2_CLK: R7E14.1 U6E1.BD12
I2S1_SFRM_SNDW2_CLK_R: R7E14.2(B) R9A18.1 R9A20.1
I2S1_TXD: R8C31.2(B) R9B1.1
I2S1_TXD_SNDW2_DATA: R7E13.1 U6E1.BE12
I2S1_TXD_SNDW2_DATA_R: R7E13.2(B) R8C27.1 R8C31.1
I2S2_RXD: R7R12.1 R7R13.1 U6E1.AW18
I2S2_RXD_HDR: J9B4.5 R9B28.2(B)
I2S2_RXD_R: R7R12.2(B) R9B27.1 R9B28.1
I2S2_SCLK: R7R17.1 R7R18.1 U6E1.AV18
I2S2_SCLK_HDR: J9B4.1 R9B18.2(B)
I2S2_SCLK_R: R7R17.2(B) R9B18.1 R9B19.1
I2S2_SFRM: R7E16.1 U6E1.BE16
I2S2_SFRM_HDR: J9B4.2 R9B16.2(B)
I2S2_SFRM_R: R7E16.2(B) R9B16.1 R9B17.1
I2S2_TXD: R7R10.1 U6E1.BA17
I2S2_TXD_HDR: J9B4.4 R9B22.2(B)
I2S2_TXD_R: R7R10.2(B) R9B22.1 R9B23.1
I2S_MCLK: R9A16.2(B) R9A17.2(B) U6E1.AP29
I2S_MCLK_3P3V: R9A17.1 U9A1.4
I2S_MCLK_LS: R9A14.2(B) U9A1.3
I2S_MCLK_LS_R: R9A13.1 R9A14.1 R9A15.1 R9A16.1
I2S_MCLK_POST1_I2S_MCLK: J9A5.12 R8B6.2(B)
I2S_MCLK_R: R8B6.1 R9A15.2(B)
ISEN1P: ISO3B4.2(B<0>) R3M35.1
ISEN2P: ISO3B3.2(B<0>) R3M39.1
ISEN3P: ISO3B2.2(B<0>) R3M34.1
ISEN4P: ISO3B1.2(B<0>) R3M38.1
ISEN5P: ISO2B2.2(B<0>) R2M14.1
ISEN6P: ISO2B1.2(B<0>) R2M15.1
ISEN7P: ISO4B2.2(B<0>) R4M22.1
ISEN8P: ISO4B1.2(B<0>) R4M26.1
ISH_EEPROM_CLK: R7H52.2(B) U7H3.6
ISH_EEPROM_DATA: R7H53.2(B) U7H3.5
ISH_GP_0: R8H2.1 U6E1.BF35
ISH_GP_0_SNSR_HDR: J8H2.18 R8H2.2(B)
ISH_GP_1: R8H1.1 U6E1.BD34
ISH_GP_1_SNSR_HDR: J8H2.16 R8H1.2(B)
ISH_GP_2: R7H50.1 U6E1.BE34
ISH_GP_2_SNSR_HDR: J8H2.59 R7H50.2(B)
ISH_GP_3: R8H26.1 U6E1.BA33
ISH_GP_3_SNSR_HDR: J8H2.21 R8H26.2(B)
ISH_GP_4: R8H5.1 U6E1.AW32
ISH_GP_4_SNSR_HDR: J8H2.42 R8H5.2(B)
ISH_GP_5: R8H4.1 U6E1.AV34
ISH_GP_5_SNSR_HDR: J8H2.36 R8H4.2(B)
ISH_GP_6_SNSR_HDR: J8H2.20 R8H3.2(B)
ISH_GP_7_SNSR_HDR: J8H2.9(IO9) R8H25.2(B)
ISH_I2C0_LS_EN: R7H54.2(B) R7H55.2(B) U7H2.7(VREFB) U7H2.8
ISH_I2C0_SCL: R7H59.1 R7H60.2(B) R7V1.1 U6E1.AG45 U7H2.5
ISH_I2C0_SCL_LS: R7H48.1 R7H52.1 R7H62.2(B) R7V1.2(B) U7H2.4
ISH_I2C0_SCL_SNSR_HDR: J8H2.55 R7H48.2(B)
ISH_I2C0_SCL_TTK: J7G1.24 R7H59.2(B)
ISH_I2C0_SDA: R7H56.2(B) R7H58.1 R7V2.1 U6E1.AH46 U7H2.6
ISH_I2C0_SDA_LS: R7H49.1 R7H53.1 R7H66.2(B) R7V2.2(B) U7H2.3
ISH_I2C0_SDA_SNSR_HDR: J8H2.57 R7H49.2(B)
ISH_I2C0_SDA_TTK: J7G1.22 R7H58.2(B)
ISH_I2C1_LS_EN: R8G66.2(B) R8G67.2(B) U8G2.7(VREFB) U8G2.8
ISH_I2C1_SCL: Q6G2.3 R8G51.1 R8G54.2(B) U6E1.AH47 U8G2.5
ISH_I2C1_SCL_SNSR_HDR: J8H2.12 R8G49.2(B) R8G51.2(B) U8G2.4
ISH_I2C1_SDA: Q6G1.3 R8G50.1 R8G53.2(B) U6E1.AH48 U8G2.6
ISH_I2C1_SDA_SNSR_HDR: J8H2.10 R8G48.2(B) R8G50.2(B) U8G2.3
ISH_I2C2_LPSS_I2C3_SCL: C9B3.1 J9B2.3 R8H27.1 R8H30.1 R9B11.2(B) U6E1.BE14
ISH_I2C2_LPSS_I2C3_SDA: C9B2.1 J9B2.1 R8H28.1 R8H31.1 R9B7.2(B) U6E1.BE15
ISH_I2C2_SCL_SNSR_HDR: J8H2.23 R8H27.2(B)
ISH_I2C2_SDA_SNSR_HDR: J8H2.25 R8H28.2(B)
ISH_LPSS_GSPI2_CLK: R7R22.1 R7R23.1 R7R24.2(B) U6E1.BB20
ISH_LPSS_GSPI2_CS_N: R7R33.1 R7R34.1 R7R35.2(B) U6E1.BA20
ISH_LPSS_GSPI2_MISO_BSSB_CLK: R7R11.1 R7R20.2(B) R7R21.1 U6E1.BB16
ISH_LPSS_GSPI2_MOSI_BSSB_DI: R7R9.1 R7R14.2(B) R7R15.1 U6E1.AN18
ISH_SPI_CLK_SNSR_HDR: J8H2.44 R7R23.2(B)
ISH_SPI_CS_SNSR_HDR_N: J8H2.38 R7R33.2(B)
ISH_SPI_MISO_SNSR_HDR: J8H2.43 R7R11.2(B)
ISH_SPI_MOSI_SNSR_HDR: J8H2.41 R7R9.2(B)
ISH_UART0_CTS_HDR_N: J9D3.3 R8D59.2(B)
ISH_UART0_CTS_N: R8D59.1 R8D63.2(B) U6E1.BF14
ISH_UART0_ECAIC_RXD: J6J2.180
ISH_UART0_ECAIC_TXD: J6J2.196
ISH_UART0_RTS_GSPI2_CS1_N: R8D47.1 R8D49.2(B) R8D53.1 U6E1.AR18
ISH_UART0_RTS_HDR_N: J9D3.4 R8D53.2(B)
ISH_UART0_RXD_HDR: J9D3.1 R9D17.2(B)
ISH_UART0_RXD_SML0B_I2C2_SDA: R9D16.1 R9D17.1 R9D27.2(B) U6E1.BE17
ISH_UART0_TXD_HDR: J9D3.2 R9D18.2(B)
ISH_UART0_TXD_SML0B_I2C2_SCL: R9D12.1 R9D18.1 R9D29.2(B) U6E1.BF17
ISH_UART1_CTS_N: EU7H1.11 R7H29.2(B) R7H42.2(B)
ISH_UART1_CTS_SNSR_HDR_N: EU7H1.6 J8H2.56 R7H29.1
ISH_UART1_RTS_N: EU7H1.12 R7H31.2(B) R7H37.2(B)
ISH_UART1_RTS_SNSR_HDR_N: EU7H1.5 J8H2.54 R7H31.1
ISH_UART1_RXD: EU7H1.14 R7H26.2(B) R7H40.2(B)
ISH_UART1_RXD_SNSR_HDR: EU7H1.3 J8H2.60 R7H40.1
ISH_UART1_TXD: EU7H1.13 R7H33.2(B) R7H35.2(B)
ISH_UART1_TXD_SNSR_HDR: EU7H1.4 J8H2.58 R7H35.1
ISH_UART_VREF: J6J2.131 R6J8.2(B) R6J14.1
ITP_PMODE: R1C42.2(B) R1C45.1 R7D25.1 U6E1.AL3
J64EV_PN3_R697EV_PN1: J8J6.1 R8J11.1
KBC_CAPSLOCK: Q9G1.1 U8F6.35
KBC_DISABLE_N: J9E4.1 R9E19.2(B) U8E3.8
KBC_NUMLOCK: Q9G2.1 U8F6.70
KBC_SCANIN6: J6J2.221 R5J15.1
KBC_SCANIN7: J6J2.229 R5J17.1
KBC_SCANOUT14: J6J2.183 R5J8.1
KBC_SCANOUT15: J6J2.191 R5J10.1
KBC_SCANOUT<1>: J6J2.159 R5J19.2(B)
KBC_SCANOUT<2>: J6J2.158 R5J18.2(B)
KBC_SCANOUT<3>: J6J2.166 R5J20.2(B)
KBC_SCANOUT<4>: J6J2.174 R5J22.2(B)
KBC_SCANOUT<5>: J6J2.182 R5J9.1
KBC_SCANOUT<6>: J6J2.190 R5J11.1
KBC_SCANOUT<7>: J6J2.199 R5J12.1
KBC_SCANOUT<9>: J6J2.222 R5J14.1
KBC_SCANOUT<10>: J6J2.230 R5J16.1
KBC_SCANOUT<12>: J6J2.167 R5J21.2(B)
KBC_SCANOUT<13>: J6J2.175 R5J23.2(B)
KBC_SCROLLOCK: Q9G3.1 U8F6.106
KBCLK: R7J3.2(B) R7J7.1 U7H4.5
KBCLK_FB: C7J5.1 CRP7J1.3 J7J4.1 J7J6.5 R7J7.2(B)
KBDATA: R7J2.2(B) R7J6.1 U7H4.2
KBDATA_FB: C7J4.1 CRP7J1.1 J7J4.5(IO5) J7J6.1 R7J6.2(B)
L_BKLTCTL: R1B6.1 R1B7.1 U6E1.AU48
L_BKLTEN: C7F8.1 J1B2.37 R1B15.2(B) R1B16.1 R7F24.1 U6E1.AV46
L_BRIGHTNESS: J1B2.36 J1D1.1 R1B4.2(B) R1B5.2(B) R1B6.2(B)
L_VDDEN: C7T1.1 Q1C3.1 R1C26.1 R1C31.2(B) R7T10.1 U6E1.AV44
LAD_ESPI_IO_0: C7R7.1 R6U3.1 R7R57.2(B)
LAD_ESPI_IO_0_EC: R6U5.2(B) U8F6.59
LAD_ESPI_IO_0_EC_AIC: J6J2.227 R6U6.2(B)
LAD_ESPI_IO_0_HDR: J7J1.11 R6U4.2(B)
LAD_ESPI_IO_0_PCH: R7R57.1 U6E1.BB39
LAD_ESPI_IO_0_R: R6U3.2(B) R6U4.1 R6U5.1 R6U6.1
LAD_ESPI_IO_1: C7R3.1 R7R55.2(B) R7U4.1
LAD_ESPI_IO_1_EC: R7U23.2(B) U8F6.60
LAD_ESPI_IO_1_EC_AIC: J6J2.219 R7U24.2(B)
LAD_ESPI_IO_1_HDR: J7J1.10 R7U15.2(B)
LAD_ESPI_IO_1_PCH: R7R55.1 U6E1.AW37
LAD_ESPI_IO_1_R: R7U4.2(B) R7U15.1 R7U23.1 R7U24.1
LAD_ESPI_IO_2: C7R8.1 R7R61.2(B) R7U5.1
LAD_ESPI_IO_2_EC: R7U26.2(B) U8F6.61
LAD_ESPI_IO_2_EC_AIC: J6J2.211 R7U25.2(B)
LAD_ESPI_IO_2_HDR: J7J1.8 R7U16.2(B)
LAD_ESPI_IO_2_PCH: R7R61.1 U6E1.AV37
LAD_ESPI_IO_2_R: R7U5.2(B) R7U16.1 R7U25.1 R7U26.1
LAD_ESPI_IO_3: C7R5.1 R7R54.2(B) R7U9.1
LAD_ESPI_IO_3_EC: R7U29.2(B) U8F6.62
LAD_ESPI_IO_3_EC_AIC: J6J2.203 R7U28.2(B)
LAD_ESPI_IO_3_HDR: J7J1.7 R7U20.2(B)
LAD_ESPI_IO_3_PCH: R7R54.1 U6E1.BA38
LAD_ESPI_IO_3_R: R7U9.2(B) R7U20.1 R7U28.1 R7U29.1
LAN_1P0_CTRL: EU4B1.7 L4B1.1
LAN_DISABLE_R_N: EU4B1.3 R4B7.2(B) R4B13.1 R4B18.2(B) R8C32.2(B)
LAN_DISALBE_N: CR7F1.2 R7B22.1
LAN_FOX_ON: C6A26.1 R6A35.2(B) R6A40.2(B) R6A41.2(B) U6A3.2
LAN_FOX_TRCT1: C7A10.1 J7A1.7
LAN_FOX_TRCT2: C7A9.1 J7A1.1
LAN_FOX_TRCT3: C7A5.1 J7A1.6
LAN_FOX_TRCT4: C7A6.1 J7A1.12
LAN_LED0: EU4B1.26 R4A18.2(B)
LAN_LED0_R: C4A20.1 J4A2.32 R4A18.1
LAN_LED1: C4A19.1 EU4B1.27 J4A2.29
LAN_LED2: EU4B1.25 R4A19.2(B)
LAN_LED2_R: C4A21.1 J4A2.30(CATH1) R4A19.1
LAN_MDI0_DN: EU4B1.14 J4A2.21
LAN_MDI0_DN_FOX: EU7A2.9 EU7A3.46 J7A1.9
LAN_MDI0_DP: EU4B1.13 J4A2.20
LAN_MDI0_DP_FOX: EU7A2.7 EU7A3.45 J7A1.8
LAN_MDI1_DN: EU4B1.18 J4A2.23
LAN_MDI1_DN_FOX: EU7A2.3 EU7A3.49 J7A1.3
LAN_MDI1_DP: EU4B1.17 J4A2.22
LAN_MDI1_DP_FOX: EU7A2.1 EU7A3.48 J7A1.2
LAN_MDI2_DN: EU4B1.21 J4A2.25
LAN_MDI2_DN_FOX: EU7A1.9 EU7A3.52 J7A1.5
LAN_MDI2_DP: EU4B1.20 J4A2.24
LAN_MDI2_DP_FOX: EU7A1.7 EU7A3.51 J7A1.4
LAN_MDI3_DN: EU4B1.24 J4A2.27
LAN_MDI3_DN_FOX: EU7A1.3 EU7A3.55 J7A1.11
LAN_MDI3_DP: EU4B1.23 J4A2.26
LAN_MDI3_DP_FOX: EU7A1.1 EU7A3.54 J7A1.10
LAN_RBIAS_R2GND: EU4B1.12 R4A22.1
LAN_TESTEN: EU4B1.30 R4A25.2(B)
LAN_XTAL1_FOX: C7A8.2(B) EU7A3.41 Y7A1.3
LAN_XTAL2_FOX: EU7A3.40(XTAL_OUT) R7A7.2(B)
LAN_XTAL2_FOX_C: C7A7.2(B) R7A7.1 Y7A1.1
LAN_XTL_DN: EU4B1.9(XTAL_OUT) R4A24.1
LAN_XTL_DN_M3LN: C4A31.1 R4A24.2(B) Y4A2.3
LAN_XTL_DP: C4A30.1 EU4B1.10 Y4A2.1
LANPHYPC: R4B7.1 R7B26.1 U6E1.BF41
LANWAKE_N: EU4B1.2 R4B17.2(B) R7B15.1 R7B19.2(B)
LANWAKE_N_FOX: EU7A3.12 R6B10.2(B) R7B15.2(B)
LANWAKE_R_N: R7B18.2(B) R7B19.1 R7B23.2(B) R7B24.1
LANWAKE_SMC_WAKE_SCI_N: Q9F1.3 R7B23.1 R7B30.1 R8B19.2(B) R9F35.2(B) U6E1.BG44
LATCH_BKFEEDCUT_BASE_DRV1: Q8C13.6 Q8D5.1 R8D4.2(B)
LATCHED_BACKFEED_CUT: Q8D5.3 R4H21.1 R6J19.2(B) R7B3.1 R8D15.2(B) R9H7.1 R9H10.2(B)
LATCHED_BACKFEED_CUT_EC: J6J2.101 R6J19.1
LED_CAPS: CR9G1.2(C) Q9G1.3
LED_DRIVE: R6F22.2(B) R9H5.1 R9H12.2(B)
LED_DRIVE_BRD: Q8H5.2 R9H10.1 R9H12.1
LED_DRIVE_HDR: Q8H1.2 R9H5.2(B) R9H7.2(B)
LED_NUM: CR9G2.2(C) Q9G2.3
LED_SCROLL: CR9G3.2(C) Q9G3.3
LED_SEG0: DS8A1.3 DS8A1.8 DS8A2.5 DS8A3.10(G) DS8A4.10(G) R8L2.2(B) U8L1.4
LED_SEG1: DS8A1.5 DS8A2.3 DS8A2.8 DS8A3.9 DS8A4.9 R8L4.2(B) U8L1.5
LED_SEG2: DS8A1.10(G) DS8A2.10(G) DS8A3.3 DS8A3.8 DS8A4.5 R8L6.2(B) U8L1.6
LED_SEG3: DS8A1.9 DS8A2.9 DS8A3.5 DS8A4.3 DS8A4.8 R8L7.2(B) U8L1.7
LED_SEG4: DS8A1.1 DS8A2.1 DS8A3.1 DS8A4.1 U8L1.11
LED_SEG5: DS8A1.2 DS8A2.2 DS8A3.2 DS8A4.2 U8L1.12
LED_SEG6: DS8A1.4 DS8A2.4 DS8A3.4 DS8A4.4 U8L1.13
LED_SEG7: DS8A1.6 DS8A2.6 DS8A3.6 DS8A4.6 U8L1.14
LED_SEG8: DS8A1.7 DS8A2.7 DS8A3.7 DS8A4.7 U8L1.15
LEDD1: CR9G1.1 R9G26.2(B)
LEDD2: CR9G3.1 R9G28.2(B)
LEDD3: CR9G2.1 R9G27.2(B)
LFRAME_ESPI_CS0_EC_AIC_N: J6J2.187 R7U10.2(B)
LFRAME_ESPI_CS0_EC_N: R7U11.2(B) U8F6.58
LFRAME_ESPI_CS0_HDR_N: J7J1.3 R7U14.2(B)
LFRAME_ESPI_CS0_N: R7U12.1 R7U18.1 R7U19.2(B) U6E1.BE38
LFRAME_ESPI_CS0_R_N: R7U10.1 R7U11.1 R7U14.1 R7U18.2(B)
LINE1_L: C5A10.1 EU6A1.36
LINE1_R: C5A9.1 EU6A1.35
LPC_CLK1: R7U8.1 U6E1.BB34
LPC_CLK1_R: C7U1.1 R7U8.2(B) R7U17.1
LPC_ESPI_CLK: C7R4.1 R7R59.2(B) R7U13.1
LPC_ESPI_CLK_EC: R7U22.2(B) U8F6.57
LPC_ESPI_CLK_EC_AIC: J6J2.46 R7U21.2(B)
LPC_ESPI_CLK_HDR: J7J1.1 R7U17.2(B) R7U27.2(B)
LPC_ESPI_CLK_PCH: R7R59.1 U6E1.BB36
LPC_ESPI_CLK_R: R7U13.2(B) R7U21.1 R7U22.1 R7U27.1
LPC_ESPI_EC_DETECT: J6J2.11 R9G10.1 R9G14.2(B) U8F6.66
LPSS_GSPI0_CLK: R7E25.1 U6E1.BF29
LPSS_GSPI0_CLK_R: J9J2.1 R7E25.2(B) R9J13.2(B)
LPSS_GSPI0_CS0_N: R7R49.1 U6E1.BB26
LPSS_GSPI0_CS0_R_N: J9J2.2 R7R49.2(B) R9J12.2(B)
LPSS_GSPI0_CS1_N: R7E29.1 R7E30.1 U6E1.BE29
LPSS_GSPI0_CS1_R_N: J9J2.4 R7E29.2(B) R9J15.2(B)
LPSS_GSPI0_MISO: R7E27.1 U6E1.BD29
LPSS_GSPI0_MISO_R: J9J2.5 R7E27.2(B) R9J19.2(B)
LPSS_GSPI0_MOSI: R7E32.1 R7E33.2(B) R7E36.2(B) R7E37.1 R7E39.2(B) U6E1.BE30
LPSS_GSPI0_MOSI_HDR: J8J3.3(IO3) R7E36.1
LPSS_GSPI0_MOSI_R: J9J2.3 R7E32.2(B) R9J17.2(B)
LPSS_GSPI1_CLK: R7R38.1 U6E1.AU26
LPSS_GSPI1_CLK_R: J9H2.1 R7R38.2(B) R9H6.2(B)
LPSS_GSPI1_CS0_N: R7R39.1 U6E1.AW26
LPSS_GSPI1_CS0_R_N: J9H2.2 R7R39.2(B) R9H8.2(B)
LPSS_GSPI1_CS1_N: R7E44.1 R7E45.1 U6E1.BF33
LPSS_GSPI1_CS1_R_N: J9H2.4 R7E45.2(B) R9H11.2(B)
LPSS_GSPI1_MISO: R7E34.1 U6E1.BD30
LPSS_GSPI1_MISO_R: J9H2.5 R7E34.2(B) R9H14.2(B)
LPSS_GSPI1_MOSI: R7R40.1 R7R41.2(B) R7R42.2(B) R7R47.1 U6E1.BA26
LPSS_GSPI1_MOSI_R: J9H2.3 R7R40.2(B) R9H9.2(B)
LPSS_GSPI2_CLK_HDR: J9D5.1 R7R22.2(B)
LPSS_GSPI2_CS0_HDR_N: J9D5.2 R7R34.2(B)
LPSS_GSPI2_CS1_HDR_N: J9D5.4 R8D47.2(B)
LPSS_GSPI2_MISO_HDR: J9D5.5 R9D41.2(B)
LPSS_GSPI2_MOSI_HDR: J9D5.3 R9D39.2(B)
LPSS_I2C0_SCL: J9A3.3(IO3) R1E24.1 R8A22.2(B) U6E1.BC22
LPSS_I2C0_SDA: J9A3.1 R1E23.1 R8A23.2(B) U6E1.BF23
LPSS_I2C1_SCL: C8E19.1 J9B3.1 R8A13.2(B) R8E57.1 R8E62.1 U6E1.BE21
LPSS_I2C1_SCL_TCHPNL: Q8E7.3 R8E62.2(B)
LPSS_I2C1_SCL_USBC_PD: Q8E9.2(S) R8E57.2(B)
LPSS_I2C1_SDA: C8F1.1 J9B3.3 R8A12.2(B) R8F5.1 R8F8.1 U6E1.BF21
LPSS_I2C1_SDA_TCHPNL: Q8E6.3 R8F5.2(B)
LPSS_I2C1_SDA_USBC_PD: Q8E10.2(S) R8F8.2(B)
LPSS_I2C2_SCL_AUDIO: J9A5.1 R9D12.2(B)
LPSS_I2C2_SDA_AUDIO: J9A5.2 R9D16.2(B)
LPSS_I2C3_SCL_TCHPNL: Q8E8.3 R8H30.2(B)
LPSS_I2C3_SDA_TCHPNL: Q8E5.3 R8H31.2(B)
LPSS_ISH_UART1_CTS_N: R7H42.1 R7H43.1 R7H44.2(B) U6E1.BD21
LPSS_ISH_UART1_RTS_N: R7H36.1 R7H37.1 R7H38.2(B) U6E1.AW24
LPSS_ISH_UART1_RXD: R7H25.1 R7H26.1 R7H27.2(B) U6E1.AU24
LPSS_ISH_UART1_TXD: R7H32.1 R7H33.1 R7H34.2(B) U6E1.AP21
LPSS_UART0_CTS_N: R9J10.1 U6E1.AP24
LPSS_UART0_CTS_R_N: J9J1.3 R9J10.2(B) R9J11.2(B)
LPSS_UART0_RTS_N: R9J7.1 U6E1.BA24
LPSS_UART0_RTS_R_N: J9J1.4 R9J7.2(B) R9J8.2(B)
LPSS_UART0_RXD: R9J4.1 U6E1.BE23
LPSS_UART0_RXD_R: J9J1.1 R9J4.2(B) R9J5.2(B)
LPSS_UART0_TXD: R9J2.1 U6E1.BB24
LPSS_UART0_TXD_R: J9J1.2 R9J2.2(B) R9J3.2(B)
LPSS_UART1_CTS_HDR_N: J9H4.3 R7H43.2(B)
LPSS_UART1_RTS_HDR_N: J9H4.4 R7H36.2(B)
LPSS_UART1_RXD_HDR: J9H4.1 R7H25.2(B)
LPSS_UART1_TXD_HDR: J9H4.2 R7H32.2(B)
LPSS_UART2_CTS_N: R8R10.2(B) R8R11.1 R8R12.1 U6E1.AV21
LPSS_UART2_CTS_R_N: R8R12.2(B) U9C1.9
LPSS_UART2_CTS_TTK_N: J7G1.11 R8R11.2(B)
LPSS_UART2_RTS_N: R8R4.1 R8R5.1 R8R7.2(B) U6E1.AW21
LPSS_UART2_RTS_R_N: R8R5.2(B) U9C1.10
LPSS_UART2_RTS_TTK_N: J7G1.13 R8R4.2(B)
LPSS_UART2_RXD: R8R6.2(B) R8R8.1 R8R9.1 U6E1.BD20
LPSS_UART2_RXD_R: J9B6.3(IO3) R8R9.2(B)
LPSS_UART2_RXD_TTK: J7G1.7 R8R8.2(B)
LPSS_UART2_TXD: R8R1.1 R8R2.1 R8R3.2(B) U6E1.BE20
LPSS_UART2_TXD_R: J9B5.3(IO3) R8R2.2(B)
LPSS_UART2_TXD_TTK: J7G1.9(IO9) R8R1.2(B)
LS_PRE: EU2A7.27 R2A37.1
LS_REXT: EU2A7.36 R2A68.2(B)
LSPCON_VDD33_AUX: R3L2.2(B) U3A5.C5
M2_SSD_DAS_DSS: DS8H1.2(C) J8H1.10
M2_SSD_LED_PU: DS8H1.1 R8H6.2(B)
M2_SSD_PWREN: R7D16.2(B) R8G70.1 U6E1.AR3
M.2_BT_PCMCLK: J7C1.8 R9B19.2(B)
M.2_BT_PCMFRM_CRF_RST_N: J7C1.10 R7B82.1 R9B17.2(B)
M.2_BT_PCMIN: J7C1.12 R9B27.2(B)
M.2_BT_PCMOUT_CLKREQ0: J7C1.14 R7B79.1 R9B23.2(B)
M.2_BT_RF_KILL_N: J7C1.54(W_DISABLE2_N) Q7B8.3 R7B49.2(B) R7B50.1
M.2_BTWIFI_SUS_CLK: J7C1.50 R7F21.2(B)
M.2_CLINK_CLK_WLAN: J7C1.42 R7D15.2(B)
M.2_CLINK_DATA_WLAN: J7C1.40 R7D30.2(B)
M.2_CLINK_RST_WLAN_N: J7C1.38 R7D37.2(B)
M.2_REFCLK0: J7C1.64 R7B41.1 R7B45.1
M.2_SSD_P0_RX_DN: R8H14.1 U6E1.K43
M.2_SSD_P0_RX_DP: R8H15.1 U6E1.K44
M.2_SSD_P0_RX_R_DN: J8H1.43 R8H14.2(B)
M.2_SSD_P0_RX_R_DP: J8H1.41 R8H15.2(B)
M.2_SSD_P0_TX_C_DN: C8H10.2(B) R8H13.1 U8H1.4(PIN4)
M.2_SSD_P0_TX_C_DP: C8H9.2(B) R8H9.2(B) U8H1.1
M.2_SSD_P0_TX_CMC_DN: J8H1.47 R8H13.2(B) U8H1.3
M.2_SSD_P0_TX_CMC_DP: J8H1.49 R8H9.1 U8H1.2
M.2_SSD_P0_TX_DN: C8H10.1 U6E1.A42
M.2_SSD_P0_TX_DP: C8H9.1 U6E1.B42
M.2_SSD_P1_RX_DN: R8H18.1 U6E1.P41
M.2_SSD_P1_RX_DP: R8H17.1 U6E1.R40
M.2_SSD_P1_RX_R_DN: J8H1.29 R8H18.2(B)
M.2_SSD_P1_RX_R_DP: J8H1.31 R8H17.2(B)
M.2_SSD_P1_TX_C_DN: C8H12.2(B) R8H16.1 U8H2.4(PIN4)
M.2_SSD_P1_TX_C_DP: C8H11.2(B) R8H10.2(B) U8H2.1
M.2_SSD_P1_TX_CMC_DN: J8H1.35 R8H16.2(B) U8H2.3
M.2_SSD_P1_TX_CMC_DP: J8H1.37 R8H10.1 U8H2.2
M.2_SSD_P1_TX_DN: C8H12.1 U6E1.C42
M.2_SSD_P1_TX_DP: C8H11.1 U6E1.D42
M.2_SSD_P2_RX_DN: R8H21.1 U6E1.M44
M.2_SSD_P2_RX_DP: R8H20.1 U6E1.N42
M.2_SSD_P2_RX_R_DN: J8H1.17 R8H21.2(B)
M.2_SSD_P2_RX_R_DP: J8H1.19 R8H20.2(B)
M.2_SSD_P2_TX_C_DN: C8H14.2(B) R8H19.1 U8H3.4(PIN4)
M.2_SSD_P2_TX_C_DP: C8H13.2(B) R8H11.2(B) U8H3.1
M.2_SSD_P2_TX_CMC_DN: J8H1.23 R8H19.2(B) U8H3.3
M.2_SSD_P2_TX_CMC_DP: J8H1.25 R8H11.1 U8H3.2
M.2_SSD_P2_TX_DN: C8H14.1 U6E1.C44
M.2_SSD_P2_TX_DP: C8H13.1 U6E1.D43
M.2_SSD_P3_RX_DN: R8H24.1 U6E1.R35
M.2_SSD_P3_RX_DP: R8H23.1 U6E1.R37
M.2_SSD_P3_RX_R_DN: J8H1.5 R8H24.2(B)
M.2_SSD_P3_RX_R_DP: J8H1.7 R8H23.2(B)
M.2_SSD_P3_TX_C_DN: C8H16.2(B) R8H22.1 U8H4.4(PIN4)
M.2_SSD_P3_TX_C_DP: C8H15.2(B) R8H12.2(B) U8H4.1
M.2_SSD_P3_TX_CMC_DN: J8H1.11 R8H22.2(B) U8H4.3
M.2_SSD_P3_TX_CMC_DP: J8H1.13 R8H12.1 U8H4.2
M.2_SSD_P3_TX_DN: C8H16.1 U6E1.A44
M.2_SSD_P3_TX_DP: C8H15.1 U6E1.B44
M.2_SSD_PLN_IN_N: R8H46.2(B) U8H5.2
M.2_SSD_PLN_N: J8H1.8 R8H50.2(B) R8H51.2(B) R8H52.2(B)
M.2_SSD_PLN_R_N: R8H50.1 U8H5.7
M.2_SSD_SATA_PCIE_DET_N: J8H1.69 R7F51.2(B) R8H8.2(B) R8H77.2(B)
M.2_WIFI_RF_KILL_N: J7C1.56 Q7B7.3 R7B42.1 R7B46.2(B)
M_ACT_A_N: J1E5.62 J1F1.62 J3D1.AY30
M_ACT_B_N: J1F2.62 J1F3.62 J3D1.AP25
M_ALERT_A_N: J3D1.AY29 R3G3.2(B)
M_ALERT_A_N_R: J1E5.208 J1F1.208 R3G3.1 R3G5.2(B)
M_ALERT_B_N: J3D1.AP24 R3G2.2(B)
M_ALERT_B_N_R: J1F2.208 J1F3.208 R3G2.1 R3G4.2(B)
M_BA_A_0: J1E5.81 J1F1.81 J3D1.AY16
M_BA_A_1: J1E5.224 J1F1.224 J3D1.AW17
M_BA_B_0: J1F2.81 J1F3.81 J3D1.AP18
M_BA_B_1: J1F2.224 J1F3.224 J3D1.AN19
M_BG_A_0: J1E5.63 J1F1.63 J3D1.AV29
M_BG_A_1: J1E5.207 J1F1.207 J3D1.AW29
M_BG_B_0: J1F2.63 J1F3.63 J3D1.AM23
M_BG_B_1: J1F2.207 J1F3.207 J3D1.AM22
M_DATA_A<0>: J1E5.5 J1F1.5 J3D1.AE40
M_DATA_A<1>: J1E5.150 J1F1.150 J3D1.AF40
M_DATA_A<2>: J1E5.12 J1F1.12 J3D1.AH40
M_DATA_A<3>: J1E5.157 J1F1.157 J3D1.AH38
M_DATA_A<4>: J1E5.3 J1F1.3 J3D1.AE38
M_DATA_A<5>: J1E5.148 J1F1.148 J3D1.AE39
M_DATA_A<6>: J1E5.10 J1F1.10 J3D1.AG40
M_DATA_A<7>: J1E5.155 J1F1.155 J3D1.AH39
M_DATA_A<8>: J1E5.16 J1F1.16 J3D1.AK39
M_DATA_A<9>: J1E5.161 J1F1.161 J3D1.AL40
M_DATA_A<10>: J1E5.23 J1F1.23 J3D1.AN39
M_DATA_A<11>: J1E5.168 J1F1.168 J3D1.AN38
M_DATA_A<12>: J1E5.14 J1F1.14 J3D1.AK38
M_DATA_A<13>: J1E5.159 J1F1.159 J3D1.AK40
M_DATA_A<14>: J1E5.21 J1F1.21 J3D1.AM40
M_DATA_A<15>: J1E5.166 J1F1.166 J3D1.AN40
M_DATA_A<16>: J1E5.27 J1F1.27 J3D1.AT40
M_DATA_A<17>: J1E5.172 J1F1.172 J3D1.AU40
M_DATA_A<18>: J1E5.34 J1F1.34 J3D1.AW38
M_DATA_A<19>: J1E5.179 J1F1.179 J3D1.AR38
M_DATA_A<20>: J1E5.25 J1F1.25 J3D1.AR40
M_DATA_A<21>: J1E5.170 J1F1.170 J3D1.AR39
M_DATA_A<22>: J1E5.32 J1F1.32 J3D1.AV39
M_DATA_A<23>: J1E5.177 J1F1.177 J3D1.AV38
M_DATA_A<24>: J1E5.38 J1F1.38 J3D1.AY36
M_DATA_A<25>: J1E5.183 J1F1.183 J3D1.AY35
M_DATA_A<26>: J1E5.45 J1F1.45 J3D1.AY33
M_DATA_A<27>: J1E5.190 J1F1.190 J3D1.AW33
M_DATA_A<28>: J1E5.36 J1F1.36 J3D1.AV36
M_DATA_A<29>: J1E5.181 J1F1.181 J3D1.AW36
M_DATA_A<30>: J1E5.43 J1F1.43 J3D1.AY34
M_DATA_A<31>: J1E5.188 J1F1.188 J3D1.AV33
M_DATA_A<32>: J1E5.97 J1F1.97 J3D1.AW10
M_DATA_A<33>: J1E5.242 J1F1.242 J3D1.AW9
M_DATA_A<34>: J1E5.104 J1F1.104 J3D1.AY7
M_DATA_A<35>: J1E5.249 J1F1.249 J3D1.AV7
M_DATA_A<36>: J1E5.95 J1F1.95 J3D1.AW11
M_DATA_A<37>: J1E5.240 J1F1.240 J3D1.AV11
M_DATA_A<38>: J1E5.102 J1F1.102 J3D1.AY8
M_DATA_A<39>: J1E5.247 J1F1.247 J3D1.AW7
M_DATA_A<40>: J1E5.108 J1F1.108 J3D1.AW5
M_DATA_A<41>: J1E5.253 J1F1.253 J3D1.AY4
M_DATA_A<42>: J1E5.115 J1F1.115 J3D1.AV2
M_DATA_A<43>: J1E5.260 J1F1.260 J3D1.AV1
M_DATA_A<44>: J1E5.106 J1F1.106 J3D1.AV5
M_DATA_A<45>: J1E5.251 J1F1.251 J3D1.AY5
M_DATA_A<46>: J1E5.113 J1F1.113 J3D1.AW3
M_DATA_A<47>: J1E5.258 J1F1.258 J3D1.AW2
M_DATA_A<48>: J1E5.119 J1F1.119 J3D1.AT1
M_DATA_A<49>: J1E5.264 J1F1.264 J3D1.AR1
M_DATA_A<50>: J1E5.126 J1F1.126 J3D1.AN1
M_DATA_A<51>: J1E5.271 J1F1.271 J3D1.AN3
M_DATA_A<52>: J1E5.117 J1F1.117 J3D1.AT3
M_DATA_A<53>: J1E5.262 J1F1.262 J3D1.AT2
M_DATA_A<54>: J1E5.124 J1F1.124 J3D1.AP1
M_DATA_A<55>: J1E5.269 J1F1.269 J3D1.AN2
M_DATA_A<56>: J1E5.130 J1F1.130 J3D1.AL2
M_DATA_A<57>: J1E5.275 J1F1.275 J3D1.AK1
M_DATA_A<58>: J1E5.137 J1F1.137 J3D1.AH1
M_DATA_A<59>: J1E5.282 J1F1.282 J3D1.AH3
M_DATA_A<60>: J1E5.128 J1F1.128 J3D1.AL3
M_DATA_A<61>: J1E5.273 J1F1.273 J3D1.AL1
M_DATA_A<62>: J1E5.135 J1F1.135 J3D1.AJ1
M_DATA_A<63>: J1E5.280 J1F1.280 J3D1.AH2
M_DATA_A_CB<0>: J1E5.49 J1F1.49 J3D1.AL30
M_DATA_A_CB<1>: J1E5.194 J1F1.194 J3D1.AK30
M_DATA_A_CB<2>: J1E5.56 J1F1.56 J3D1.AL32
M_DATA_A_CB<3>: J1E5.201 J1F1.201 J3D1.AJ32
M_DATA_A_CB<4>: J1E5.47 J1F1.47 J3D1.AM31
M_DATA_A_CB<5>: J1E5.192 J1F1.192 J3D1.AM30
M_DATA_A_CB<6>: J1E5.54 J1F1.54 J3D1.AM32
M_DATA_A_CB<7>: J1E5.199 J1F1.199 J3D1.AK32
M_DATA_B<0>: J1F2.5 J1F3.5 J3D1.AD36
M_DATA_B<1>: J1F2.150 J1F3.150 J3D1.AE36
M_DATA_B<2>: J1F2.12 J1F3.12 J3D1.AG36
M_DATA_B<3>: J1F2.157 J1F3.157 J3D1.AG35
M_DATA_B<4>: J1F2.3 J1F3.3 J3D1.AD34
M_DATA_B<5>: J1F2.148 J1F3.148 J3D1.AD35
M_DATA_B<6>: J1F2.10 J1F3.10 J3D1.AF36
M_DATA_B<7>: J1F2.155 J1F3.155 J3D1.AG34
M_DATA_B<8>: J1F2.16 J1F3.16 J3D1.AJ35
M_DATA_B<9>: J1F2.161 J1F3.161 J3D1.AK36
M_DATA_B<10>: J1F2.23 J1F3.23 J3D1.AM35
M_DATA_B<11>: J1F2.168 J1F3.168 J3D1.AM34
M_DATA_B<12>: J1F2.14 J1F3.14 J3D1.AJ34
M_DATA_B<13>: J1F2.159 J1F3.159 J3D1.AJ36
M_DATA_B<14>: J1F2.21 J1F3.21 J3D1.AL36
M_DATA_B<15>: J1F2.166 J1F3.166 J3D1.AM36
M_DATA_B<16>: J1F2.27 J1F3.27 J3D1.AR36
M_DATA_B<17>: J1F2.172 J1F3.172 J3D1.AT36
M_DATA_B<18>: J1F2.34 J1F3.34 J3D1.AT33
M_DATA_B<19>: J1F2.179 J1F3.179 J3D1.AP33
M_DATA_B<20>: J1F2.25 J1F3.25 J3D1.AP36
M_DATA_B<21>: J1F2.170 J1F3.170 J3D1.AT35
M_DATA_B<22>: J1F2.32 J1F3.32 J3D1.AT34
M_DATA_B<23>: J1F2.177 J1F3.177 J3D1.AR33
M_DATA_B<24>: J1F2.38 J1F3.38 J3D1.AR31
M_DATA_B<25>: J1F2.183 J1F3.183 J3D1.AT30
M_DATA_B<26>: J1F2.45 J1F3.45 J3D1.AT28
M_DATA_B<27>: J1F2.190 J1F3.190 J3D1.AP28
M_DATA_B<28>: J1F2.36 J1F3.36 J3D1.AP31
M_DATA_B<29>: J1F2.181 J1F3.181 J3D1.AT31
M_DATA_B<30>: J1F2.43 J1F3.43 J3D1.AT29
M_DATA_B<31>: J1F2.188 J1F3.188 J3D1.AR28
M_DATA_B<32>: J1F2.97 J1F3.97 J3D1.AT11
M_DATA_B<33>: J1F2.242 J1F3.242 J3D1.AR12
M_DATA_B<34>: J1F2.104 J1F3.104 J3D1.AT10
M_DATA_B<35>: J1F2.249 J1F3.249 J3D1.AN10
M_DATA_B<36>: J1F2.95 J1F3.95 J3D1.AP12
M_DATA_B<37>: J1F2.240 J1F3.240 J3D1.AT12
M_DATA_B<38>: J1F2.102 J1F3.102 J3D1.AP10
M_DATA_B<39>: J1F2.247 J1F3.247 J3D1.AR10
M_DATA_B<40>: J1F2.108 J1F3.108 J3D1.AR8
M_DATA_B<41>: J1F2.253 J1F3.253 J3D1.AT7
M_DATA_B<42>: J1F2.115 J1F3.115 J3D1.AT5
M_DATA_B<43>: J1F2.260 J1F3.260 J3D1.AR5
M_DATA_B<44>: J1F2.106 J1F3.106 J3D1.AP8
M_DATA_B<45>: J1F2.251 J1F3.251 J3D1.AT8
M_DATA_B<46>: J1F2.113 J1F3.113 J3D1.AT6
M_DATA_B<47>: J1F2.258 J1F3.258 J3D1.AP5
M_DATA_B<48>: J1F2.119 J1F3.119 J3D1.AM5
M_DATA_B<49>: J1F2.264 J1F3.264 J3D1.AM6
M_DATA_B<50>: J1F2.126 J1F3.126 J3D1.AL5
M_DATA_B<51>: J1F2.271 J1F3.271 J3D1.AK7
M_DATA_B<52>: J1F2.117 J1F3.117 J3D1.AM8
M_DATA_B<53>: J1F2.262 J1F3.262 J3D1.AM7
M_DATA_B<54>: J1F2.124 J1F3.124 J3D1.AK6
M_DATA_B<55>: J1F2.269 J1F3.269 J3D1.AK5
M_DATA_B<56>: J1F2.130 J1F3.130 J3D1.AH7
M_DATA_B<57>: J1F2.275 J1F3.275 J3D1.AH6
M_DATA_B<58>: J1F2.137 J1F3.137 J3D1.AF7
M_DATA_B<59>: J1F2.282 J1F3.282 J3D1.AF6
M_DATA_B<60>: J1F2.128 J1F3.128 J3D1.AH8
M_DATA_B<61>: J1F2.273 J1F3.273 J3D1.AH5
M_DATA_B<62>: J1F2.135 J1F3.135 J3D1.AG5
M_DATA_B<63>: J1F2.280 J1F3.280 J3D1.AF5
M_DATA_B_CB<0>: J1F2.49 J1F3.49 J3D1.AK28
M_DATA_B_CB<1>: J1F2.194 J1F3.194 J3D1.AM27
M_DATA_B_CB<2>: J1F2.56 J1F3.56 J3D1.AL26
M_DATA_B_CB<3>: J1F2.201 J1F3.201 J3D1.AJ28
M_DATA_B_CB<4>: J1F2.47 J1F3.47 J3D1.AL28
M_DATA_B_CB<5>: J1F2.192 J1F3.192 J3D1.AM28
M_DATA_B_CB<6>: J1F2.54 J1F3.54 J3D1.AM26
M_DATA_B_CB<7>: J1F2.199 J1F3.199 J3D1.AK26
M_DQS_A_DN<0>: J1E5.152 J1F1.152 J3D1.AF38
M_DQS_A_DN<1>: J1E5.163 J1F1.163 J3D1.AL38
M_DQS_A_DN<2>: J1E5.174 J1F1.174 J3D1.AT38
M_DQS_A_DN<3>: J1E5.185 J1F1.185 J3D1.AV35
M_DQS_A_DN<4>: J1E5.244 J1F1.244 J3D1.AV9
M_DQS_A_DN<5>: J1E5.255 J1F1.255 J3D1.AV4
M_DQS_A_DN<6>: J1E5.266 J1F1.266 J3D1.AR3
M_DQS_A_DN<7>: J1E5.277 J1F1.277 J3D1.AK3
M_DQS_A_DN<8>: J1E5.196 J1F1.196 J3D1.AJ31
M_DQS_A_DP<0>: J1E5.153 J1F1.153 J3D1.AG38
M_DQS_A_DP<1>: J1E5.164 J1F1.164 J3D1.AM38
M_DQS_A_DP<2>: J1E5.175 J1F1.175 J3D1.AU38
M_DQS_A_DP<3>: J1E5.186 J1F1.186 J3D1.AV34
M_DQS_A_DP<4>: J1E5.245 J1F1.245 J3D1.AV8
M_DQS_A_DP<5>: J1E5.256 J1F1.256 J3D1.AV3
M_DQS_A_DP<6>: J1E5.267 J1F1.267 J3D1.AP3
M_DQS_A_DP<7>: J1E5.278 J1F1.278 J3D1.AJ3
M_DQS_A_DP<8>: J1E5.197 J1F1.197 J3D1.AJ30
M_DQS_B_DN<0>: J1F2.152 J1F3.152 J3D1.AE34
M_DQS_B_DN<1>: J1F2.163 J1F3.163 J3D1.AK34
M_DQS_B_DN<2>: J1F2.174 J1F3.174 J3D1.AP35
M_DQS_B_DN<3>: J1F2.185 J1F3.185 J3D1.AP30
M_DQS_B_DN<4>: J1F2.244 J1F3.244 J3D1.AN12
M_DQS_B_DN<5>: J1F2.255 J1F3.255 J3D1.AP7
M_DQS_B_DN<6>: J1F2.266 J1F3.266 J3D1.AL8
M_DQS_B_DN<7>: J1F2.277 J1F3.277 J3D1.AG8
M_DQS_B_DN<8>: J1F2.196 J1F3.196 J3D1.AJ26
M_DQS_B_DP<0>: J1F2.153 J1F3.153 J3D1.AF34
M_DQS_B_DP<1>: J1F2.164 J1F3.164 J3D1.AL34
M_DQS_B_DP<2>: J1F2.175 J1F3.175 J3D1.AP34
M_DQS_B_DP<3>: J1F2.186 J1F3.186 J3D1.AP29
M_DQS_B_DP<4>: J1F2.245 J1F3.245 J3D1.AN11
M_DQS_B_DP<5>: J1F2.256 J1F3.256 J3D1.AP6
M_DQS_B_DP<6>: J1F2.267 J1F3.267 J3D1.AK8
M_DQS_B_DP<7>: J1F2.278 J1F3.278 J3D1.AF8
M_DQS_B_DP<8>: J1F2.197 J1F3.197 J3D1.AJ27
M_MAA_A<0>: J1E5.79 J1F1.79 J3D1.AU18
M_MAA_A<1>: J1E5.72 J1F1.72 J3D1.AY25
M_MAA_A<2>: J1E5.216 J1F1.216 J3D1.AY24
M_MAA_A<3>: J1E5.71 J1F1.71 J3D1.AW25
M_MAA_A<4>: J1E5.214 J1F1.214 J3D1.AV25
M_MAA_A<5>: J1E5.213 J1F1.213 J3D1.AY26
M_MAA_A<6>: J1E5.69 J1F1.69 J3D1.AV26
M_MAA_A<7>: J1E5.211 J1F1.211 J3D1.AY27
M_MAA_A<8>: J1E5.68 J1F1.68 J3D1.AW27
M_MAA_A<9>: J1E5.66 J1F1.66 J3D1.AY28
M_MAA_A<10>: J1E5.225 J1F1.225 J3D1.AU17
M_MAA_A<11>: J1E5.210 J1F1.210 J3D1.AV27
M_MAA_A<12>: J1E5.65 J1F1.65 J3D1.AV28
M_MAA_A<13>: J1E5.232 J1F1.232 J3D1.AW14
M_MAA_A<14>: J1E5.228 J1F1.228 J3D1.AW16
M_MAA_A<15>: J1E5.86 J1F1.86 J3D1.AU16
M_MAA_A<16>: J1E5.82 J1F1.82 J3D1.AV16
M_MAA_B<0>: J1F2.79 J1F3.79 J3D1.AP19
M_MAA_B<1>: J1F2.72 J1F3.72 J3D1.AP20
M_MAA_B<2>: J1F2.216 J1F3.216 J3D1.AR20
M_MAA_B<3>: J1F2.71 J1F3.71 J3D1.AM20
M_MAA_B<4>: J1F2.214 J1F3.214 J3D1.AP21
M_MAA_B<5>: J1F2.213 J1F3.213 J3D1.AN21
M_MAA_B<6>: J1F2.69 J1F3.69 J3D1.AR22
M_MAA_B<7>: J1F2.211 J1F3.211 J3D1.AM21
M_MAA_B<8>: J1F2.68 J1F3.68 J3D1.AP22
M_MAA_B<9>: J1F2.66 J1F3.66 J3D1.AN23
M_MAA_B<10>: J1F2.225 J1F3.225 J3D1.AR18
M_MAA_B<11>: J1F2.210 J1F3.210 J3D1.AP23
M_MAA_B<12>: J1F2.65 J1F3.65 J3D1.AR24
M_MAA_B<13>: J1F2.232 J1F3.232 J3D1.AP15
M_MAA_B<14>: J1F2.228 J1F3.228 J3D1.AP17
M_MAA_B<15>: J1F2.86 J1F3.86 J3D1.AP16
M_MAA_B<16>: J1F2.82 J1F3.82 J3D1.AM18
M_ODT_A<0>: J1E5.87 J3D1.AY14
M_ODT_A<1>: J1E5.91 J3D1.AV14
M_ODT_A<2>: J1F1.87 J3D1.AU14
M_ODT_A<3>: J1F1.91 J3D1.AT14
M_ODT_B<0>: J1F2.87 J3D1.AM17
M_ODT_B<1>: J1F2.91 J3D1.AP14
M_ODT_B<2>: J1F3.87 J3D1.AM16
M_ODT_B<3>: J1F3.91 J3D1.AM14
M_PARITY_A: J1E5.222 J1F1.222 J3D1.AV18
M_PARITY_B: J1F2.222 J1F3.222 J3D1.AM19
M_SCKE_A<0>: J1E5.60 J3D1.AY31
M_SCKE_A<1>: J1E5.203 J3D1.AW31
M_SCKE_A<2>: J1F1.60 J3D1.AV30
M_SCKE_A<3>: J1F1.203 J3D1.AV31
M_SCKE_B<0>: J1F2.60 J3D1.AT25
M_SCKE_B<1>: J1F2.203 J3D1.AR26
M_SCKE_B<2>: J1F3.60 J3D1.AT26
M_SCKE_B<3>: J1F3.203 J3D1.AP26
M_SCS_A_N<0>: J1E5.84 J3D1.AY15
M_SCS_A_N<1>: J1E5.89 J3D1.AY13
M_SCS_A_N<2>: J1F1.84 J3D1.AV15
M_SCS_A_N<3>: J1F1.89 J3D1.AV13
M_SCS_B_N<0>: J1F2.84 J3D1.AN17
M_SCS_B_N<1>: J1F2.89 J3D1.AN15
M_SCS_B_N<2>: J1F3.84 J3D1.AR16
M_SCS_B_N<3>: J1F3.89 J3D1.AM15
ME_LED_DRV: DS8H2.2(C) EU8H1.6
MECC_BC_ACOK_DSW: J6J2.112 R6J21.1
MECC_PMC_ALERT_N: J6J2.165
MECC_SLP_LAN_N: J6J2.104 R6J20.1
MECC_SLP_WLAN_N: J6J2.106 R6J12.1
MECC_STD_ADP_PRSNT: J6J2.232
MIC2-L_RING2: EU6A1.32 R6A6.1 R6A12.2(B)
MIC2-L_RING2_R: R5A1.1 R6A6.2(B) R6A8.2(B)
MIC2-R_SLEEVE: EU6A1.33 R6A1.2(B) R6A5.1 R6A11.2(B)
MIC2-R_SLEEVE_R: R5A9.1 R6A5.2(B) R6A7.2(B)
MIC2-VREFO-L: R5A4.1 R6A2.2(B) R6A16.2(B)
MIC2-VREFO-R: R5A15.1 R6A14.2(B) R6A15.2(B)
MLK_CLK: R7D14.1 R7D15.1 U6E1.AR2
MLK_CLK_HDR: J7H1.7 R7D14.2(B)
MLK_DATA: R7D29.1 R7D30.1 U6E1.AT5
MLK_DATA_HDR: J7H1.3 R7D29.2(B)
MLK_RST_N: R7D36.1 R7D37.1 U6E1.AU4
MLK_RST_N_HDR: J7H1.4 R7D36.2(B) R7H61.1
MLK_RST_N_HDR_R: R6H19.1 R7H61.2(B)
MPHY_RCOMPN: R6E1.2(B) U6E1.B12
MPHY_RCOMPP: R6E1.1 U6E1.A13
MRESET_TR: R6T7.2(B) U6E1.AC43
MRESET_TR_AIC: J6J1.6 R6T7.1 R6T9.1
MSCLK: R7J5.2(B) R7J9.1 U7H4.9
MSCLK_FB: C7J2.1 CRP7J1.6 J7J6.11 R7J9.2(B)
MSDATA: R7J4.2(B) R7J8.1 U7H4.6
MSDATA_FB: C7J6.1 CRP7J1.4 J7J6.7 R7J8.2(B)
NET_CLR_CMOS_JUMPER: J8J9.3(IO3) R8J22.1
NET_CLR_RTC_JUMPER: J9E6.3(IO3) R9E27.1
NMI_GATE_SLG_INPUT: EU8F1.2 R8F17.2(B)
NPN_EC_AMP_PD_BASE: Q8B2.1 R8B2.2(B)
NPN_RESETO_BASE: Q8B1.1 R8B1.2(B)
OE_N: EU8G3.9 R8G60.2(B) R8G61.1
PA_HPD_SCL: R5A30.2(B) R5A39.2(B) R5A41.1 U5A2.T2
PA_USB2_MXCTL: R5A34.1 U5A2.R2
PA_USB2_RBIAS: R5L5.1 U5A2.H19
PB_HPD_SDA: R5L9.1 R5L11.2(B) R5L12.2(B) U5A2.T1
PB_USB2_MXCTL: R5A35.1 U5A2.R1
PB_USB2_RBIAS: R5L3.1 U5A2.F19
PCA9555_RST_N: R8E36.2(B) U8E3.1
PCH_2_CPU_TRIGGER: J3D1.E12 R7D47.1
PCH_2_CPU_TRIGGER_R: R7D47.2(B) U6E1.AK3
PCH_CODEC_PWR_EN: R6A20.1 R6A25.1 U6E1.AE48
PCH_CONFIG_JUMPER: J8J3.1 R7T16.1 R8H76.1
PCH_CPU_BCLK_DN: R5E25.1 U6E1.C8
PCH_CPU_BCLK_DP: R5E29.1 U6E1.B8
PCH_CPU_BCLK_R_DN: J3D1.T1 R5E25.2(B)
PCH_CPU_BCLK_R_DP: J3D1.U1 R5E29.2(B)
PCH_CPU_NSSC_CLK_DN: R5E15.1 U6E1.C6
PCH_CPU_NSSC_CLK_DP: R5E19.1 U6E1.D7
PCH_CPU_PCIBCLK_DN: R5E5.1 U6E1.B6
PCH_CPU_PCIBCLK_DP: R5E8.1 U6E1.A6
PCH_CPU_PCIBCLK_R_DN: J3D1.T3 R5E5.2(B)
PCH_CPU_PCIBCLK_R_DP: J3D1.T4 R5E8.2(B)
PCH_DPWROK: C8D17.1 J8J13.25 Q7F1.1 R7R58.1 R8D8.2(B) R8D21.1 R8D42.2(B) R8D43.2(B) R8D46.1 R8F16.1 R9F16.2(B) TP7R1.1(TP)
PCH_DPWROK_SLG_IN: EU8F1.3 R8F16.2(B)
PCH_HOT_N: C9G3.1 R5J8.2(B) R7E46.1 R9G20.2(B) U8F6.77
PCH_HOT_R_N: R7E42.2(B) R7E43.1 R7E46.2(B) U6E1.BD33
PCH_INTRUDER_HDR_N: J9F3.1 R7R60.2(B) U6E1.BB44
PCH_JTAG_TCK: R1C35.2(B) R7D33.1 U6E1.AJ3
PCH_JTAG_TDI: R1C28.2(B) R7D27.2(B) U6E1.AH2
PCH_JTAG_TDO: R1C30.2(B) R7D26.2(B) U6E1.AH3
PCH_JTAG_TMS: R1C27.2(B) R7D22.2(B) U6E1.AJ4
PCH_JTAG_TRST_N: R1C29.2(B) U6E1.AM4
PCH_JTAGX: R1C34.2(B) U6E1.AH4
PCH_PCIESLOT2_PWREN: R8C2.1 U6E1.AD47
PCH_PCIESLOT3_PWREN: R8B41.1 U6E1.AR48
PCH_PECI: R7D24.2(B) R7D39.1 U6E1.AF2
PCH_PEGSLOT_PWREN: R6B13.1 U6E1.L48
PCH_PLN_DELAY_EN: Q8H3.1 R8H38.1 U6E1.AE44
PCH_PLN_DELAY_SEL: R6F6.2(B) R8H42.1
PCH_PLN_DELAY_SEL_LED_DRIVE: R6F2.2(B) R6F6.1 R6F22.1 U6E1.AJ47
PCH_PLN_DELAY_SEL_R: R8H42.2(B) U8H5.3
PCH_PORT80_LED: R7E21.2(B) R7E22.1 R8H73.1 U6E1.BE25
PCH_PRDY_N: R1C99.2(B) R7D12.2(B) U6E1.AM5
PCH_PREQ_N: R1C102.2(B) R7D18.2(B) U6E1.AL2
PCH_PS_ON_B_1G97_5: R8D72.2(B) U8D9.6
PCH_PWROK: C7R6.1 J8J6.2 J8J13.26 Q7C1.5 R8C35.1 R8C40.2(B) TP8J1.1(TP) U6E1.AY42
PCH_PWROK_EC: J6J2.32 R6J26.2(B) R9G11.1 R9G17.2(B) U8F6.73
PCH_PWROK_N: Q7C1.2 Q7C1.3 R7C6.2(B)
PCH_RSMRST_AND_N: R8D91.1 U8D13.4(Y)
PCH_RSMRST_EC_AND_N: J6J2.231 R8D92.1 U8D13.2 U8F6.12
PCH_RSMRST_EC_N: R8D91.2(B) R8D92.2(B) R9F8.2(B)
PCH_RSMRST_N: C9F1.1 J8J13.3 R1C47.1 R4H48.1 R6H22.2(B) R7F7.1 R7U30.1 R8D21.2(B) R9F8.1 R9F11.2(B) TP9F2.1(TP)
PCH_RST_GPIO: R8D61.1 U6E1.V48
PCH_RTCRST_PULLUP: C7R9.1 J8J9.2 J8J13.17 R7H11.1 R7R62.2(B) TP7R2.1(TP) U6E1.BE47
PCH_RTCX1: C7F6.1 R7F11.2(B) R7F15.2(B) U6E1.BA49
PCH_RTCX1_XTAL: R7F15.1 Y7F1.1
PCH_RTCX2: C7F5.1 R7F11.1 R7F14.2(B) U6E1.BA48
PCH_RTCXO_XTAL: R7F14.1 Y7F1.2
PCH_SATA1_PWR_EN: R6J32.2(B) U6E1.AJ46 U6J1.2
PCH_SATA2_PWR_EN: R8H70.2(B) U6E1.R47
PCH_SATA2_PWR_EN_R: J8H6.3 R8H66.2(B) R8H70.1
PCH_SATA3_PWR_EN: R8H69.2(B) U6E1.P48
PCH_SATA3_PWR_EN_R: J8H6.2 R8H65.2(B) R8H69.1
PCH_SATA_LED_BJT2: Q9G6.5 Q9G6.6 R9G40.2(B)
PCH_SATA_LED_N: Q9G6.2 R9G35.2(B) R9G36.2(B) R9G38.2(B) R9G39.2(B)
PCH_SLP_A_APS_N: J9H3.6 R9H19.1
PCH_SLP_A_N: C8H22.1 EU8H1.9 J8J10.2 J8J13.24 R8E17.1 R8H55.1 R9H19.2(B) U6E1.BE40
PCH_SLP_S0_N: R7E26.2(B) U6E1.BC28
PCH_SPI_OE_N: Q7G1.3 R7G14.2(B) U7G1.1(OE_N) U7G1.4 U7G1.10 U7G1.13 U7G2.1(OE_N) U7G2.4 U7G2.10
PCH_SPKR_AMP_PD_N: CR8A1.1(CATHODE) Q8B2.2(E) R8A30.1 U6E1.AV7
PCH_SRTCRST_N: C7F7.1 J8J13.28 J9E6.2 R7F23.2(B) TP8J2.1(TP) U6E1.BD46
PCH_SUSCLK: R7F17.1 R7F18.1 R7F19.1 R7F20.1 R7F21.1 R7F22.1 U6E1.BE45
PCH_SYSPWROK: C7D2.1 J8J13.36 Q8C12.3 R1C37.1 R8C66.2(B) R8C67.2(B) R8C80.2(B) R8D1.2(B) R9G17.1 TP9G1.1(TP) U6E1.AU3
PCH_THERMTRIP_N: R4D5.1 R4D8.2(B) R6D49.1
PCH_THERMTRIP_R_N: R6D49.2(B) U6E1.AD3
PCH_WAKE_N: R5A63.1 R5B53.1 R5C13.1 R7B18.1 R7B27.2(B) R7F48.2(B) R7F49.2(B) R8B22.2(B) R8B24.2(B) R8G79.2(B) U6E1.BB47
PCHXDP_PM_RSMRST_N: J6H2.39 R6H22.1
PCIE3_LAN_FOX_RX_C_DN: C6A47.2(B) EU7A3.24
PCIE3_LAN_FOX_RX_C_DP: C6A42.2(B) EU7A3.25
PCIE3_LAN_FOX_RX_DN: C6A47.1 U6E1.K18
PCIE3_LAN_FOX_RX_DP: C6A42.1 U6E1.J18
PCIE3_LAN_FOX_TX_C_DN: C6A41.2(B) EU7A3.27
PCIE3_LAN_FOX_TX_C_DP: C6A38.2(B) EU7A3.28
PCIE3_LAN_FOX_TX_DN: C6A41.1 U6E1.B19
PCIE3_LAN_FOX_TX_DP: C6A38.1 U6E1.C19
PCIE4_M.2_WLAN_RX_DN: R7B66.1 U6E1.N18
PCIE4_M.2_WLAN_RX_DP: R7B70.1 U6E1.R18
PCIE4_M.2_WLAN_RX_R_DN: J7C1.43 R7B66.2(B)
PCIE4_M.2_WLAN_RX_R_DP: J7C1.41 R7B70.2(B)
PCIE4_M.2_WLAN_TX_C_DN: C7B16.2(B) J7C1.37
PCIE4_M.2_WLAN_TX_C_DP: C7B17.2(B) J7C1.35
PCIE4_M.2_WLAN_TX_DN: C7B16.1 U6E1.D20
PCIE4_M.2_WLAN_TX_DP: C7B17.1 U6E1.C20
PCIE5_TR_RX_C_DN: C4B1.1 U5A2.Y22
PCIE5_TR_RX_C_DP: C4A35.1 U5A2.Y23
PCIE5_TR_RX_DN: C4A33.1 R6E3.2(B)
PCIE5_TR_RX_DP: C4A32.1 R6E4.2(B)
PCIE5_TR_TX_C_DN: C4A33.2(B) U5A2.V22
PCIE5_TR_TX_C_DP: C4A32.2(B) U5A2.V23
PCIE5_TR_TX_DN: C4B1.2(B) R5E18.2(B)
PCIE5_TR_TX_DP: C4A35.2(B) R5E22.2(B)
PCIE5_TR_U2_RX_DN: R6E2.1 R6E3.1 U6E1.F20
PCIE5_TR_U2_RX_DP: R6E4.1 R6E5.1 U6E1.G20
PCIE5_TR_U2_TX_DN: R5E17.1 R5E18.1 U6E1.B21
PCIE5_TR_U2_TX_DP: R5E21.1 R5E22.1 U6E1.A22
PCIE5_U2_R_RX_DN: J5H1.B5 R5G33.2(B)
PCIE5_U2_R_RX_DP: J5H1.B4 R5G34.2(B)
PCIE5_U2_R_TX_DN: C5G17.1 J5H1.D5
PCIE5_U2_R_TX_DP: C5G16.1 J5H1.D4
PCIE5_U2_RX_DN: R5G33.1 R6E2.2(B)
PCIE5_U2_RX_DP: R5G34.1 R6E5.2(B)
PCIE5_U2_TX_DN: C5G17.2(B) R5E17.2(B)
PCIE5_U2_TX_DP: C5G16.2(B) R5E21.2(B)
PCIE6_TR_RX_C_DN: C4A28.1 U5A2.T22
PCIE6_TR_RX_C_DP: C4A23.1 U5A2.T23
PCIE6_TR_RX_DN: C4A18.1 R6E9.2(B)
PCIE6_TR_RX_DP: C4A17.1 R6E6.2(B)
PCIE6_TR_TX_C_DN: C4A18.2(B) U5A2.P22
PCIE6_TR_TX_C_DP: C4A17.2(B) U5A2.P23
PCIE6_TR_TX_DN: C4A28.2(B) R5E32.2(B)
PCIE6_TR_TX_DP: C4A23.2(B) R5E27.2(B)
PCIE6_TR_U2_RX_DN: R6E8.1 R6E9.1 U6E1.K21
PCIE6_TR_U2_RX_DP: R6E6.1 R6E7.1 U6E1.J21
PCIE6_TR_U2_TX_DN: R5E31.1 R5E32.1 U6E1.D21
PCIE6_TR_U2_TX_DP: R5E27.1 R5E28.1 U6E1.C21
PCIE6_U2_R_RX_DN: J5H1.A5 R5H2.2(B)
PCIE6_U2_R_RX_DP: J5H1.A4 R5H3.2(B)
PCIE6_U2_R_TX_DN: C5G21.1 J5H1.C5
PCIE6_U2_R_TX_DP: C5G20.1 J5H1.C4
PCIE6_U2_RX_DN: R5H2.1 R6E8.2(B)
PCIE6_U2_RX_DP: R5H3.1 R6E7.2(B)
PCIE6_U2_TX_DN: C5G21.2(B) R5E31.2(B)
PCIE6_U2_TX_DP: C5G20.2(B) R5E28.2(B)
PCIE7_TR_RX_C_DN: C4A16.1 U5A2.M22
PCIE7_TR_RX_C_DP: C4A15.1 U5A2.M23
PCIE7_TR_RX_DN: C4A13.1 R6E14.2(B)
PCIE7_TR_RX_DP: C4A14.1 R6E16.2(B)
PCIE7_TR_TX_C_DN: C4A13.2(B) U5A2.K22
PCIE7_TR_TX_C_DP: C4A14.2(B) U5A2.K23
PCIE7_TR_TX_DN: C4A16.2(B) R5E36.2(B)
PCIE7_TR_TX_DP: C4A15.2(B) R5E33.2(B)
PCIE7_TR_U2_RX_DN: R6E14.1 R6E15.1 U6E1.L24
PCIE7_TR_U2_RX_DP: R6E16.1 R6E17.1 U6E1.J24
PCIE7_TR_U2_TX_DN: R5E35.1 R5E36.1 U6E1.C23
PCIE7_TR_U2_TX_DP: R5E33.1 R5E34.1 U6E1.B23
PCIE7_U2_R_RX_DN: J5H1.B8 R5G29.2(B)
PCIE7_U2_R_RX_DP: J5H1.B7 R5G30.2(B)
PCIE7_U2_R_TX_DN: C5G19.1 J5H1.D8
PCIE7_U2_R_TX_DP: C5G18.1 J5H1.D7
PCIE7_U2_RX_DN: R5G29.1 R6E15.2(B)
PCIE7_U2_RX_DP: R5G30.1 R6E17.2(B)
PCIE7_U2_TX_DN: C5G19.2(B) R5E35.2(B)
PCIE7_U2_TX_DP: C5G18.2(B) R5E34.2(B)
PCIE8_TR_RX_C_DN: C4A12.1 U5A2.H22
PCIE8_TR_RX_C_DP: C4A11.1 U5A2.H23
PCIE8_TR_RX_DN: C4A9.1 R6E12.2(B)
PCIE8_TR_RX_DP: C4A10.1 R6E11.2(B)
PCIE8_TR_TX_C_DN: C4A9.2(B) U5A2.F22
PCIE8_TR_TX_C_DP: C4A10.2(B) U5A2.F23
PCIE8_TR_TX_DN: C4A12.2(B) R5E38.2(B)
PCIE8_TR_TX_DP: C4A11.2(B) R5E40.2(B)
PCIE8_TR_U2_RX_DN: R6E12.1 R6E13.1 U6E1.F24
PCIE8_TR_U2_RX_DP: R6E10.1 R6E11.1 U6E1.G24
PCIE8_TR_U2_TX_DN: R5E37.1 R5E38.1 U6E1.B24
PCIE8_TR_U2_TX_DP: R5E39.1 R5E40.1 U6E1.C24
PCIE8_U2_R_RX_DN: J5H1.A8 R5G35.2(B)
PCIE8_U2_R_RX_DP: J5H1.A7 R5H1.2(B)
PCIE8_U2_R_TX_DN: C5G23.1 J5H1.C8
PCIE8_U2_R_TX_DP: C5G22.1 J5H1.C7(TX3_P)
PCIE8_U2_RX_DN: R5G35.1 R6E13.2(B)
PCIE8_U2_RX_DP: R5H1.1 R6E10.2(B)
PCIE8_U2_TX_DN: C5G23.2(B) R5E37.2(B)
PCIE8_U2_TX_DP: C5G22.2(B) R5E39.2(B)
PCIE9_SLOT3_RX_DN: R8B37.2(B) U6E1.G36
PCIE9_SLOT3_RX_DP: R8B35.2(B) U6E1.F36
PCIE9_SLOT3_RX_R_DN: J8B1.A17 R8B37.1
PCIE9_SLOT3_RX_R_DP: J8B1.A16 R8B35.1
PCIE9_SLOT3_TX_C_DN: C8B30.2(B) J8B1.B15
PCIE9_SLOT3_TX_C_DP: C8B28.2(B) J8B1.B14
PCIE9_SLOT3_TX_DN: C8B30.1 U6E1.C34
PCIE9_SLOT3_TX_DP: C8B28.1 U6E1.D34
PCIE10_SLOT3_RX_DN: R8C6.2(B) U6E1.K37
PCIE10_SLOT3_RX_DP: R8C3.2(B) U6E1.J37
PCIE10_SLOT3_RX_R_DN: J8B1.A22 R8C6.1
PCIE10_SLOT3_RX_R_DP: J8B1.A21 R8C3.1
PCIE10_SLOT3_TX_C_DN: C8C1.2(B) J8B1.B20
PCIE10_SLOT3_TX_C_DP: C8B37.2(B) J8B1.B19
PCIE10_SLOT3_TX_DN: C8C1.1 U6E1.C35
PCIE10_SLOT3_TX_DP: C8B37.1 U6E1.B35
PCIE11_SLOT3_RX_DN: R8C17.2(B) U6E1.G38
PCIE11_SLOT3_RX_DP: R8C14.2(B) U6E1.F39
PCIE11_SLOT3_RX_R_DN: J8B1.A26 R8C17.1
PCIE11_SLOT3_RX_R_DP: J8B1.A25 R8C14.1
PCIE11_SLOT3_TX_C_DN: C8C10.2(B) J8B1.B24
PCIE11_SLOT3_TX_C_DP: C8C7.2(B) J8B1.B23
PCIE11_SLOT3_TX_DN: C8C10.1 U6E1.B36
PCIE11_SLOT3_TX_DP: C8C7.1 U6E1.C36
PCIE12_SLOT3_RX_DN: R8C23.2(B) U6E1.H42
PCIE12_SLOT3_RX_DP: R8C21.2(B) U6E1.J41
PCIE12_SLOT3_RX_R_DN: J8B1.A30 R8C23.1
PCIE12_SLOT3_RX_R_DP: J8B1.A29 R8C21.1
PCIE12_SLOT3_TX_C_DN: C8C14.2(B) J8B1.B28
PCIE12_SLOT3_TX_C_DP: C8C12.2(B) J8B1.B27
PCIE12_SLOT3_TX_DN: C8C14.1 U6E1.D38
PCIE12_SLOT3_TX_DP: C8C12.1 U6E1.E37
PCIE13_LAN_RX_C_DN: C4B10.2(B) EU4B1.39
PCIE13_LAN_RX_C_DP: C4B9.2(B) EU4B1.38
PCIE13_LAN_RX_DN: C4B10.1 U6E1.C45
PCIE13_LAN_RX_DP: C4B9.1 U6E1.C46
PCIE13_LAN_TX_C_DN: C4B12.2(B) EU4B1.42
PCIE13_LAN_TX_C_DP: C4B11.2(B) EU4B1.41
PCIE13_LAN_TX_DN: C4B12.1 U6E1.B38
PCIE13_LAN_TX_DP: C4B11.1 U6E1.C38
PCIE14_SATA1B_RX_DN: C6G12.1 R6G10.1 U6E1.D46
PCIE14_SATA1B_RX_DP: C6G11.1 R6G9.1 U6E1.C47
PCIE14_SATA1B_TX_DN: C6G9.1 R6G5.1 U6E1.C39
PCIE14_SATA1B_TX_DP: C6G10.1 R6G6.1 U6E1.D39
PCIE15_SATA2_RX_DN: C6G8.1 U6E1.F44
PCIE15_SATA2_RX_DP: C6G7.1 U6E1.E45
PCIE15_SATA2_TX_DN: C6G5.1 U6E1.B40
PCIE15_SATA2_TX_DP: C6G6.1 U6E1.C40
PCIE16_SATA3_RX_DN: C6G4.2(B) U6E1.L41
PCIE16_SATA3_RX_DP: C6G3.2(B) U6E1.M40
PCIE16_SATA3_TX_DN: C6G1.1 U6E1.B41
PCIE16_SATA3_TX_DP: C6G2.1 U6E1.C41
PCIE21_SLOT2_RX_DN: R8B36.2(B) U6E1.T43
PCIE21_SLOT2_RX_DP: R8B38.2(B) U6E1.R44
PCIE21_SLOT2_RX_R_DN: J7B1.A17 R8B36.1
PCIE21_SLOT2_RX_R_DP: J7B1.A16 R8B38.1
PCIE21_SLOT2_TX_C_DN: C8B31.2(B) J7B1.B15
PCIE21_SLOT2_TX_C_DP: C8B29.2(B) J7B1.B14
PCIE21_SLOT2_TX_DN: C8B31.1 U6E1.G47
PCIE21_SLOT2_TX_DP: C8B29.1 U6E1.F46
PCIE22_SLOT2_RX_DN: R8C7.2(B) U6E1.U40
PCIE22_SLOT2_RX_DP: R8C4.2(B) U6E1.U41
PCIE22_SLOT2_RX_R_DN: J7B1.A22 R8C7.1
PCIE22_SLOT2_RX_R_DP: J7B1.A21 R8C4.1
PCIE22_SLOT2_TX_C_DN: C8C2.2(B) J7B1.B20
PCIE22_SLOT2_TX_C_DP: C8B38.2(B) J7B1.B19
PCIE22_SLOT2_TX_DN: C8C2.1 U6E1.H47
PCIE22_SLOT2_TX_DP: C8B38.1 U6E1.H48
PCIE23_SLOT2_RX_DN: R8C18.2(B) U6E1.W43
PCIE23_SLOT2_RX_DP: R8C15.2(B) U6E1.W44
PCIE23_SLOT2_RX_R_DN: J7B1.A26 R8C18.1
PCIE23_SLOT2_RX_R_DP: J7B1.A25 R8C15.1
PCIE23_SLOT2_TX_C_DN: C8C11.2(B) J7B1.B24
PCIE23_SLOT2_TX_C_DP: C8C8.2(B) J7B1.B23
PCIE23_SLOT2_TX_DN: C8C11.1 U6E1.G49
PCIE23_SLOT2_TX_DP: C8C8.1 U6E1.G48
PCIE24_SLOT2_RX_DN: R8C24.2(B) U6E1.Y40
PCIE24_SLOT2_RX_DP: R8C22.2(B) U6E1.Y41
PCIE24_SLOT2_RX_R_DN: J7B1.A30 R8C24.1
PCIE24_SLOT2_RX_R_DP: J7B1.A29 R8C22.1
PCIE24_SLOT2_TX_C_DN: C8C15.2(B) J7B1.B28
PCIE24_SLOT2_TX_C_DP: C8C13.2(B) J7B1.B27
PCIE24_SLOT2_TX_DN: C8C15.1 U6E1.G46
PCIE24_SLOT2_TX_DP: C8C13.1 U6E1.G45
PCIE_SLOT2_B12: J7B1.B12 R8B27.2(B)
PCIE_SLOT2_PRSNT2_N: J7B1.B17 J7B1.B31 R8C29.2(B)
PCIE_SLOT2_PWREN_R: EU8B1.2 EU8B1.3 R8B40.2(B) R8C1.1 R8C2.2(B) U8B2.2
PCIE_SLOT2_RST_N: J7B1.A11 R7B53.1 R7B56.2(B) R7B61.2(B)
PCIE_SLOT2_RST_R_N: R7B56.1 U7B3.4(Y)
PCIE_SLOT2_SR: C8B27.1 U8B2.7
PCIE_SLOT3_B12: J8B1.B12 R8B28.2(B) R8C30.2(B)
PCIE_SLOT3_PRSNT2_N: J8B1.B17 J8B1.B31 R8C28.2(B)
PCIE_SLOT3_PWREN_R: EU8B4.2 EU8B4.3 R8B39.1 R8B41.2(B) R8B42.2(B) U8B1.2
PCIE_SLOT3_RST_N: J8B1.A11 R8C43.2(B) R8C48.1 R8C51.2(B)
PCIE_SLOT3_RST_R_N: R8C43.1 U9C2.4(Y)
PCIE_SLOT3_SR: C8B26.1 U8B1.7
PCIEX4_SLOT2_PRSNT2_R_N: Q8C2.2(S) R8B27.1 R8C9.2(B) R8C29.1
PCIEX4_SLOT3_PRSNT2_R_N: Q8C1.2(S) R8B28.1 R8C12.2(B) R8C28.1
PCIEX16_PRSNT1_N: J5B2.A1 R5B16.1
PCIEX16_PRSNT2_N: J5B2.B17 J5B2.B31 J5B2.B48 J5B2.B81 R5C5.2(B)
PCIEX16_PRSNT2_R_N: Q6C1.2(S) R5C4.1 R5C5.1 R5C6.2(B)
PCON_RESET: R3A4.2(B) R3A23.2(B) U3A5.B8
PCON_RESET_R: R3A4.1 R3A5.1 U3A4.4(Y)
PCON_V1P2_EN: R2A71.1 R3A24.1 R3A25.2(B)
PCON_V1P2_EN_R: R3A25.1 U3A5.G8
PD_988_HRESET: R5A24.2(B) R5A25.2(B) R6F14.1
PD_COMP_N: R6A66.1 R6A70.2(B) U6A4.1
PD_COMP_OUT: Q6A1.5 R6A57.2(B) R6A58.2(B) U6A4.4
PD_COMP_P: R6A58.1 R6A59.1 R6A65.2(B) U6A4.3
PD_DRAIN1: EU5A1.8 EU5A1.15 EU5A1.19 EU5A1.58
PD_DRAIN2: EU5A1.7 EU5A1.52 EU5A1.56 EU5A1.57
PD_EC_I2C_GATE: Q8G2.1 Q8G3.1 R8G11.2(B)
PD_GPIO1: EU5A1.17 R5A51.1
PD_HRESET_AIC_R: J6J1.2 R6F19.1 R6H37.2(B)
PD_HRESET_EC: R5J9.2(B) R6F17.2(B) U8F6.38
PD_HRESET_OPTION: R6F14.2(B) R6F15.1 R6F17.1 R6F19.2(B)
PD_HRESET_PCH: R6F15.2(B) U6E1.N48
PD_INT_EC_ISOLATION_G: Q8G8.1 Q9G4.1 R9G24.2(B)
PD_INT_PCH_ISOLATION_G: Q6T1.1 Q6T2.1 R6T20.2(B)
PD_PCH_I2C_GATE: Q8E9.1 Q8E10.1 R8E65.2(B)
PD_SX_ACK_G2: R6H40.1 R6H41.1 R8F20.2(B) R8F21.2(B)
PD_SX_ACK_G2_AIC: J6J1.15 R6H41.2(B)
PD_SX_ACK_G2_BP: EU5A1.40 R6H40.2(B)
PD_SX_ACK_G2_EC: R5J18.1 R8F21.1 R8F23.2(B) U8F6.15
PD_SX_ACK_G2_PCH: R6F11.2(B) R8F20.1 U6E1.P47
PECI_EC: J6J2.87 R8G24.2(B) U8F6.94
PECI_MUX_CTRL_ER_INT: R5J23.1 U8F6.76
PEG_RESET_JUMPER: J9E3.1 R9E11.1
PEG_RST_R_N: J9E3.2(IO2) R7F25.2(B) R7F40.2(B) R8E60.1 U8F2.2
PEG_SLOT_PWREN_R: EU6B1.2 EU6B1.3 EU6B3.2 R6B12.1 R6B13.2(B) R6B14.2(B)
PEG_SLOT_RST_N: J5B2.A11 R8E53.1 R8E60.2(B) R8E61.2(B)
PEG_SLOT_RST_R_N: R8E61.1 U8F2.4(Y)
PEG_SR: C6B5.1 EU6B3.7
PERST_N_M2_SLOTB_N: J5B3.50 R5C8.1 R5C10.2(B) R5C11.2(B)
PERST_N_M2_SLOTB_R: R5C10.1 U5C1.4(Y)
PERST_SLTA_L: J5J1.3 R5V4.2(B) R6H34.2(B)
PERST_SLTB_L: J5J1.4 R5H12.2(B) R5V3.2(B) R6H8.2(B)
PERST_SLTC_L: J5J1.11 R5V7.2(B) R6H2.2(B)
PERST_SLTD_L: J5J1.12 R5H12.1
PH_EXTEND: EU1B1.45 R1B45.1 R1B47.1
PHYSLP_LED: CR8H1.1 R8H32.1
PHYSLP_LED_R: CR8H1.2(C) Q8H2.3
PINSET_TSENC: R2B33.1 R2B35.2(B) R2B36.2(B) R2B37.1 RT3B1.2(B<0>)
PINSET_TSENG: R2C7.2(B) R2C8.1 R2C10.1 R2C13.2(B) RT2D2.2(B<0>)
PINTSENC_H: R2B36.1 R2B38.2(B)
PINTSENC_L: R2B30.1 R2B33.2(B)
PINTSENG_H: R2C13.1 R2C18.2(B)
PINTSENG_L: R2C10.2(B) R2C12.1
PIRQ_ESPI_ALRT0_N: R7U1.1 R7U2.1 U6E1.BA36
PIRQ_N: J7J1.20 R6V1.2(B) R7U1.2(B)
PLN_DELAY_EN: Q8H3.3 R8H38.2(B) R8H43.1 R8H47.2(B) U8H5.4
PLT_RST_LAN_N_FOX: EU7A3.13 R7B60.2(B) R7B63.2(B) R7B64.1
PLTRST_CPU_N: J3D1.T7 U6E1.AG5
PLTRST_EC_N: J6J2.54 R9G7.1 U8F6.56
PLTRST_FOX_N: R7B55.2(B) R7B60.1 R7E30.2(B) U7B2.2
PLTRST_FOX_R_N: R7B63.1 U7B2.4(Y)
PLTRST_J15EV: J9F2.1 R9F4.1
PLTRST_LAN_N: EU4B1.36 J5B1.5 R5B26.1
PLTRST_N: EU8H2.6 R5B26.2(B) R5G26.1 R6T9.2(B) R8F9.1 R9F4.2(B) TP9F1.1(TP) U5C1.1 U8F5.1 U8F5.2
PLTRST_N_1P8V: R7H3.1 R7W3.1 R8A27.1 R8A28.2(B) U7H1.4(Y)
PLTRST_N_BUF: J8J13.34 R1C44.1 R3A23.1 R7H18.1 R7W4.1 R8F6.1 U3A4.1 U5G2.1 U7B2.1 U7B3.1 U7H1.2 U8F1.1 U8F2.1 U8F5.4(Y) U8G1.1 U9C2.1
PLTRST_N_U2: J5H1.B1 R5G24.2(B) R5G25.2(B) R5G26.2(B)
PLTRST_R_N: R7R50.1 R8F9.2(B) U6E1.AV29
PLTRST_SPI_TPM: J7G1.49 J7G2.19 R7H3.2(B) R7H18.2(B)
PLTRST_TBT_RST_BUF_N: R5G21.1 U5G2.4(Y)
PLTRST_TBT_RST_N: R5G18.2(B) R5G20.1 R5G21.2(B) R5G25.1 U5A2.T4
PLTRST_TBT_RST_R_N: R5G18.1 R5G19.2(B) R6H4.2(B) U5G2.2
PLX_SX_ENTRY_AIC: J6J1.13 R6H42.2(B)
PLX_SX_ENTRY_BP_N: EU5A1.18 R6H43.2(B)
PLX_SX_ENTRY_EC: R5J19.1 R8F24.2(B) R8F30.1 U8F6.14
PLX_SX_ENTRY_G1_N: R6H42.1 R6H43.1 R8F22.2(B) R8F30.2(B)
PLX_SX_ENTRY_G1_PCH_N: R6F21.2(B) R8F22.1 U6E1.L46
PM_BATLOW_N: CR5A7.1(CATHODE) J6J2.47 J8J13.7 R6J27.2(B) U8F6.93
PM_DPWROK_R13LH_N: Q8D10.1 R8D39.2(B) R8D42.1
PM_SLP_S0_TTK_N: J7G1.20 R7G30.1
PM_SLP_S3_TTK_N: J7G1.19 R7H9.2(B)
PM_SLP_S4_TTK_N: J7G1.21 R7H10.2(B)
PM_SLP_S5_TTK_N: J7G1.26 R7G31.1
PMC_GPIO: J9E2.1 R9E6.2(B) U8E3.10
PMC_GPIO_PD: J9E2.2(IO2) R9E14.1
PP_EXT1_BP: EU5A1.48 R6A67.1
PP_EXT1_BP_R: Q6A1.3 Q6A2.2 R6A67.2(B) R6A69.1
PPV_BLT_CLK: J8J5.3(IO3) R7J12.1
PPV_BLT_DATA: J8J5.1 R7J14.1
PS2_KBCLK: J6J2.239 U7H4.4 U8F6.78
PS2_KBDATA: J6J2.234 U7H4.3 U8F6.79
PS2_MSCLK: J6J2.215 U7H4.8 U8F6.52
PS2_MSDATA: J6J2.210 U7H4.7 U8F6.88
PS2_OE_N: R7J1.1 U7H4.1
PS_ON_1G97_OUT: CR4J1.1(C) CR8D2.3(C) R4J8.1 U8D9.4(Y)
PS_ON_B: J4J1.2(IO2) R4J4.1 R6J11.1 R7T9.2(B) R8D60.1 R8D72.1 R8F51.2(B) R8F56.1
PS_ON_IN_EC_N: J6J2.138 R8F51.1 U8F6.121
PS_ON_LED: CR8F5.1 R8F55.2(B)
PS_ON_LED_GATE: Q8F1.1 R8F56.2(B)
PS_ON_LED_R: CR8F5.2(C) Q8F1.3
PS_ON_N: J4J4.1 Q4J1.3 R4H5.2(B) R4H8.1 R8G46.1 R8G47.1
PS_ON_OUT_EC_N: R6J10.2(B) R6J11.2(B) U8F6.22
PS_ON_OUT_MECC_N: J6J2.69 R6J10.1
PULSAR_38P4M_REFCLK: R6R1.1 R7B41.2(B) U6E1.R6
PWR_MON1_ADDR: R3H38.1 U3H1.C2
PWR_MON1_PDN_N: C3H5.1 R3H21.2(B) R3H28.1 U3H1.B3
PWR_MON1_SLOW: C3H8.1 R3H41.1 U3H1.C3
PWR_MON2_ADDR: R1E19.1 U1E2.C2
PWR_MON2_PDN_N: C1E4.1 R1E15.2(B) R1E16.1 U1E2.B3
PWR_MON2_SLOW: C1E6.1 R1E20.1 U1E2.C3
PWR_MON3_ADDR: R1E38.1 U1E3.C2
PWR_MON3_PDN_N: C1E9.1 R1E31.2(B) R1E35.1 U1E3.B3
PWR_MON3_SLOW: C1E10.1 R1E40.1 U1E3.C3
PWR_MON4_ADDR: R1E8.1 U1E1.C2
PWR_MON4_PDN_N: C1E1.1 R1D16.2(B) R1E4.1 U1E1.B3
PWR_MON4_SLOW: C1E2.1 R1E12.1 U1E1.C3
PWR_MON5_ADDR: R4H35.1 U4H1.C2
PWR_MON5_PDN_N: C4H8.1 R4H25.2(B) R4H31.1 U4H1.B3
PWR_MON5_SLOW: C4H13.1 R4H36.1 U4H1.C3
PWR_MON6_ADDR: R3H39.1 U3H2.C2
PWR_MON6_PDN_N: C3H6.1 R3H23.2(B) R3H29.1 U3H2.B3
PWR_MON6_SLOW: C3H9.1 R3H40.1 U3H2.C3
PWR_MON7_ADDR: R4H38.1 U4H2.C2
PWR_MON7_SLOW: C4H14.1 R4H44.1 U4H2.C3
PWR_MON_I2C_SCL: J4H1.1 R1E24.2(B) R4H53.1 R4H54.1 R5J1.2(B) U1E1.C4 U1E2.C4 U1E3.C4 U3H1.C4 U3H2.C4 U4H1.C4 U4H2.C4
PWR_MON_I2C_SDA: J4H1.2 R1E23.2(B) R4J1.1 R4J3.1 R5J2.2(B) U1E1.D4 U1E2.D4 U1E3.D4 U3H1.D4 U3H2.D4 U4H1.D4 U4H2.D4
PWRBTN_EC_IN_N: J6J2.127 J8J13.1 R5H7.2(B) R5H10.2(B) R8F36.2(B) R8H46.1 U8F6.127
PWRBTN_EC_OUT_N: J6J2.63 R5H15.2(B) R9F32.2(B) U8F6.42
PWRBTN_N: C5H1.1 J8J13.23 R5H7.1 R5H8.1 R5H14.2(B) SW5H2.1 SW5H2.2
PWRBTN_TTK_N: J7G1.5 R7H6.2(B)
PWRGD_3V_EC: J6J2.117 R6J26.1
PWRGD_3V_PU_HDR: J8J6.3(IO3) R8J19.2(B)
PWRGD_LED_D: DS8H7.1 R8H63.2(B)
PWRGD_LED_DRV: DS8H7.2(C) EU8H2.8
PWRGD_PS: C4G23.1 C4G24.1 J9G8.1 Q3G3.1 R4G22.1 R8C36.1 R8C59.1
PWRGD_PS_1G97: C8C19.1 R8C55.1 R8C59.2(B) U8C3.3
PWRGD_PS_OPT: R8C68.1 R8C82.1 R8D1.1 U8C3.4(Y)
PWRGD_PS_OPT_RC: C8D1.1 R8C82.2(B) R8D2.1
PWRGD_PS_R: J4G1.8 R4G22.2(B)
PWRGD_PS_SMBUS_ISOLATE: Q6G1.1 Q6G2.1 Q7B9.1 Q7B10.1 Q7C1.6 R7C7.2(B)
PWRGD_PS_U6LH_PN8: R8C79.1 U8C4.4(Y_N)
PWRGD_VCCSFR_OC: R5C25.2(B) R5C61.1 R5E4.1 R5E12.1
PWRGOOD_3.3V_TTK: R7H1.2(B) R7H7.1
PWRGOOD_TTK: J7G1.15 R7H7.2(B) R7H8.2(B)
Q1LH_PIN5: Q8C12.1 R8C75.1 R8C79.2(B)
Q4TS_VDDQ: Q2G1.3 R2G13.2(B)
Q5D1BV_PIN5: Q8C11.5 Q8C11.6 R8C57.2(B)
Q7G10_P1_P3: Q8C12.5(E<0>) Q8C12.6
Q7G10_PIN5: Q8C12.4 R8D2.2(B)
Q7PR_PIN2: C8C18.1 Q8C8.1 R8C46.2(B)
Q7PR_PIN6: Q8C5.1 Q8C8.3 R8C38.2(B) U8C2.2
Q12LH_BF_CUT: Q8C3.2(S) Q8C4.2(S) Q8C6.3
Q28BV_PIN1: Q4H1.3 Q4H3.1(E<0>) Q4H3.4 R4H27.1
Q28BV_PIN2: Q4H3.2 R4H12.2(B)
Q28BV_PIN3: Q4H3.6 R4H30.2(B)
Q28BV_PIN6: Q4H3.3 R4H26.2(B) R4H29.1
Q36BV_PIN2: Q4H5.1 R4H48.2(B)
Q36BV_PIN4: Q4H4.2(E) R4H50.2(B)
Q41BV_PIN2: C8D13.1 Q8D12.1 R8D23.2(B) R8D36.1
Q41BV_PIN2_R: CR8D1.1 CR8D1.2 R8D23.1
Q41BV_PIN3: Q8D11.3 R8D35.1
Q41BV_PIN3_R: R8D28.1 R8D34.2(B) R8D35.2(B)
Q41BV_PIN6: Q8D12.3 R8D37.1
Q41BV_PIN6_R: R8D29.1 R8D30.2(B) R8D37.2(B)
Q47BV_PIN5: Q4H1.2 Q4H1.5 R4H3.2(B) R4H6.1 R4H11.2(B) R4H21.2(B)
Q18141_PIN6: Q7A1.6 Q7B1.5 Q7B1.6 R7B4.2(B)
Q161258_PIN1: Q8G4.1 R8G42.2(B)
Q161310_PIN1: Q8G1.1 R8G9.2(B)
Q182122_PIN3: Q7A1.3 Q7B5.2(S) Q7B6.3
Q_1G74_22: U8D6.5 U8D8.6
R2Q1_GRNLED_BRD: Q8G6.1 R8G47.2(B)
R2Q1_GRNLED_HDR: Q8G5.1 R8G46.2(B)
RCIN_ESPI_ALRT1_HDR_N: J7J1.23 R7E54.2(B)
RCIN_ESPI_ALRT1_N: R7E52.1 R7E54.1 R7E57.2(B) U6E1.BE39
RCIN_N_EC: J6J2.84 R7E52.2(B) U8F6.49
REAR_FAN_CTRL: J9C1.4(IO4) Q9C2.3
REAR_FAN_CTRL_EC: J6J2.157 R9C8.2(B) R9C9.1 U8F6.47
REAR_FAN_PWM_R: Q9C2.1 R9C11.1
REAR_FAN_R_CTRL: Q9C2.2(SRC) R9C9.2(B) R9C10.2(B)
REAR_FAN_TACH: C9C6.1 R9C6.1 R9C7.2(B)
REAR_FAN_TACH_DRIVER: J9C1.1 R9C2.1
REAR_TACH_OUT: J9C1.3 R9C5.2(B) R9C7.1
RECOVERY_CONFIGURE_PULLUP: J8J3.2 R8H75.2(B)
REV_FAB_ID0: R8E20.1 R8E21.2(B) U8E3.4
REV_FAB_ID1: R8E18.1 R8E19.2(B) U8E3.5
RING2_CONN: C5A3.1 FB5A1.2(B) J5A1.1
RING2_FB_CONN: FB5A1.1 R5A1.2(B) R5A4.2(B)
RSMRST_N: C7F3.1 R7F7.2(B) U6E1.BA47
RSMRST_PWRGD_EC_N: J9E9.3 R9F18.1 U8F6.23
RSMRST_PWRGD_N: J6J2.8 J8J13.30 R8D84.2(B) R9F17.2(B) R9F18.2(B) TP9F3.1(TP) U8D13.1 U8D14.4(Y)
RST_N_1G74_22: R8D65.2(B) U8D6.6
RSVD1: EU4B1.1 R4B16.2(B)
RTC_RST_TTK_N: J7G1.23 R7H11.2(B)
RX_IN: J9B6.2 U9C1.12
S3_LED_DRV: DS8H3.2(C) EU8H1.8
S3_VTT_CNTL: R2G32.2(B) R2G34.1 R2G39.2(B) U2G2.3
