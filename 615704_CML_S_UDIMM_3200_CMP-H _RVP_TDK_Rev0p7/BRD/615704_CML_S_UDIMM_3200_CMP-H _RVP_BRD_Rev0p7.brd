# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+V5S on TOP: 102.74,81.53 104.39,79.88 104.39,78.1 104.9,77.6 116.45,77.6 121.92,72.13 121.92,70.61 121.79,70.48 120.9,70.48 120.26,69.85 120.26,64.51 121.72,63.05 135.44,63.05 136.27,62.23 145.92,62.23 149.86,58.29 159.63,58.29 160.14,57.78 160.14,54.99 159.51,54.35 148.2,54.35 146.3,56.26 146.3,57.02 143.25,60.07 138.68,60.07 137.92,59.31 132.84,59.31 132.08,60.07 118.87,60.07 116.58,62.36 116.58,72.39 113.79,75.18 104.39,75.18 102.99,73.79 102.99,72.13 102.87,72.01 102.1,72.01 101.98,72.13 101.98,73.79 99.69,76.07 99.69,83.18 101.6,85.09 103.88,85.09 104.14,84.83 104.14,83.56 104.01,83.44 103.12,83.44 102.74,83.06
+V5S on TOP: 279.78,285.88 278.89,285.88 278.51,286.26 278.51,288.03 278.76,288.29 279.78,288.29 280.41,287.65 281.17,287.65 281.55,287.27 281.55,285.24 281.43,285.11 280.28,285.11 280.03,285.37 280.03,285.62
+V5S on TOP: 10.79,70.36 8.5,70.36 6.6,68.45 6.6,66.93 7.11,66.42 9.27,66.42 11.04,68.2 11.68,68.2 11.81,68.32 11.81,70.1 12.57,70.86 14.09,70.86 14.47,71.25 14.47,72.26 14.35,72.39 13.08,72.39 12.06,71.37 11.81,71.37
+V5S on TOP: 231.64,285.88 231.52,285.75 229.23,285.75 229.1,285.88 229.1,287.78 229.23,287.91 231.39,287.91 231.64,287.65
+V5S on TOP: 183.76,83.56 185.42,83.56 185.54,83.44 185.54,82.93 185.67,82.8 187.19,82.8 188.72,81.28 188.72,74.93 188.08,74.29 187.32,74.29 183.64,77.98 183.64,83.44
+V5S on TOP: 192.02,81.28 192.02,79.5 192.4,79.12 193.54,79.12 194.43,78.23 195.07,78.23 195.58,77.72 195.58,72.26 195.32,72.01 188.46,72.01 186.81,73.66 186.81,80.9 187.32,81.41 191.89,81.41
+V5S on TOP: 296.54,221.36 298.19,221.36 298.45,221.61 301.24,221.61 302.13,220.72 302.13,219.33 301.75,218.95 300.48,218.95 299.21,220.22 296.67,220.22 296.29,220.6 296.29,221.11
+V5S on TOP: 202.05,275.84 204.59,275.84 204.72,275.72 204.72,274.32 204.47,274.06 202.81,274.06 202.69,274.19 202.18,274.19 202.05,274.32
+V5S on TOP: 252.85,282.7 254.5,282.7 254.63,282.57 254.63,280.54 254.38,280.29 252.98,280.29 252.73,280.54 252.73,282.57
+V5S on BOTTOM: 225.55,288.29 233.29,288.29 234.18,287.4 234.18,276.48 229.1,271.4 229.1,264.79 230.5,263.4 230.5,260.09 231.77,258.82 231.77,254.13 231.52,253.87 228.09,253.87 227.83,254.13 227.83,263.65 227.07,264.41 223.39,264.41 223.01,264.03 214.88,264.03 209.04,269.87 209.04,272.79 207.89,273.94 202.43,273.94 202.18,274.19 202.18,277.11 202.69,277.62 206.62,277.62 210.94,273.3 210.94,271.14 216.15,265.94 220.59,265.94 224.15,269.49 224.15,286.89 ; 1 cut-out
+V5S on LAY2: outline of 108 points within 183.74,39.34 303.55,290.85 ; 6 cut-outs
+V5S on LAY6: 181.35,76.71 192.4,76.71 192.91,76.2 192.91,73.4 189.48,69.98 181.48,69.98 173.1,61.59 173.1,57.28 170.05,54.23 159,54.23 158.49,54.74 158.49,57.91 159.51,58.93 167.13,58.93 168.4,60.2 168.4,63.75
+V5S on LAY6: 202.69,275.84 208.78,275.84 213.99,270.64 226.06,270.64 226.44,270.25 226.44,267.08 225.8,266.44 209.04,266.44 202.18,273.3 202.18,275.33
+V5S on LAY6: 280.79,290.7 280.86,290.64 301.05,290.64 303.78,287.91 303.78,217.55 303.4,217.17 301.37,217.17 300.86,217.68 300.86,239.27 300.73,239.39 300.6,239.39 300.6,240.41 300.86,240.66 300.86,262.38 299.84,263.4 299.84,280.16 298.45,281.56 271.39,281.56 267.97,284.99 260.73,284.99 259.58,283.84 259.58,282.83 253.49,276.73 234.06,276.73 233.04,277.75 233.04,281.68 231.58,283.15 231.58,284.42 229.23,286.76 229.23,287.78 232.15,290.7 ; 1 cut-out
+V5S_HDMIC_CONN1 on TOP: 268.35,286.89 273.43,286.89 274.32,286 274.82,286 275.2,285.62 278.38,285.62 278.76,285.24 279.78,285.24 279.78,283.97 279.52,283.72 268.35,283.72 268.09,283.97 268.09,286.64
+V5S_HDMID_CONN2 on TOP: 252.34,286.64 252.34,281.81 252.09,281.56 248.15,281.56 245.99,283.72 245.99,286.64 246.12,286.76 252.22,286.76
+V5S_R on TOP: 197.1,75.31 201.42,75.31 201.67,75.06 201.67,72.9 203,71.56 203.39,71.56 204.47,70.48 204.47,67.56 204.21,67.31 193.29,67.31 192.91,67.69 192.91,70.86 193.29,71.25 196.59,71.25 197.1,71.75
+V5S_R on BOTTOM: 193.92,71.5 211.32,71.5 217.29,65.53 222.25,65.53 224.02,63.75 224.02,61.85 222.37,60.2 205.99,60.2 202.43,63.75 193.42,63.75 192.78,64.39 192.78,70.36
+V5S_SATADOM_SATA1B on TOP: 122.3,65.28 123.69,63.88 124.2,63.88 124.58,64.26 124.58,64.77 123.69,65.66 123.69,71.25 123.44,71.5 122.42,71.5 122.3,71.37
+V5S_SATADOM_SATA2 on TOP: 103.63,73.28 103.37,73.02 103.37,67.94 104.52,66.8 104.52,66.17 104.9,65.78 105.66,65.78 105.91,66.04 105.91,67.18 105.02,68.07 105.02,73.02 104.77,73.28
+V5S_SATADOM_SATA3 on TOP: 104.64,84.71 105.41,84.71 105.79,84.33 105.79,78.36 105.91,78.23 105.91,77.72 105.66,77.47 105.15,77.47 104.52,78.1 104.52,84.58
+V12S on TOP: 66.29,35.43 67.81,35.43 67.94,35.3 67.94,31.24 67.43,30.73 66.16,30.73 65.91,30.99 65.91,35.05
+V12S on TOP: 106.29,263.27 108.07,263.27 108.33,263.02 108.33,262.25 109.72,260.86 109.72,250.57 111.25,249.05 115.31,249.05 115.57,248.79 115.57,244.98 114.93,244.35 107.06,244.35 103.25,248.16 103.25,252.6 106.04,255.4 106.04,263.02
+V12S on TOP: 43.18,253.62 43.43,253.36 50.41,253.36 50.8,253.74 50.8,259.59 50.54,259.84 45.33,259.84 43.94,258.44 43.56,258.44 43.18,258.06
+V12S on TOP: 292.22,249.3 292.98,249.3 293.11,249.17 293.11,247.27 292.86,247.01 292.1,247.01 291.84,247.27 291.84,248.92
+V12S on TOP: 13.33,261.75 13.33,260.6 13.46,260.48 14.98,260.48 15.11,260.6 15.11,261.75 14.98,261.87 13.46,261.87
+V12S on TOP: 245.11,76.33 245.11,69.47 242.95,67.31 238.75,67.31 238.37,66.93 234.95,66.93 234.56,67.31 234.56,70.61 234.31,70.86 234.31,72.52 232.66,74.17 232.66,77.34 232.91,77.6 243.84,77.6
+V12S on TOP: 293.87,140.46 293.62,140.21 292.22,140.21 291.84,139.83 290.57,139.83 290.44,139.7 290.44,136.65 291.46,135.63 295.4,135.63 295.78,136.02 295.78,137.03 295.91,137.16 297.94,137.16 299.33,138.56 300.86,138.56 301.49,137.92 301.49,134.24 300.86,133.6 289.68,133.6 286.89,136.4 286.89,139.95 288.54,141.6 291.21,141.6 291.46,141.86 291.46,144.27 292.1,144.91 293.62,144.91 293.87,144.65
+V12S on BOTTOM: 294.51,223.39 295.78,223.39 296.16,223.77 296.16,239.52 292.86,242.82 292.86,249.3 292.6,249.55 291.59,249.55 291.33,249.3 291.33,242.44 294.76,239.01 294.76,228.98 294,228.22 294,225.17 294.38,224.79 294.38,223.52
+V12S on LAY2: outline of 306 points within 2.39,1.24 251.35,281.08 ; 14 cut-outs
+V12S on LAY5: 291.33,170.81 291.97,170.81 292.35,170.43 292.35,164.72 291.46,163.83 291.46,163.07 290.06,161.67 290.06,159.89 287.14,156.97 283.71,156.97 281.05,154.3 281.05,149.22 283.59,146.68 283.59,144.14 284.73,143 285.11,143 288.03,140.08 288.03,135.76 287.78,135.51 286.38,135.51 286.13,135.76 286.13,135.89 283.21,138.81 283.21,140.71 280.67,143.25 280.67,145.92 278.76,147.83 278.76,150.75 279.52,151.51 279.52,156.08 283.84,160.4 285.87,160.4 287.21,161.73 287.21,164.15 288.29,165.23 288.29,166.5 289.68,167.89 289.68,169.16 ; 3 cut-outs
+V12S on LAY5: 295.14,223.01 295.14,224.92 294.89,225.17 293.37,225.17 292.35,224.15 292.35,223.01 293.49,221.87 294,221.87
+V12S_AUDIO on TOP: 14.35,258.44 14.09,258.19 11.43,258.19 11.17,258.44 11.17,258.95 11.43,259.21 12.19,259.21 12.95,259.97 14.22,259.97 14.35,259.84
+V12S_CPU on TOP: 163.32,173.73 163.06,173.48 161.29,173.48 160.9,173.86 160.9,176.53 161.16,176.78 163.19,176.78 163.32,176.66
+V12S_CPU on TOP: 300.22,271.14 299.59,270.51 296.03,270.51 293.24,267.71 293.24,262.13 292.1,260.98 286.89,260.98 286.25,260.35 286.25,257.43 284.73,255.9 284.73,248.66 284.48,248.41 280.79,248.41 280.54,248.66 280.54,252.6 281.68,253.74 281.68,266.57 283.59,268.48 283.59,276.35 284.22,276.99 299.08,276.99 300.22,275.84
+V12S_CPU on TOP: 172.59,206.75 173.22,206.75 173.48,206.5 173.48,204.21 173.35,204.09 171.95,204.09 171.7,204.34 171.7,204.98 171.32,205.36 171.32,205.74 171.45,205.87 172.33,205.87 172.46,205.99 172.46,206.63
+V12S_CPU on TOP: 250.95,214.25 268.73,214.25 274.7,208.28 274.7,203.58 274.32,203.2 270.51,203.2 270.12,203.58 270.12,205.99 264.41,211.71 250.95,211.71 250.69,211.96 250.69,213.99
+V12S_CPU on TOP: 166.87,248.41 166.11,248.41 165.98,248.54 165.98,250.06 166.24,250.32 169.41,250.32 170.56,249.17 170.56,248.79 170.81,248.54 170.81,247.9 170.43,247.52 167.76,247.52
+V12S_CPU on LAY2: 284.52,277.26 293.26,277.26 293.26,255.61 294.41,254.46 294.41,253.91 293.26,252.77 293.26,251.88 291.74,250.36 291.74,245.83 292.25,245.32 292.25,244.3 292.63,243.92 292.63,242.42 290.11,242.42 288.96,243.56 286.55,243.56 285.6,244.52 285.6,245.15 285.15,245.59 282.53,245.59 282.34,245.41 282.34,244.77 282.27,244.71 281.72,244.71 281.41,245.03 281.41,246.04 280.71,246.74 280.01,246.74 280.01,252.3 281.66,253.96 281.66,263.73 282.17,264.24 282.17,266.53 283.69,268.05 283.69,276.43
+V12S_CPU on LAY3: 265.43,203.96 279.14,203.96 279.2,204.02 283.4,204.02 286.89,207.52 286.89,218.95 289.05,221.11 289.05,238.76 289.3,239.01 289.3,242.06 293.24,246 293.24,262.25 291.46,264.03 289.94,264.03 289.81,264.16 284.09,264.16 281.68,261.75 281.68,259.97 281.05,259.33 281.05,253.11 274.06,246.12 273.81,246.12 272.28,244.6 272.28,239.14 268.22,235.08 268.22,221.74 261.74,215.26 251.96,215.26 250.82,214.12 250.82,212.34 251.2,211.96 262.89,211.96 263.9,210.95 263.9,205.48 ; 1 cut-out
+V12S_CPU on LAY5: 179.45,245.11 179.45,244.09 180.08,243.46 180.08,229.23 180.21,229.11 175,229.11 172.97,231.14 172.97,238.63 167.38,244.22 166.11,244.22 165.35,244.98 165.35,248.79 166.11,249.55 169.92,249.55 171.7,247.78 176.78,247.78
+V12S_CPU on LAY5: 176.53,240.79 176.53,236.73 177.67,235.58 177.67,230.63 180.08,228.22 180.08,226.44 184.53,221.99 185.54,221.99 188.21,219.33 188.21,217.55 186.43,215.77 186.43,213.74 186.81,213.36 192.78,213.36 193.42,213.99 193.42,229.87 187.19,236.09 182.62,236.09 179.45,239.27 179.45,241.17 176.91,241.17 ; 1 cut-out
+V12S_CPU on LAY6: 167,181.86 167,184.91 168.14,186.05 168.14,197.36 168.91,198.12 168.91,202.69 170.3,204.09 170.3,209.68 173.6,212.98 173.6,214.25 175.76,216.41 186.69,216.41 187.45,217.17 187.57,217.17 189.1,218.69 252.22,218.69 253.3,217.61 253.3,212.22 252.92,211.83 194.24,211.83 192.15,209.74 189.8,209.74 187.83,207.77 184.78,207.77 183.51,206.5 179.19,206.5 178.18,205.48 178.18,184.53 174.43,180.78 173.54,180.78 172.21,179.45 172.21,173.61 171.95,173.35 163.01,173.35 161.99,174.37 161.99,176.47 162.05,176.53 162.05,176.91
+V12S_CPU_R1 on TOP: outline of 146 points within 178.05,243.08 280.92,262.76
+V12S_CPU_R1 on BOTTOM: 184.27,245.36 184.27,243.33 184.15,243.2 179.95,243.2 179.83,243.33 179.83,245.36 180.4,245.93 183.7,245.93
+V12S_CPU_R1 on BOTTOM: outline of 107 points within 193.14,243.08 267.2,252.35
+V12S_CPU_R1 on LAY2: 277.91,263.04 281.45,263.04 281.45,254.04 279.8,252.39 279.8,246.74 275.03,246.74 271.35,243.05 180.12,243.05 179.81,243.37 179.81,244.14 178.03,245.91 178.03,249.89 179.24,251.1 196.29,251.1 196.67,250.72 226.1,250.72 229.91,254.53 231.43,254.53 232.32,255.42 263.56,255.42 264.71,256.56 276.64,256.56 277.21,257.13 277.21,262.34
+V12S_CPU_R1 on LAY3: 230.75,250.95 179.07,250.95 178.3,250.19 178.3,244.98 180.21,243.08 267.84,243.08 277.24,252.47 279.52,252.47 280.22,253.17 280.22,259.14 281.43,260.35 281.43,264.29 280.28,265.43 271.27,265.43 260.73,254.89 234.69,254.89 ; 5 cut-outs
+V12S_CPU_R1 on LAY5: 277.62,262.76 281.05,262.76 281.3,262.51 281.3,253.87 278.38,250.95 272.41,250.95 271.65,251.71 234.31,251.71 234.06,251.97 234.06,253.24 234.56,253.74 245.23,253.74 246.63,255.14 260.6,255.14 265.04,259.59 274.57,259.59 277.62,262.63
+V12S_CPU_R2 on TOP: 270.51,201.67 274.06,201.67 274.57,201.17 274.57,197.99 281.3,191.26 285.75,191.26 286.38,190.63 286.38,187.07 285.75,186.43 283.84,186.43 283.71,186.31 283.71,185.04 283.46,184.78 282.57,184.78 282.32,185.04 282.32,189.23 281.94,189.61 278.89,189.61 276.86,191.64 271.52,191.64 270.89,192.28 270.89,196.21 270.12,196.98 270.12,201.29
+V12S_CPU_R2 on TOP: 285.01,173 283.84,173 283.71,172.87 283.71,171.6 283.46,171.35 282.57,171.35 282.32,171.6 282.32,176.78 282.44,176.91 284.02,176.91 285.52,175.41 285.52,173.51
+V12S_CPU_R2 on BOTTOM: 274.06,194.82 279.14,194.82 281.68,192.28 292.48,192.28 292.98,191.77 292.98,172.97 291.21,171.19 283.84,171.19 283.69,171.35 282.44,171.35 282.32,171.47 282.32,175.66 282.44,175.79 285.64,175.79 286.76,176.91 286.76,183.89 285.87,184.78 282.44,184.78 282.32,184.91 282.32,188.97 281.81,189.48 278,189.48 276.47,191.01 272.66,191.01 272.41,191.26 272.41,193.17
+V12S_CPU_R2 on LAY5: 280.28,200.15 286.76,193.67 286.76,183.32 285.41,181.97 285.41,181.66 285.01,181.26 285.01,180.12 285.05,180.08 285.05,176.34 285.75,175.64 285.75,172.85 284.09,171.19 282.06,171.19 281.68,171.58 281.68,187.32 278.51,190.5 272.54,190.5 270.38,192.66 270.38,199.52 271.01,200.15 ; 1 cut-out
+V12S_CPU_R2 on LAY6: 276.6,200.28 284.6,192.28 284.73,192.28 289.05,187.96 289.05,175 284.98,170.94 281.68,170.94 281.66,170.96 281.66,172.81 280.92,173.55 280.92,183.48 281.62,184.18 281.62,186.37 280.28,187.7 280.28,188.97 278.25,191.01 273.93,191.01 270.38,194.56 270.38,199.64 271.01,200.28 ; 1 cut-out
+V12S_FAN on TOP: 294.25,152.14 295.4,151 300.48,151 300.99,150.49 300.99,148.84 300.48,148.33 294.76,148.33 293.75,149.35 290.19,149.35 289.68,149.86 289.68,151.76 290.06,152.14
+V12S_FAN on TOP: 99.06,46.1 100.96,46.1 101.34,45.72 101.34,44.7 100.96,44.32 98.67,44.32 98.55,44.45 98.55,45.59
+V12S_FAN on TOP: 11.68,212.22 11.43,211.96 9.27,211.96 7.62,210.31 5.58,210.31 5.33,210.56 5.33,212.47 5.84,212.98 8.38,212.98 9.9,214.5 11.43,214.5 11.68,214.25
+V12S_FAN on TOP: 173.48,36.96 175.51,36.96 175.76,36.7 175.76,35.3 175.51,35.05 173.48,35.05 173.22,35.3 173.22,36.7
+V12S_FAN on BOTTOM: 98.42,45.46 99.94,45.46 100.07,45.34 100.07,42.54 99.69,42.16 98.55,42.16 98.04,42.67 98.04,45.08
+V12S_FAN on BOTTOM: 4.31,13.33 4.95,13.33 6.6,11.68 6.6,10.92 6.47,10.79 4.44,10.79 4.06,11.17 4.06,13.08
+V12S_FAN on LAY5: 3.3,13.84 4.69,13.84 5.2,13.33 5.2,11.05 4.95,10.79 3.42,10.79 3.04,11.17 3.04,13.59
+V12S_FAN on LAY6: 174.75,37.46 175.64,37.46 175.76,37.34 175.76,35.3 175.51,35.05 174.75,35.05 174.49,35.3 174.49,37.21
+V12S_FAN on LAY6: 298.06,86.99 299.59,86.99 299.97,87.37 299.97,116.46 293.37,123.06 291.46,123.06 290.95,122.55 290.95,121.54 292.6,119.89 292.6,110.87 297.81,105.66 297.81,87.25
+V12S_FAN on LAY6: 291.08,151.76 289.81,151.76 289.43,151.38 289.43,149.1 290.57,147.95 291.46,147.95 291.46,151.38
+V12S_FAN on LAY6: 253.87,41.4 292.1,41.4 292.6,40.89 292.6,39.75 292.35,39.5 253.74,39.5 253.36,39.88 253.36,40.89
+V12S_FAN_R on TOP: 293.62,148.08 293.87,147.83 293.87,145.41 293.62,145.16 291.33,145.16 291.08,144.91 291.08,142.75 290.83,142.49 289.3,142.49 288.67,143.13 288.67,147.7 289.05,148.08
+V12S_PCIE_SLOT2 on TOP: 62.1,255.27 62.23,255.14 62.23,250.95 63.11,250.06 65.4,250.06 65.78,249.68 65.78,248.28 66.48,247.59 66.48,246.82 62.35,242.7 47.49,242.7 47.11,243.08 47.11,250.19 48.26,251.33 56.64,251.33 57.02,251.71 57.02,255.01 57.27,255.27
+V12S_PCIE_SLOT2_R on TOP: 55.49,255.4 52.45,255.4 52.07,255.78 51.43,255.78 51.3,255.65 51.3,252.35 51.81,251.84 55.49,251.84 55.62,251.97 55.62,255.27
+V12S_PCIE_SLOT3 on TOP: 37.46,253.49 42.67,253.49 46.35,249.81 46.35,243.2 46.22,243.08 38.1,243.08 36.83,244.35 31.49,244.35 31.24,244.6 31.24,250.82 31.62,251.2 36.7,251.2 36.95,251.46 36.95,252.98
+V12S_PCIE_SLOT3_R on TOP: 42.54,254.89 37.59,254.89 37.21,255.27 37.21,257.55 37.71,258.06 42.41,258.06 42.67,257.81 42.67,255.01
+V12S_PEG_SLOT on TOP: 140.46,249.3 142.62,247.14 142.62,246.38 143.12,245.87 144.39,245.87 145.28,246.76 147.7,246.76 147.95,246.51 147.95,245.49 147.44,244.98 145.92,244.98 145.03,244.09 138.04,244.09 137.28,243.33 132.71,243.33 131.95,244.09 123.69,244.09 123.06,244.73 123.06,248.28 124.07,249.3
+V12S_PEG_SLOT_R on TOP: 118.87,249.05 121.15,249.05 121.53,248.66 121.53,244.85 120.9,244.22 116.33,244.22 116.07,244.47 116.07,247.65 116.45,248.03 117.85,248.03
+V12S_R on TOP: 233.99,72.45 233.99,67.12 233.8,66.93 229.61,66.93 229.36,67.18 229.36,68.71 228.79,69.28 225.61,69.28 223.64,67.31 217.8,67.31 217.42,67.69 217.42,74.67 217.67,74.93 231.52,74.93
+V12S_R on BOTTOM: 231.01,66.55 230.5,66.04 226.44,66.04 225.42,67.05 218.44,67.05 218.05,67.44 218.05,72.01 218.69,72.64 229.1,72.64 231.01,70.74
+VBUS_USBC_CONN_BP on TOP: 133.6,262.38 135.89,262.38 136.01,262.25 136.01,259.97 135.63,259.59 134.62,259.59 133.73,260.48 132.96,260.48 132.71,260.73 132.71,261.62 132.46,261.87 132.46,262.63 132.71,262.89 133.09,262.89
+VBUS_USBC_CONN_BP on TOP: 171.83,286.02 172.33,286.02 172.46,285.89 172.46,285.38 172.72,285.13 172.72,284.75 172.59,284.62 172.21,284.62 172.08,284.49 172.08,283.73 171.95,283.61 171.7,283.61 171.57,283.73 171.57,285.76
+VBUS_USBC_CONN_BP on TOP: 169.41,286.02 169.79,286.02 169.92,285.89 169.92,284.75 169.67,284.49 169.67,283.73 169.03,283.73 169.03,285.64
+VBUS_USBC_CONN_BP on BOTTOM: 171.83,285.89 172.46,285.89 172.59,285.76 172.59,283.99 172.46,283.86 171.83,283.86 171.57,284.11 171.57,285.64
+VBUS_USBC_CONN_BP on BOTTOM: 169.16,286.02 169.79,286.02 169.92,285.89 169.92,284.11 169.67,283.86 169.16,283.86 169.03,283.99 169.03,285.89
+VBUS_USBC_CONN_BP on LAY5: 139.44,275.84 141.35,275.84 143.63,273.56 143.63,270.76 143.38,270.51 139.7,270.51 139.19,270 139.19,264.41 137.16,262.38 136.27,262.38 135.63,261.75 132.84,261.75 132.46,262.13 132.46,263.4 133.09,264.03 135,264.03 135.63,264.67 135.63,265.94 136.01,266.32 136.01,270.89 136.27,271.14 136.27,272.67 ; 1 cut-out
+VBUS_USBC_CONN_BP on LAY6: 172.84,286.76 169.29,286.76 167.44,284.92 167.06,284.92 166.24,284.1 166.24,282.7 165.6,282.07 164.71,282.07 161.79,279.14 161.79,278.13 160.9,277.24 156.08,277.24 155.7,276.86 147.57,276.86 145.28,279.14 139.7,279.14 138.55,278 138.55,275.72 139.19,275.08 141.35,275.08 142.49,276.22 145.54,276.22 146.43,275.33 162.3,275.33 163.44,276.48 163.44,278 164.33,278.89 169.54,278.89 171.83,281.18 172.46,281.81 172.46,282.7 173.22,283.46 173.22,286.38
+VBUS_USBC_CONN_BP_L on TOP: 129.28,266.32 132.33,266.32 133.09,267.08 133.09,268.22 132.33,268.98 131.82,268.98 131.44,269.37 131.06,269.37 130.93,269.24 129.15,269.24 129.03,269.11 129.03,266.57
+VBUS_USBC_CONN_BP_L on TOP: 138.55,265.17 139.19,265.17 139.31,265.05 139.31,263.65 138.3,262.63 133.6,262.63 132.08,264.16 132.08,265.94 131.44,266.57 131.44,268.22 131.82,268.6 133.35,268.6 134.49,267.46 134.49,264.79 134.87,264.41 137.79,264.41
+VBUS_USBC_CONN_FP3 on TOP: 135.25,272.79 136.52,272.79 136.77,272.54 136.77,271.65 136.52,271.4 134.49,271.4 133.35,270.25 133.35,269.37 133.22,269.24 131.82,269.24 131.44,269.62 131.44,270.13 132.2,270.89 132.2,272.29 132.96,273.05 135,273.05
+VBUS_USBC_CONN_FP3 on TOP: 122.68,200.02 122.8,200.02 123.82,199.01 123.82,197.1 123.69,196.98 122.68,196.98 122.55,197.1 122.55,199.9
+VBUS_USBC_CONN_FP3 on TOP: 114.8,208.28 114.3,207.77 114.3,203.83 114.42,203.71 115.31,203.71 115.44,203.83 115.44,204.98 115.69,205.23 119.5,205.23 119.63,205.1 119.63,203.96 119.88,203.71 120.14,203.71 120.26,203.83 120.26,204.85 121.79,206.37 121.79,207.14 120.65,208.28
+VBUS_USBC_CONN_FP3 on BOTTOM: 132.71,271.14 133.73,271.14 134.11,270.76 134.11,269.11 133.35,268.35 133.35,266.7 133.98,266.06 133.98,263.78 131.57,261.36 127,261.36 126.11,260.48 124.33,260.48 124.07,260.73 124.07,262.76 125.09,263.78 130.93,263.78 131.95,264.79 131.44,265.3 131.44,269.87
+VBUS_USBC_CONN_FP3 on LAY5: 120.39,208.15 123.19,208.15 123.57,207.77 123.57,201.67 124.33,200.91 124.33,196.59 124.2,196.47 121.66,196.47 119.63,198.5 119.63,207.39
+VBUS_USBC_CONN_FP3 on LAY6: 130.04,254.13 123.57,247.65 123.55,247.65 122.88,246.98 122.88,245.68 117.65,240.45 117.65,239.42 116.43,238.2 116.43,235.3 112.77,231.65 111.76,231.65 111.12,231.01 108.71,231.01 108.33,230.63 108.33,229.74 109.47,228.6 109.47,221.49 107.56,219.58 107.56,217.3 108.83,216.03 117.72,216.03 121.15,212.6 121.15,207.14 120.77,206.75 115.95,206.75 115.44,207.26 115.44,210.06 114.42,211.07 108.33,211.07 104.77,214.63 104.77,222.38 105.28,222.88 105.28,223.9 106.8,225.42 106.8,227.84 105.53,229.11 105.53,232.41 107.69,234.57 109.09,234.57 111.06,236.54 111.06,241.36 111.63,241.93 111.63,245.24 117.34,250.95 122.68,250.95 125.92,254.19 125.92,258.25 124.2,259.97 124.2,261.75 124.58,262.13 128.77,262.13 130.04,260.86
+VBUS_USBC_CONN_FP3_L on TOP: 134.49,271.14 136.65,271.14 138.55,269.24 139.19,269.24 139.31,269.11 139.31,268.73 139.19,268.6 137.66,268.6 136.65,269.62 133.73,269.62 133.6,269.75 133.6,270.25
+VCC0V9_SVR on TOP: 155.44,275.46 155.44,272.29 156.33,271.4 156.33,270.64 156.08,270.38 152.9,270.38 152.65,270.64 152.65,274.32 153.98,275.65 155.25,275.65
+VCC0V9_SVR on LAY5: 164.46,264.67 164.46,265.56 164.21,265.81 163.95,265.81 163.83,265.94 163.83,266.32 163.95,266.44 163.95,266.83 163.7,267.08 161.79,267.08 160.65,268.22 153.67,268.22 153.28,268.6 153.28,271.78 153.79,272.29 156.84,272.29 158.87,270.25 163.44,270.25 163.83,270.64 163.83,271.27 164.21,271.65 170.68,271.65 171.32,271.02 171.32,267.84 170.43,266.95 168.14,266.95 168.02,266.83 167.89,266.83 167.76,266.7 167.76,265.94 167.89,265.81 168.78,265.81 168.91,265.68 168.91,265.17 168.78,265.05 167.89,265.05 167.25,264.41 164.71,264.41 ; 3 cut-outs
+VCC3V3_S0 on TOP: 161.03,269.62 161.92,269.62 162.05,269.49 162.05,268.86 161.92,268.73 161.79,268.73 161.41,269.11 159.89,269.11 158.62,270.38 158.62,275.72 158.74,275.84 159.63,275.84 159.89,276.1 159.89,276.73 160.27,277.11 162.43,277.11 162.56,276.99 162.56,274.06 162.43,273.94 161.54,273.94 160.14,272.54 160.14,270.51
+VCC3V3_S0 on LAY6: 158.87,272.16 159.76,272.16 160.4,271.52 163.32,271.52 163.83,271.02 163.83,270.13 162.3,268.6 159.63,268.6 158.62,269.62 158.62,271.91
+VCC3V3_SX on TOP: 156.33,277.49 159.13,277.49 159.38,277.24 159.38,276.1 159.25,275.97 156.21,275.97 156.08,275.84 153.67,275.84 152.4,274.57 152.4,267.59 153.03,266.95 153.03,265.94 152.78,265.68 152.14,265.68 151.25,266.57 151.25,267.84 150.68,268.41 150.68,271.97 150.49,272.16 150.49,275.84 151.63,276.99 155.82,276.99
+VCC3V3_SX on LAY6: 152.01,270.13 151.25,270.13 151,269.87 151,263.27 151.38,262.89 154.05,262.89 154.3,262.63 154.3,261.62 154.68,261.24 157.6,261.24 159.51,263.14 159.51,264.03 161.16,265.68 161.41,265.68 162.68,266.95 165.35,266.95 165.6,266.7 165.6,266.19 165.22,265.81 163.83,265.81 163.7,265.68 163.7,265.3 163.83,265.17 165.86,265.17 166.37,265.68 166.37,270.64 166.62,270.89 168.14,270.89 168.78,270.25 168.78,270.13 169.16,269.75 169.54,269.75 169.67,269.87 169.67,270.51 168.65,271.52 166.24,271.52 165.73,271.02 165.73,267.97 165.6,267.84 163.83,267.84 163.57,268.1 160.27,268.1 158.62,266.44 158.62,266.19 157.98,265.56 157.98,264.41 157.6,264.03 156.84,264.03 154.55,266.32 153.54,266.32 153.28,266.57 153.28,267.33 153.03,267.59 152.27,267.59 152.14,267.71 152.14,270
+VCC_EDP_BKLT on TOP: 292.22,246.76 295.52,246.76 295.65,246.63 295.65,246.12 296.29,245.49 298.7,245.49 298.95,245.24 298.95,244.85 298.83,244.73 295.4,244.73 295.02,245.11 292.6,245.11 292.1,245.62 292.1,246.63
+VCC_ISH_EEPROM on TOP: 66.16,49.4 64.26,49.4 64.13,49.27 64.13,46.35 64.51,45.97 64.89,45.97 65.02,46.1 65.02,47.5 66.29,48.77 66.29,49.27
+VCCA_XTAL_1P05_L on TOP: 105.41,180.34 105.53,180.47 106.17,180.47 106.42,180.21 106.42,176.4 106.29,176.27 105.53,176.27 105.41,176.4
+VCCAMPHYPLL_1P05 on TOP: 112.01,135 113.15,135 113.66,134.49 113.66,131.06 114.93,129.79 114.93,121.28 118.99,117.22 118.99,113.28 118.74,113.03 116.96,113.03 116.71,113.28 116.71,113.92 116.96,114.17 116.96,115.31 116.2,116.08 115.44,116.08 115.18,116.33 115.18,118.36 113.28,120.27 113.28,121.41 113.28,121.41 113.28,129.28 112.26,130.3 112.26,133.98 111.88,134.36 111.88,134.87
+VCCAMPHYPLL_1P05_L on TOP: 115.18,115.7 116.07,115.7 116.33,115.44 116.33,110.11 115.95,109.73 115.31,109.73 114.8,110.23 114.8,115.31
+VCCAZPLL_1P05 on TOP: 100.96,183.13 102.23,183.13 102.48,182.88 102.48,180.97 102.1,180.59 102.1,179.45 101.85,179.2 99.18,179.2 99.06,179.32 99.06,180.34 99.31,180.59 100.58,180.59 100.71,180.72 100.71,182.88
+VCCAZPLL_1P05 on TOP: 112.01,158.37 112.64,158.37 113.66,159.38 113.66,159.64 113.41,159.89 113.28,159.89 112.64,159.26 112.14,159.26 111.88,159 111.88,158.49
+VCCAZPLL_1P05 on LAY5: 111.37,158.62 113.53,158.62 114.04,159.13 114.04,161.03 111.25,163.83 111.25,168.65 115.31,172.72 115.31,180.47 111.12,184.66 103.25,184.66 101.6,183.01 101.6,181.61 101.72,181.48 102.36,181.48 103.25,182.37 109.72,182.37 112.39,179.7 112.39,172.59 109.6,169.8 109.6,160.4
+VCCAZPLL_1P05_L on TOP: 99.18,178.69 102.36,178.69 102.87,178.18 102.87,176.53 102.61,176.27 100.07,176.27 99.82,176.53 99.82,177.04 99.69,177.16 99.18,177.16 99.06,177.29 99.06,178.56
+VCCCORE on TOP: 237.65,198.88 237.65,194.92 236.09,193.36 236.09,189.99 235.83,189.74 235.2,189.74 234.18,188.72 234.18,187.07 234.06,186.94 233.17,186.94 232.66,186.43 232.66,173.86 232.15,173.35 227.96,173.35 225.93,171.32 216.66,171.32 215.26,172.72 215.26,173.1 216.66,174.5 216.66,185.93 217.93,187.2 217.93,187.61 217.8,187.74 217.2,187.74 216.97,187.97 216.97,189.92 217.93,190.88 218.05,190.88 218.05,191.26 217.8,191.52 217.84,191.56 217.84,196.47 218.04,196.66 218.04,199.01 218.31,199.28 218.31,205.48 208.4,215.39 198.37,215.39 193.8,219.96 191.77,219.96 185.54,226.19 185.54,227.84 185.92,228.22 190.35,228.22 191,227.56 192.4,227.56 192.61,227.77 195.66,227.77 195.66,227.78 266.7,227.78 267.97,226.51 267.97,216.41 266.44,214.88 250.57,214.88 247.77,212.09 247.77,209
+VCCCORE on BOTTOM: 255.5,216.66 250.55,211.71 250.55,211.33 250.19,211.33 236.85,197.99 236.85,192.78 235.71,191.64 235.71,191.01 233.8,189.1 233.8,187.45 232.53,186.18 232.53,184.91 231.9,184.28 230.37,184.28 229.87,183.77 229.87,178.05 229.36,177.54 225.8,177.54 225.17,176.91 225.17,172.08 224.91,171.83 216.02,171.83 215.77,172.08 215.77,177.04 217.42,178.69 217.42,186.4 218.39,187.37 218.39,189.56 218.44,189.61 218.44,201.14 218.43,201.14 218.43,201.3 214.6,205.13 214.6,207.89 206.92,215.56 200.99,215.56 189.28,227.28 185.62,227.28 185.54,227.36 185.54,227.96 185.67,228.09 187.07,228.09 187.45,228.47 187.45,229.36 187.7,229.61 193.29,229.61 194.69,228.22 265.55,228.22 266.44,227.33 266.44,224.03 259.08,216.66 ; 2 cut-outs
+VCCCORE_PH1_OUT on TOP: 239.52,232.03 242.44,232.03 242.57,231.9 242.57,230.12 242.69,230 243.58,230 243.71,230.12 243.71,231.9 243.84,232.03 246.63,232.03 246.88,231.77 246.88,228.6 246.76,228.47 239.52,228.47 239.39,228.6 239.39,231.9
+VCCCORE_PH1_OUT on BOTTOM: 239.39,234.06 239.39,228.6 239.52,228.47 246.38,228.47 246.63,228.73 246.63,229.61 246.76,229.74 250.19,229.74 250.44,230 250.44,232.54 250.19,232.79 248.28,232.79 246.63,234.44 239.77,234.44
+VCCCORE_PH2_OUT on TOP: 228.21,232.03 230.5,232.03 230.63,231.9 230.63,230.12 230.75,230 231.64,230 231.77,230.12 231.77,231.9 231.9,232.03 234.69,232.03 234.95,231.77 234.95,228.6 234.82,228.47 228.34,228.47 228.09,228.73 228.09,231.9
+VCCCORE_PH2_OUT on BOTTOM: 228.34,228.47 233.29,228.47 233.42,228.6 233.42,229.49 233.68,229.74 236.98,229.74 237.1,229.87 237.1,232.66 236.98,232.79 235.83,232.79 233.68,234.95 228.6,234.95 228.09,234.44 228.09,228.73
+VCCCORE_PH3_OUT on TOP: 216.15,232.03 219.07,232.03 219.2,231.9 219.2,230.12 219.32,230 220.34,230 220.47,230.12 220.47,231.9 220.59,232.03 223.26,232.03 223.52,231.77 223.52,228.6 223.39,228.47 216.15,228.47 216.02,228.6 216.02,231.9
+VCCCORE_PH3_OUT on BOTTOM: 223.39,228.47 224.66,229.74 226.82,229.74 226.94,229.87 226.94,234.31 226.31,234.95 216.28,234.95 216.02,234.69 216.02,228.6 216.15,228.47
+VCCCORE_PH4_OUT on TOP: 204.85,232.03 207.01,232.03 207.26,231.77 207.26,230.12 207.39,230 208.28,230 208.53,230.25 208.53,231.9 208.66,232.03 211.32,232.03 211.58,231.77 211.58,228.6 211.45,228.47 204.97,228.47 204.72,228.73 204.72,231.9
+VCCCORE_PH4_OUT on BOTTOM: 213.74,233.04 213.74,229.23 213.48,228.98 210.18,228.98 209.67,228.47 204.97,228.47 204.72,228.73 204.72,234.19 204.97,234.44 211.07,234.44 212.34,233.17 213.61,233.17
+VCCCORE_PH5_OUT on TOP: 262.76,232.03 265.55,232.03 265.81,231.77 265.81,230.12 265.93,230 266.95,230 267.08,230.12 267.08,231.9 267.2,232.03 269.87,232.03 270.12,231.77 270.12,228.6 270,228.47 262.76,228.47 262.63,228.6 262.63,231.9
+VCCCORE_PH5_OUT on BOTTOM: 262.63,231.9 262.63,228.6 262.76,228.47 265.93,228.47 267.08,227.33 267.08,223.77 267.46,223.39 270.12,223.39 270.51,223.77 270.51,231.77 270.25,232.03 262.76,232.03
+VCCCORE_PH6_OUT on TOP: 251.33,232.03 253.61,232.03 253.87,231.77 253.87,230.12 254,230 255.01,230 255.14,230.12 255.14,231.9 255.27,232.03 257.93,232.03 258.19,231.77 258.19,228.6 258.06,228.47 251.33,228.47 251.07,228.73 251.07,231.77
+VCCCORE_PH6_OUT on BOTTOM: 256.41,228.47 251.33,228.47 251.07,228.73 251.07,234.19 251.33,234.44 259.96,234.44 260.22,234.19 260.22,230.12 259.84,229.74 256.79,229.74 256.54,229.49 256.54,228.6
+VCCCORE_PH7_OUT on TOP: 193.16,232.03 196.08,232.03 196.21,231.9 196.21,230.12 196.34,230 197.35,230 197.48,230.12 197.48,231.9 197.61,232.03 200.27,232.03 200.53,231.77 200.53,228.6 200.4,228.47 193.16,228.47 193.04,228.6 193.04,231.9
+VCCCORE_PH7_OUT on BOTTOM: 199.77,228.47 195.19,228.47 193.29,230.38 193.29,233.93 193.8,234.44 203.7,234.44 203.96,234.19 203.96,229.23 203.7,228.98 200.27,228.98
+VCCCORE_PH8_OUT on TOP: 181.61,232.03 184.15,232.03 184.27,231.9 184.27,230.12 184.4,230 185.29,230 185.42,230.12 185.42,231.9 185.54,232.03 188.34,232.03 188.59,231.77 188.59,228.6 188.46,228.47 181.73,228.47 181.48,228.73 181.48,231.9
+VCCCORE_PH8_OUT on BOTTOM: 181.73,228.47 186.69,228.47 186.81,228.6 186.81,229.61 187.1,229.91 187.1,230.32 187.25,230.46 190.64,230.46 190.75,230.57 190.75,234.06 190.37,234.44 181.73,234.44 181.48,234.19 181.48,228.73
+VCCDDQ_EDGECAP2 on BOTTOM: 214.24,171.7 215.26,170.69 215.51,170.69 215.77,170.43 215.77,170.05 215.9,169.92 216.53,169.92 216.78,170.18 216.78,171.58 216.66,171.7 215.26,171.7 215.01,171.96 215.01,172.59 215.26,172.85 215.26,173.23 215.13,173.35 214.37,173.35 214.24,173.23
+VCCDPHY_1P24 on LAY6: 89.28,152.02 93.09,148.21 99.95,148.21 100.2,147.95 100.2,147.83 98.55,146.18 91.69,146.18 87.44,150.43 87.44,152.97 84.07,156.34 84.07,157.1 84.39,157.42 86.93,157.42 89.28,155.07
+VCCGT on TOP: 238.9,179.59 238.36,179.05 238.36,178.32 238.22,178.18 235.25,178.18 234.85,177.78 234.85,174.35 234.22,173.72 233.43,173.72 233.04,174.12 233.04,183.64 233.55,184.15 237.87,184.15 240.96,187.24 243.63,187.24 245.41,189.03 249.55,189.03 256.74,196.21 259.58,196.21 261.36,197.99 261.36,203.33 261.87,203.83 265.81,203.83 267.33,202.31 268.47,202.31 268.85,201.93 268.85,197.36 270.63,195.58 270.63,192.53 269.74,191.64 269.74,170.05 269.49,169.8 268.41,169.8 266.85,171.35 263.53,171.35 254.43,180.45 242.9,180.45 242.04,179.59
+VCCGT on BOTTOM: 234.83,177.67 234.83,175.6 234.6,175.37 234.37,175.37 233.55,174.54 233.55,173.99 233.42,173.86 232.15,173.86 232.02,173.99 232.02,183.51 233.04,184.53 238.25,184.53 238.88,185.16 241.8,185.16 244.47,187.83 246.5,187.83 248.29,189.62 253.36,189.62 255.38,191.64 265.04,191.64 268.85,195.45 270.38,195.45 270.63,195.2 270.63,192.53 267.2,189.1 267.2,184.28 267.71,183.77 271.01,183.77 271.14,183.64 271.14,178.94 270.76,178.56 267.84,178.56 267.33,178.05 267.33,174.24 267.71,173.86 271.14,173.86 271.39,173.61 271.39,170.31 270.89,169.8 265.04,169.8 254.46,180.39 243.39,180.39 242.34,179.33 236.49,179.33 235.21,178.05
+VCCGT_OUT1 on TOP: 276.6,189.74 276.6,187.83 276.22,187.45 275.46,187.45 275.33,187.58 273.93,187.58 273.81,187.45 273.81,186.31 272.66,185.16 271.14,185.16 270.76,185.55 270.76,187.83 271.01,188.09 271.39,188.09 273.3,189.99 276.35,189.99
+VCCGT_OUT1 on BOTTOM: 267.97,188.09 271.39,188.09 273.3,189.99 276.35,189.99 276.6,189.74 276.6,186.31 275.2,184.91 268.09,184.91 267.71,185.29 267.71,187.83
+VCCGT_OUT2 on TOP: 271.01,177.93 275.97,177.93 276.35,177.54 276.35,176.27 275.97,175.89 275.08,175.89 274.82,176.15 273.93,176.15 273.68,175.89 273.68,174.88 273.43,174.62 270.89,174.62 270.76,174.75 270.76,177.67
+VCCGT_OUT2 on BOTTOM: 268.09,178.05 276.09,178.05 276.35,177.8 276.35,176.02 274.95,174.62 271.65,174.62 271.27,175 268.09,175 267.84,175.26 267.84,177.8
+VCCIO_0 on TOP: 179.95,188.72 179.95,183.77 180.21,183.51 183.13,183.51 183.38,183.26 183.38,179.96 182.37,178.94 177.92,178.94 176.65,180.21 176.65,187.96 175.76,188.85 175.76,190.5 176.02,190.75 177.92,190.75
+VCCIO_0 on TOP: 213.74,181.86 214.12,181.86 214.5,181.48 214.88,181.48 215.01,181.35 215.01,177.67 214.88,177.54 214.12,177.54 213.74,177.93
+VCCIO_0 on BOTTOM: 212.09,175.37 211.9,175.18 210.74,175.18 210.71,175.21 210.71,176.78 210.58,176.91 209.29,176.91 208.78,177.42 208.78,177.65 208.28,178.15 208.28,178.54 208.4,178.66 209.81,178.66 209.24,179.23 209.24,180 210.26,181.02 210.26,181.39 209.82,181.83 209.06,181.83 208.97,181.91 208.97,184.1 209.07,184.2 209.08,184.2 210.53,185.65 211.94,185.65 212.09,185.49
+VCCIO_0 on LAY2: 176.88,187.98 190.71,187.98 194.26,184.42 202.35,184.42 202.63,184.7 202.63,184.67 202.87,184.43 204.12,184.43 204.36,184.67 204.36,185 204.12,185.24 203.17,185.24 203.37,185.44 210.01,185.44 213.57,181.88 214.58,181.88 215.29,181.18 215.29,178.09 214.97,177.78 209.97,177.78 209.72,178.03 209.25,178.03 208.99,177.78 208.95,177.78 208.7,178.03 208.36,178.03 208.1,177.78 208.06,177.78 207.81,178.03 207.47,178.03 207.22,177.78 205.02,177.78 204,178.79 203.07,178.79 202.95,178.68 202.72,178.67 202.51,178.89 202.22,179.17 192.36,179.17 185.5,172.32 184.99,172.32 182.77,170.1 182.77,169.33 182.32,168.89 179.87,168.89 179.42,169.33 179.42,174.03 178.47,174.98 177.52,174.98 177.52,175.3 175.23,177.59 175.23,178.14 176.88,179.79 ; 2 cut-outs
+VCCIO_0_OUT on TOP: 169.92,194.18 169.67,193.93 169.67,192.53 169.79,192.4 171.95,192.4 172.46,191.9 177.29,191.9 177.67,192.28 177.67,193.29 177.03,193.93 177.03,195.83 176.78,196.09 174.24,196.09 173.99,195.83 173.99,194.69 173.48,194.18
+VCCIO_1_2 on TOP: 214.12,177.29 214.88,177.29 215.39,176.78 215.64,176.78 215.77,176.66 215.77,176.53 215.13,175.89 215.13,175.13 214.37,174.37 213.86,174.37 213.74,174.5 213.74,174.62 214.12,175
+VCCIO_1_2 on TOP: 163.44,161.54 165.98,161.54 166.37,161.16 166.37,156.08 166.49,155.95 168.02,155.95 168.21,155.76 168.21,151.07 168.65,150.62 168.65,149.22 168.52,149.1 166.11,149.1 165.73,149.48 165.73,150.87 163.06,150.87 162.81,151.13 162.81,160.91
+VCCIO_1_2 on TOP: 214.75,171.96 216.02,170.69 216.02,169.8 215.77,169.54 213.36,169.54 211.58,171.32 211.58,171.7 211.83,171.96
+VCCIO_1_2 on BOTTOM: 213.99,171.77 215.51,170.25 215.51,169.8 215.26,169.54 213.36,169.54 211.07,171.83 211.07,172.59 210.69,172.97 210.69,174.12 210.94,174.37 211.32,174.37 211.58,174.12 211.58,173.23 211.83,172.97 213.86,172.97 213.99,172.85
+VCCIO_1_2 on LAY3: 211.61,175.05 210.79,174.23 210.79,171.9 213.14,169.55 215.62,169.55 216.45,170.38 227.47,170.38 227.97,170.87 227.97,173.73 226.64,175.05
+VCCIO_1_2 on LAY8: 215.47,170.5 215.47,169.67 213.61,169.67 212.46,170.81 211.32,170.81 210.83,171.31 210.83,176.82 208.98,178.67 204.05,178.67 203.42,179.3 197.44,179.3 167.21,149.07 164.5,149.07 164.31,149.27 164.31,154.77 165.2,155.66 165.2,157.05 168.5,160.36 168.5,161.12 175.93,168.55 175.93,173.48 177.23,174.77 178.01,174.77 185.92,182.69 214.87,182.69 215.75,181.8 215.75,170.79 ; 1 cut-out
+VCCIO_1_2_OUT on TOP: 158.11,163.83 158.75,163.83 159.25,163.32 163.19,163.32 163.57,162.94 163.57,162.3 163.32,162.05 162.3,162.05 161.92,161.67 161.92,159.76 161.79,159.64 158.24,159.64 157.98,159.89 157.98,163.7
+VCCPGPPA_3P3_1P8 on LAY2: 77.91,144.55 78.12,144.33 80.09,142.36 82.76,142.36 82.98,142.14 91.77,142.14 91.77,142.14 91.86,142.14 93.64,143.91 98.45,143.91 98.45,142.2 99.21,141.43 99.21,138.4 97.74,138.4 97.36,138.02 95.46,138.02 94.2,136.77 94.2,137.84 93,139.04 88.34,139.04 87.45,138.15 85.3,138.15 82.56,135.4 81.97,135.99 79.67,135.99 76.55,139.11 76.55,139.91 76.55,139.91 76.55,143.8 76.55,143.81 76.55,144.3 76.62,144.3 76.87,144.55 77.89,144.55 ; 1 cut-out
+VCCPGPPBC_3P3_1P8 on LAY2: 68.74,151.03 69.17,151.03 69.17,151.03 69.8,151.03 71.33,149.5 75.98,149.5 75.99,149.5 76.86,149.5 76.86,147.91 78.54,146.2 79.2,146.2 79.2,146.2 83.98,146.2 84.49,146.71 92.03,146.71 92.66,146.07 98.7,146.07 98.7,144.31 98.5,144.12 93.55,144.12 91.77,142.34 83.07,142.34 82.85,142.56 80.17,142.56 78.26,144.47 77.99,144.75 77.89,144.75 77.89,144.75 76.79,144.75 76.73,144.69 76.73,144.69 76.53,144.5 73.49,144.5 73.11,144.12 72.09,144.12 71.71,143.74 67.6,143.74 67.41,143.93 67.41,145.37 68.04,146.01 68.04,150.33
+VCCPGPPBC_3P3_1P8 on LAY5: 69.85,151.51 72,151.51 72.77,150.75 72.77,145.54 72.26,145.03 72.26,143.13 72,142.87 71.12,142.87 70.23,143.76 70.23,148.21 71.37,149.35 71.37,149.73 71.12,149.99 69.72,149.99 69.46,150.24 69.46,151.13
+VCCPGPPBC_3P3_1P8 on LAY6: 77.59,84.2 76.2,84.2 75.69,83.69 75.69,82.55 74.8,81.66 74.8,76.58 75.18,76.2 76.32,76.2 76.96,76.83 76.96,80.77 77.59,81.41
+VCCPGPPD_3P3_1P8 on LAY2: 77.51,151.03 78.19,151.03 80.22,148.99 86.19,148.99 86.57,148.61 93.68,148.61 93.93,148.36 98.7,148.36 98.7,146.28 92.75,146.28 92.11,146.91 84.41,146.91 83.9,146.4 79.2,146.4 79.2,146.4 78.63,146.4 77.06,147.99 77.06,150.58
+VCCPGPPEF_3P3_1P8 on LAY2: 100.49,142.52 102.75,142.52 102.51,142.28 102.51,131.61 101.49,130.6 101.49,126.96 102.13,126.32 102.13,120.23 103.53,118.83 103.53,112.69 102.51,111.67 102.51,110.84 95.54,110.84 95.35,111.04 95.35,112.99 96.74,114.38 96.74,116.5 96.36,116.88 96.36,129.88 99.41,132.93 99.41,141.43 ; 1 cut-out
+VCCPGPPHK_3P3_1P8 on LAY2: 103.04,142.52 104.23,142.52 104.31,142.44 104.54,142.2 104.54,140.93 104.67,140.8 104.67,137.27 105.08,136.87 105.08,136.52 105.34,136.26 105.49,136.26 105.61,136.13 106.06,136.13 106.31,135.89 106.31,129.89 106.32,129.88 108.99,127.21 108.99,111.17 108.41,110.59 102.91,110.59 102.71,110.78 102.71,111.59 103.73,112.61 103.73,118.91 102.33,120.31 102.33,126.41 101.7,127.04 101.7,130.51 102.71,131.53 102.71,142.2
+VCCPHVLDO_1P8 on LAY6: 98.17,157.86 99.56,157.86 100.07,157.35 100.07,151.64 101.85,149.86 101.85,149.35 101.6,149.1 101.47,149.1 101.09,149.48 99.82,149.48 98.93,150.37 98.93,154.43 98.04,155.32 98.04,157.73
+VCCPRIM_1P05 on TOP: 134.23,109.73 134.23,107.69 133.98,107.44 128.77,107.44 128.52,107.69 128.52,112.52 128.77,112.77 134.49,112.77 134.62,112.65 134.62,111.89 134.36,111.63 134.36,109.85
+VCCPRIM_1P05 on TOP: 103.5,180.47 104.77,180.47 104.9,180.34 104.9,179.2 104.77,179.07 103.5,179.07 103.25,179.32 103.25,180.21
+VCCPRIM_1P05 on TOP: 100.07,175.77 101.47,175.77 101.6,175.64 101.6,173.61 101.34,173.35 100.83,173.35 99.94,174.24 99.94,175.64
+VCCPRIM_1P05 on TOP: 112.9,158.49 112.9,158.37 112.64,158.11 112.64,157.99 113.41,157.22 113.66,157.22 113.66,158.14 114.28,158.76 114.3,158.75 114.8,158.75 115.06,159 115.06,159.89 114.8,160.15 114.55,160.15
+VCCPRIM_1P05 on TOP: 117.09,108.96 116.96,109.09 116.96,110.27 117.11,110.13 117.31,110.08 117.71,110.49 117.31,110.9 117.11,110.84 116.96,110.71 116.96,111.12 117.09,111.25 118.74,111.25 119.12,111.63 119.38,111.63 119.5,111.5 119.5,109.09 119.38,108.96
+VCCPRIM_1P05 on BOTTOM: 100.11,143.61 100.15,143.63 100.88,143.63 100.99,143.53 102.69,143.53 102.8,143.63 103.59,143.63 104.08,143.68 104.17,144.16 104.26,144.26 104.69,144.26 104.86,144.08 104.86,143.45 104.55,143.13 99.29,143.13 98.99,143.44 98.99,148.5 99.35,148.86 100.12,148.86 100.14,148.84 101.6,148.84 101.99,149.23 101.99,150.48 102.49,150.99 102.78,150.99 102.94,150.83 102.94,150.29 102.48,149.84 102.48,148.59 102.21,148.31 100.35,148.31 100.31,148.27 99.73,148.27 99.53,148.06 99.53,147.49 99.52,147.48 99.52,143.92 99.53,143.92 99.71,143.64 100.04,143.59 100.08,143.6
+VCCPRIM_1P05 on BOTTOM: 105.23,143.7 105.06,143.88 105.06,144.25 104.88,144.43 104.87,144.45 104.88,144.48 104.97,144.65 104.98,144.84 104.92,144.97 104.82,145.08 104.79,145.14 104.82,145.2 104.87,145.24 104.98,145.45 104.96,145.68 104.9,145.77 104.82,145.85 104.79,145.91 104.82,145.97 104.95,146.12 104.99,146.32 104.97,146.41 104.93,146.5 104.93,146.58 105,146.62 105.93,146.62 106.42,146.12 106.42,145.41 105.91,144.91 105.91,143.83 105.79,143.7
+VCCPRIM_1P05 on BOTTOM: 100.47,144.41 100.39,144.49 100.39,147.97 100.54,148.12 102.4,148.12 102.74,148.46 102.74,149.48 102.99,149.73 103.41,149.73 103.47,149.67 103.47,149.64 103.47,149.63 103.41,149.31 103.59,149.05 103.59,148.97 103.47,148.85 103.4,148.69 103.4,148.68 103.65,148.25 104.13,148.38 104.19,148.42 104.25,148.38 104.29,148.34 104.34,148.3 104.37,148.24 104.17,147.85 104.37,147.46 104.34,147.4 104.18,147.14 104.25,146.84 104.04,146.63 103.95,146.68 103.84,146.71 103.48,146.54 103.43,146.14 103.59,145.96 103.83,145.9 104.09,145.64 104.09,144.64 103.86,144.41
+VCCPRIM_1P05 on LAY2: outline of 172 points within 93.19,89.38 141.75,181.51 ; 61 cut-outs
+VCCPRIM_1P8 on BOTTOM: 71.75,165.35 74.42,165.35 74.67,165.1 74.67,163.83 74.29,163.45 73.02,163.45 72.64,163.83 72,163.83 71.75,164.08
+VCCPRIM_1P8 on BOTTOM: 101.35,150.11 101.35,149.36 101.09,149.1 100.39,149.1 99.67,149.81 99.67,149.86 99.18,150.35 99.18,150.62 98.93,150.87 98.04,150.87 97.79,151.13 96.64,151.13 96.39,151.38 96.39,151.76 96.64,152.02 99.06,152.02 99.82,151.26 99.82,150.49 100.01,150.3 100.34,150.3 100.47,150.3 100.54,150.37 101.09,150.37
+VCCPRIM_1P8 on LAY2: 67.47,167.92 69.93,167.92 71.58,166.27 75.65,166.27 76.03,165.89 78.44,165.89 79.71,164.62 80.09,164.62 81.87,162.84 83.93,162.84 84.92,161.85 84.92,161.85 84.96,161.81 84.96,159.07 86.26,157.76 86.44,157.76 86.44,157.76 87.79,157.76 90.45,155.09 90.88,155.09 90.89,155.09 92.62,155.09 92.66,155.09 92.77,155.21 92.89,155.21 92.96,155.14 92.96,154.95 92.92,154.91 92.6,154.6 92.6,154.13 92.79,153.95 93.38,153.95 93.76,154.33 93.93,154.33 94.13,154.13 94.13,153.04 94.36,152.81 94.54,152.81 94.99,152.36 95.39,152.36 95.7,152.04 97.36,152.04 97.36,152.04 97.45,152.04 97.45,152.04 97.74,152.04 98.06,151.72 98.06,150.72 95.03,150.72 94.27,151.48 92.49,151.48 92.11,151.87 82.9,151.87 82.9,152.06 75.98,158.98 74.08,158.98 73.82,159.23 73.7,159.23 72.05,160.88 71.16,160.88 69.06,162.98 69.06,164.63 69,164.69 69,164.69 67.28,166.41 67.28,167.72
+VCCPRIM_3P3 on BOTTOM: 87.37,159.38 91.44,155.32 92.96,155.32 93.09,155.19 93.72,155.19 93.98,155.45 94.36,155.45 94.87,154.94 94.87,154.18 94.74,154.05 94.61,154.05 94.23,153.67 91.82,153.67 87.5,157.99 86.36,157.99 82.04,162.3 81.78,162.3 80.26,163.83 80.01,163.83 79.75,164.08 79.75,165.1 79.12,165.73 77.34,165.73 76.83,166.24 75.94,166.24 75.81,166.37 75.81,166.88 76.2,167.26 79.88,167.26 84.45,162.69 84.45,161.67 86.74,159.38
+VCCPRIM_3P3 on LAY2: 82.9,151.66 92.03,151.66 92.41,151.28 94.19,151.28 94.95,150.52 98.12,150.52 98.7,149.94 98.7,148.56 94.02,148.56 93.76,148.82 86.65,148.82 86.27,149.2 82.9,149.2
+VCCPRIM_3P3 on LAY6: 89.02,161.29 96.26,161.29 97.79,159.77 97.79,155.19 98.8,154.18 98.8,150.37 99.94,149.22 100.71,149.22 101.21,148.72 101.21,147.45 100.96,147.19 100.96,143.89 101.21,143.64 104.64,143.64 105.15,144.14 105.15,147.45 105.28,147.57 106.04,147.57 106.3,147.32 106.3,147.06 107.31,146.05 107.31,143.76 106.42,142.87 100.58,142.87 99.82,142.11 99.82,137.03 99.18,136.4 96.26,136.4 95.75,136.9 95.75,137.92 97.66,139.83 97.66,142.87 98.8,144.02 98.8,146.18 100.33,147.7 100.33,148.08 100.07,148.33 98.04,148.33 98.04,148.34 93.47,148.34 89.72,152.08 89.72,153.73 89.66,153.8 89.66,155.83 85.47,160.02 83.56,160.02 82.8,160.78 82.8,161.41 80.51,163.7 80.01,163.7 79.62,164.08 79.62,164.97 80.01,165.35 84.96,165.35
+VCCPSPI_PCH_3P3_1P8 on LAY2: 97.83,138.2 99.21,138.2 99.21,133.01 96.16,129.96 96.16,122.27 93.26,122.27 92.81,122.72 92.81,125.43 93.44,126.07 93.44,130.64 96.62,133.81 96.62,136.48 97.51,137.37 97.51,137.88
+VCCSA on TOP: 175.76,242.31 176.27,242.82 179.07,242.82 179.19,242.7 179.19,239.14 178.94,238.89 178.94,237.23 180.46,235.71 180.46,231.01 179.95,230.5 175,230.5 174.75,230.76 174.75,238.12 175.76,239.14
+VCCSA on TOP: 214.31,184.21 214.17,184.06 214.17,182.1 214.22,182.05 214.31,182.05 214.75,181.61 215.51,181.61 215.77,181.86 215.77,181.99 215.36,182.4 215.36,183.49 215.64,183.77 215.64,184.02 215.46,184.21
+VCCSA on BOTTOM: 214.25,189.81 214.25,188.81 215.17,187.89 215.17,187.12 214.25,186.2 213.61,186.2 212.93,186.87 212.93,189.81
+VCCSA on BOTTOM: 175,238.76 178.3,238.76 178.43,238.63 178.43,237.74 180.46,235.71 180.46,231.01 179.95,230.5 175.38,230.5 174.75,231.14 174.75,238.5
+VCCSA on LAY2: outline of 93 points within 165.84,181.33 217.82,237.26 ; 39 cut-outs
+VCCSFR on TOP: 201.93,187.2 197.23,187.2 193.42,191.01 185.54,191.01 185.42,190.88 185.42,189.99 185.67,189.74 189.35,189.74 191.64,187.45 193.67,187.45 194.18,186.94 194.18,186.05 194.81,185.42 202.18,185.42 202.81,186.05 202.81,186.31
+VCCSFR on TOP: 181.61,196.34 180.59,196.34 180.46,196.47 180.46,198.63 180.59,198.75 181.99,198.75 182.24,198.5 182.24,197.36 181.73,196.85 181.73,196.47
+VCCSFR_MIX on TOP: 177.16,211.33 177.16,210.69 177.03,210.56 176.65,210.56 175.13,209.04 175.13,208.15 175,208.02 173.86,208.02 173.73,208.15 173.73,210.69 173.86,210.82 174.75,210.82 175.38,211.45 177.03,211.45
+VCCSFR_OC on TOP: 177.41,198.63 177.41,196.47 177.29,196.34 176.14,196.34 175.89,196.59 175.89,198.5 176.14,198.75 177.29,198.75
+VCCSFR_OC on TOP: 177.29,208.66 177.29,206.75 177.03,206.5 174.87,206.5 174.24,207.14 174.24,207.52 174.49,207.77 175.38,207.77 175.64,208.02 175.64,208.79 175.89,209.04 176.65,209.04 176.91,208.79 177.16,208.79
+VCCSFR_OC on LAY5: 174.24,207.77 178.94,207.77 179.95,206.75 179.95,198.75 178.43,197.23 178.43,194.05 178.81,193.67 184.53,193.67 190.11,188.09 190.11,187.2 193.42,183.89 193.42,176.57 192.07,175.23 190.02,175.23 189.48,175.77 189.48,184.66 188.21,185.93 188.21,186.69 185.67,189.23 176.14,189.23 173.86,191.51 173.86,198.44 175.7,200.28 175.7,201.67 173.99,203.39 173.99,207.52
+VCCSFR_OC on LAY6: 192.91,177.04 191.38,175.51 191.38,175 196.08,170.31 196.08,165.35 208.66,152.78 209.42,152.78 211.96,155.32 229.36,155.32 230.5,156.46 230.5,165.86 230.37,165.99 229.61,165.99 229.36,165.73 229.36,159.13 228.09,157.86 219.2,157.86 218.31,158.75 218.31,165.86 218.05,166.11 216.15,166.11 215.9,165.86 215.9,160.53 213.61,158.24 206.5,158.24 197.86,166.88 197.86,172.59 193.42,177.04
+VCCSFR_OC_R1 on TOP: 167.38,209.55 167.38,211.71 167.51,211.83 171.83,211.83 173.35,210.31 173.35,209.42 173.1,209.17 167.76,209.17
+VCCST on TOP: 178.56,198.63 180.08,198.63 180.21,198.5 180.21,196.59 182.62,194.18 183.13,194.18 184.53,192.78 184.53,190.63 185.54,189.61 189.1,189.61 194.05,184.66 202.56,184.66 202.94,184.28 203.7,184.28 204.08,184.66 204.72,184.66 204.85,184.53 204.85,183.01 204.72,182.88 202.56,182.88 202.05,182.37 190.37,182.37 188.59,184.15 184.27,184.15 183.38,185.04 183.38,187.07 183.13,187.32 180.46,187.32 180.08,187.7 180.08,188.72 178.43,190.37 178.43,193.17 179.32,194.05 179.32,194.44 178.94,194.82 178.94,196.85 178.43,197.36 178.43,198.5
+VCCST on LAY5: 178.68,196.09 188.21,196.09 191.26,193.04 191.26,192.15 192.15,191.26 192.15,186.18 191.89,185.93 191.77,185.93 190.75,186.94 190.75,187.7 184.78,193.67 178.81,193.67 178.43,194.05 178.43,195.83
+VCCST_VCCSFR on TOP: 133.09,117.6 135.38,117.6 135.5,117.47 135.5,116.46 135.25,116.2 133.09,116.2 132.84,116.46 132.84,117.35
+VCCST_VCCSFR on TOP: 182.11,200.28 182.11,199.64 181.73,199.26 176.65,199.26 176.4,199.52 176.4,200.91 176.27,201.04 173.99,201.04 173.86,201.17 173.86,201.42 175,202.56 177.8,202.56 178.3,202.06 180.72,202.06 180.84,201.93 180.84,200.79 181.22,200.4 181.99,200.4
+VCCST_VCCSFR on TOP: 124.33,87.37 124.33,86.49 124.07,86.23 121.41,86.23 121.15,86.49 121.15,87.37 121.28,87.5 124.2,87.5
+VCCST_VCCSFR on BOTTOM: 126.11,59.05 128.52,59.05 130.81,56.77 130.81,50.67 129.54,49.4 128.01,49.4 127.88,49.53 127.88,50.16 128.39,50.67 128.39,51.94 127.76,52.58 127.76,56.13 125.85,58.04 125.85,58.8
+VCCST_VCCSFR on BOTTOM: 121.41,88.01 123.19,88.01 123.31,87.88 123.31,86.36 122.93,85.98 121.15,85.98 121.03,86.1 121.03,87.63
+VCCST_VCCSFR on LAY5: 175.38,200.53 175.38,201.55 174.62,202.31 167.25,202.31 161.54,196.59 161.54,191.51 161.92,191.13 164.97,191.13 165.35,191.51 165.35,192.15 164.21,193.29 164.21,194.44 164.71,194.94 167.38,194.94 169.41,196.98 172.84,196.98 173.22,197.36 173.22,198.37
+VCCST_VCCSFR on LAY5: 133.6,117.6 135.89,117.6 137.47,119.19 138.68,119.19 138.93,118.93 138.93,115.7 138.04,114.81 136.01,114.81 135,115.82 133.35,115.82 133.09,116.08 133.09,117.09
+VCCSTG on TOP: 185.29,196.72 185.29,198.63 185.42,198.75 188.59,198.75 188.84,198.5 188.84,196.98 188.59,196.72
+VCCSTG on TOP: 192.4,187.32 193.67,187.32 194.05,186.94 194.05,185.67 193.8,185.42 193.54,185.42 192.15,186.82 192.15,187.07
+VCCSTG on LAY5: 192.4,188.09 193.42,188.09 193.67,187.83 193.67,186.05 193.29,185.67 192.65,185.67 192.27,186.05 192.27,187.96
+VCCSTG on LAY5: 89.4,180.97 89.02,180.97 88.77,180.72 88.77,178.81 89.78,177.8 95.5,177.8 95.75,178.05 95.75,179.2 95.37,179.58 93.85,179.58 92.96,180.47 89.91,180.47
+VCCSTG_LW on TOP: 186.18,201.93 186.05,202.06 183.76,202.06 183.64,201.93 183.64,200.91 183.38,200.66 183.38,199.64 183.51,199.52 186.81,199.52 186.94,199.64 186.94,200.28 186.81,200.4 186.56,200.4 186.18,200.79
+VCCSTG_OUT on TOP: 205.74,186.43 206.37,186.43 207.13,185.67 208.15,185.67 208.28,185.55 208.28,185.16 208.15,185.04 205.86,185.04 205.35,185.55 205.35,186.05
+VCCSTG_OUT on TOP: 163.7,194.18 164.46,194.18 165.35,193.29 165.35,192.91 165.1,192.66 163.7,192.66 163.57,192.78 163.57,194.05 ; 1 cut-out
+VCCSTG_OUT on TOP: 184.91,198.63 184.91,196.72 184.78,196.59 184.15,196.59 183.89,196.34 183.38,196.34 183.26,196.47 183.26,198.5 183.38,198.63
+VCCSTG_OUT on LAY5: 173.86,177.8 173.1,177.8 167.76,183.13 167.76,190.37 165.48,192.66 165.1,192.66 164.71,193.04 164.71,194.18 165.1,194.56 169.29,194.56 174.24,189.61 174.24,178.18
+VCCSTG_OUT on LAY5: 183.26,196.59 183.64,196.21 185.42,196.21 186.81,197.61 188.46,197.61 200.91,185.16 205.99,185.16 206.37,185.55 206.37,186.18 205.61,186.94 204.34,186.94 202.43,188.85 202.43,191.13 197.86,195.71 193.54,195.71 188.72,200.53 184.02,200.53 183.26,199.77
+VCCSTG_OUT on LAY6: 173.1,177.42 174.62,177.42 174.75,177.54 174.75,179.32 174.62,179.45 173.1,179.45 172.84,179.2 172.84,177.67
