# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DATA_B<43>: length 91.3
  TOP w0.088: J1F3.260 179.7,100.97 179.25,102.76 179.25,103.23 v1(179.8,103.93) 179.8,104.71 179.89,104.8 180.01,104.8 180.1,104.89 180.1,105.02 180.03,105.1 179.75,105.1 179.67,105.17 179.67,105.3 179.76,105.39 179.98,105.39 180.07,105.48 180.07,105.64 179.92,105.78 J1F2.260
  TOP w0.165: v3(206.69,167.46) J3D1.AR5
  LAY9 w0.088: 202.55,165.01 202.79,165.24 202.97,165.24 203.84,166.11 205.1,166.11 205.38,166.39 205.38,166.72 205.61,166.96 206.33,166.96 206.69,167.33 v3(206.69,167.46)
  LAY9 w0.089: 202.55,165.01 202.55,164.83 201.67,163.95 186.83,149.1 186.83,145.06 187.54,144.34 187.54,142.09 186.91,141.46 186.91,141.46 186.91,141.46 183.75,138.3 183.63,138.3 183.49,138.44 183.37,138.44 183.04,138.12 183.04,137.99 183.18,137.85 183.18,137.73 182.86,137.41 182.73,137.41 182.62,137.51 182.5,137.51 182.18,137.19 182.18,137.06 182.28,136.96 182.28,136.83 181.96,136.51 181.96,133.28 181.27,132.58 181.27,132.09 181.41,131.94 181.41,131.17 182.26,130.32 182.26,129.59 182.27,129.58 183.11,128.09 183.11,127.55 182.26,126.7 182.26,125.88 183.09,124.12 183.09,123.62 182.25,122.77 182.25,121.74 183.09,120.28 183.09,119.82 182.25,118.97 182.25,118.21 181.87,117.84 181.87,115.22 181.19,114.54 181.19,113.95 181.41,113.73 181.41,113.19 180.56,112.35 180.56,111.6 179.71,110.75 179.71,109.4 179.28,108.96 179.28,107.79 179.8,107.27 v1(179.8,103.93)
M_DATA_B<44>: length 92
  TOP w0.088: J1F3.106 188.03,103.92 188.03,104.1 188.19,104.27 188.19,105.1 188.25,105.16 188.25,105.29 188.16,105.38 188,105.38 187.91,105.47 187.91,105.64 188,105.73 188.3,105.73 188.39,105.82 188.39,105.96 188.23,106.12 188.23,106.79 v1(188.33,107.13) 187.78,107.8 187.78,108.32 188.2,109.41 J1F2.106
  TOP w0.165: J3D1.AP8 v3(210.37,168.38)
  LAY9 w0.088: v3(210.37,168.38) 210.37,168.33 210.82,167.88 210.82,166.4 211.05,166.17 211.05,165.98 210.87,165.8 210.87,165.47 211.05,165.28 211.05,165.07 210.96,164.97 210.87,164.88 210.87,164.55 210.96,164.46 210.96,164.06 210.87,163.97 210.87,163.8 210.21,163.14 209.73,163.14 209.5,162.91 209.5,162.48 208.02,161 207.44,161 206.78,160.33
  LAY9 w0.089: v1(188.33,107.13) 187.78,107.68 187.78,108.33 188.63,109.18 188.63,110.74 187.78,111.59 187.78,112.13 188.63,112.98 188.63,114.05 188.89,114.31 188.89,114.75 189.76,115.62 189.76,117.91 189.46,118.22 189.46,118.75 190.3,119.59 190.3,119.61 190.31,119.62 190.31,121.17 189.46,122.02 189.46,122.55 190.31,123.4 190.31,125.16 189.48,125.99 189.48,126.52 190.32,127.36 190.32,127.41 190.33,127.42 190.33,128.94 189.48,129.79 189.48,130.54 188.63,131.39 188.63,131.92 189.03,132.33 189.03,134.68 189.12,134.77 189.58,134.77 189.67,134.68 189.67,132.7 189.76,132.61 190.18,132.61 190.3,132.73 190.3,137.24 194.8,141.74 194.8,149.08 194.9,149.18 194.9,149.18 201.56,155.84 202.29,155.84 206.78,160.33
M_DATA_B<45>: length 91.6
  TOP w0.088: J1F3.251 187.34,103.22 186.91,104.3 186.91,104.83 v1(187.46,105.5) 187.36,105.84 187.36,106.58 187.17,106.78 187.17,106.91 187.26,106.99 187.59,106.99 187.67,107.08 187.67,107.24 187.59,107.33 187.45,107.33 187.36,107.42 187.36,108.33 187.19,108.5 187.19,108.77 J1F2.251
  TOP w0.165: J3D1.AT8 v3(210.37,166.55)
  LAY9 w0.088: 205.78,160.23 207.02,161.47 207.62,161.47 208.58,162.43 208.58,162.91 208.95,163.28 209.5,163.28 210.37,164.15 210.37,164.25 210.68,164.55 210.68,164.88 210.51,165.06 210.51,165.29 210.68,165.47 210.68,165.8 210.37,166.11 v3(210.37,166.55)
  LAY9 w0.089: 205.78,160.23 202.02,156.47 201.3,156.47 194.17,149.35 194.17,142.01 191.13,138.97 189.67,137.51 189.67,137.2 189.67,136.45 189.67,136.45 189.67,135.74 189.58,135.65 189.13,135.65 189.04,135.74 189.04,135.93 188.95,136.01 188.72,136.01 188.39,135.69 188.39,133.56 188.3,133.47 187.85,133.47 187.76,133.56 187.76,134.88 187.67,134.97 187.21,134.97 187.12,134.88 187.12,133.17 187.57,132.73 187.72,132.73 188.21,132.24 188.21,131.17 189.06,130.32 189.06,129.59 189.07,129.58 189.91,128.09 189.91,127.55 189.06,126.7 189.06,125.88 189.89,124.12 189.89,123.62 189.05,122.77 189.05,121.74 189.89,120.28 189.89,119.82 189.05,118.97 189.05,117.51 189.1,117.46 189.1,116.02 188.21,115.13 188.21,113.19 187.36,112.34 187.36,110.78 188.21,109.93 188.21,109.39 187.36,108.54 187.36,106.03 187.46,105.92 v1(187.46,105.5)
M_DATA_B<46>: length 90.3
  TOP w0.088: J1F2.113 182.47,113.46 182.47,110.87 181.52,109.92 181.52,109.33 v1(181.92,108.92) 182.35,108.92 182.51,108.77 182.51,108.54 182.39,108.42 182.39,108.25 182.48,108.15 182.48,107.96 182.37,107.86 182.37,107.66 182.45,107.58 J1F3.113
  TOP w0.165: v3(207.52,166.55) J3D1.AT6
  LAY9 w0.088: v3(207.52,166.55) 207.52,166.19 207.12,165.8 207.12,165.5 206.8,165.17 206.56,165.17 206.22,164.83 206.22,164.46 206.08,164.32 205.97,164.32 205.54,163.89 204.45,163.89 204.35,163.78 204.35,163.64 204.11,163.41 203.82,163.41 203.73,163.32
  LAY9 w0.089: v1(181.92,108.92) 181.92,109.27 181.83,109.36 181.83,109.98 182.68,110.83 182.68,112.13 183.53,112.98 183.53,113.98 185.01,115.46 185.01,117.56 184.36,118.21 184.36,118.75 185.21,119.6 185.21,121.17 184.36,122.02 184.36,122.55 185.21,123.4 185.21,125.16 184.38,125.99 184.38,126.52 185.23,127.37 185.23,128.94 184.38,129.79 184.38,130.54 183.53,131.39 183.53,131.98 184.26,132.71 184.26,132.9 184.17,132.99 183.95,132.99 183.86,133.08 183.86,133.54 183.95,133.63 184.17,133.63 184.26,133.72 184.26,134.17 184.17,134.26 183.95,134.26 183.86,134.35 183.86,134.81 183.95,134.89 184.17,134.89 184.26,134.98 184.26,135.31 184.17,135.4 184.17,135.78 184.26,135.87 184.26,136.11 187.7,139.56 190.52,142.38 190.52,142.56 190.09,142.99 190.09,144.96 190.17,145.05 190.63,145.05 190.72,144.96 190.72,143.54 190.81,143.45 191.26,143.45 191.35,143.54 191.35,145.22 190.73,145.85 190.15,145.85 190.01,145.99 190.01,149.6 203.03,162.61 203.73,163.32
M_DATA_B<47>: length 91.7
  TOP w0.088: J1F3.258 181.4,100.97 180.95,102.76 180.95,103.23 v1(181.5,103.93) 181.5,104.71 181.59,104.8 181.71,104.8 181.8,104.89 181.8,105.02 181.73,105.1 181.45,105.1 181.37,105.17 181.37,105.3 181.46,105.39 181.68,105.39 181.77,105.48 181.77,105.64 181.62,105.78 J1F2.258
  TOP w0.165: J3D1.AP5 v3(207.61,168.38)
  LAY9 w0.088: v3(207.61,168.38) 207.61,168.06 207.11,167.56 207.11,166.4 206.85,166.14 206.56,166.14 206.24,165.82 206.24,165.53 205.83,165.12 205.61,165.12 205.31,164.82 205.31,164.51 205.13,164.32 203.9,164.32 203.49,163.91
  LAY9 w0.089: 203.49,163.91 203.49,163.63 203.3,163.44 203.13,163.44 202.74,163.05 202.57,163.05 189.36,149.84 189.36,144.39 189.27,144.3 188.94,144.3 188.85,144.21 188.85,143.75 188.94,143.66 189.27,143.66 189.36,143.57 189.36,143.12 189.27,143.03 188.94,143.03 188.85,142.94 188.85,142.48 188.94,142.39 189.27,142.39 189.36,142.31 189.36,142.12 187.44,140.19 187.44,140.19 183.23,135.98 183.23,132.58 183.11,132.47 183.11,131.17 183.96,130.32 183.96,129.59 183.97,129.58 184.81,128.09 184.81,127.55 183.96,126.7 183.96,125.88 184.79,124.12 184.79,123.62 183.95,122.77 183.95,121.74 184.79,120.28 184.79,119.77 183.95,118.92 183.95,117.64 184.13,117.19 184.13,115.55 183.11,114.53 183.11,113.19 182.26,112.35 182.26,111.6 181.42,110.76 181.42,108.77 180.98,108.33 180.98,107.79 181.5,107.27 v1(181.5,103.93)
M_DATA_B<48>: length 101.3
  TOP w0.088: J1F3.119 177.35,107.58 177.27,107.66 177.27,107.86 177.38,107.96 177.38,108.15 177.29,108.25 177.29,108.42 177.41,108.54 177.41,108.77 177.25,108.92 v1(176.82,108.92) 176.54,109.21 176.54,110.03 177.37,110.86 J1F2.119
  TOP w0.1: v3(207.61,170.2) J3D1.AM5
  LAY9 w0.088: 202.63,167.85 203.27,167.85 203.72,168.3 204.34,168.3 204.67,167.96 205.03,167.96 205.26,168.19 205.26,168.34 205.82,168.89 205.94,168.89 206.18,169.12 206.18,169.15 206.22,169.19 206.22,169.43 206.51,169.71 206.8,169.71 207.28,170.2 v3(207.61,170.2)
  LAY9 w0.089: v1(176.82,108.92) 176.73,109.29 176.73,110.74 175.88,111.59 175.88,112.13 176.72,112.97 176.72,112.98 176.73,112.98 176.73,116.79 177.64,117.7 177.64,118.11 177.56,118.19 177.56,118.75 178.41,119.6 178.41,121.15 178.38,121.18 178.38,121.2 177.56,122.02 177.56,122.55 178.41,123.4 178.41,125.16 177.58,125.99 177.58,126.52 178.43,127.37 178.43,128.94 177.58,129.79 177.58,130.54 176.73,131.39 176.73,131.92 177.2,132.4 177.2,132.78 177.47,133.04 177.75,133.04 178.18,133.48 178.58,133.88 178.58,143.77 178.67,143.86 179.13,143.86 179.22,143.77 179.22,138.84 179.31,138.75 179.76,138.75 179.85,138.84 179.85,145.08 200.2,165.42 200.53,165.75 202.63,167.85
M_DATA_B<49>: length 100.7
  TOP w0.088: J1F2.264 176.52,105.78 176.67,105.64 176.67,105.48 176.58,105.39 176.36,105.39 176.27,105.3 176.27,105.17 176.35,105.1 176.63,105.1 176.7,105.02 176.7,104.89 176.61,104.8 176.49,104.8 176.4,104.71 v1(176.4,103.93) 175.85,103.23 175.85,102.76 176.3,100.97 J1F3.264
  TOP w0.165: v3(208.52,170.2) J3D1.AM6
  LAY9 w0.088: v3(208.52,170.2) 208.22,170.2 207.79,170.63 207.07,170.63 206.5,170.05 206.26,170.05 205.91,169.7 205.6,169.7 205.37,169.47 205.37,169.14 205.08,168.86 203.58,168.86 203.08,168.36 202.4,168.36
  LAY9 w0.089: 202.4,168.36 202.24,168.36 199.75,165.87 177.95,144.07 177.95,142.85 177.86,142.76 177.44,142.76 177.35,142.67 177.35,142.22 177.44,142.13 177.86,142.13 177.95,142.04 177.95,141.58 177.86,141.49 177.44,141.49 177.35,141.4 177.35,140.95 177.44,140.86 177.86,140.86 177.95,140.77 177.95,140.31 177.86,140.23 177.44,140.23 177.35,140.14 177.35,139.68 177.44,139.59 177.86,139.59 177.95,139.5 177.95,139.05 177.86,138.96 177.75,138.96 177.64,138.85 177.64,138.44 177.75,138.32 177.86,138.32 177.95,138.23 177.95,134.62 176.45,133.13 176.45,132.65 176.31,132.51 176.31,131.17 177.16,130.32 177.16,129.59 177.17,129.58 178.01,128.09 178.01,127.59 177.16,126.74 177.16,125.88 177.99,124.12 177.99,123.62 177.15,122.77 177.15,121.74 177.99,120.28 177.99,119.82 177.15,118.97 177.15,118.16 175.96,116.97 175.96,114.08 176.31,113.73 176.31,113.19 175.46,112.34 175.46,110.78 176.31,109.93 176.31,109.39 175.7,108.78 175.7,107.87 176.4,107.17 v1(176.4,103.93)
M_DATA_B<50>: length 101.2
  TOP w0.088: J1F2.126 171.2,109.41 170.78,108.32 170.78,107.8 v1(171.33,107.13) 171.23,106.79 171.23,106.12 171.39,105.96 171.39,105.82 171.3,105.73 171,105.73 170.91,105.64 170.91,105.47 171,105.38 171.16,105.38 171.25,105.29 171.25,105.16 171.19,105.1 171.19,104.27 171.03,104.1 171.03,103.92 J1F3.126
  TOP w0.165: J3D1.AL5 v3(207.61,172.03)
  LAY9 w0.088: v3(207.61,172.03) 207.26,172.03 206.86,172.43 206.02,172.43 205.96,172.49 205.56,172.49 205.54,172.47 203.67,172.47 203.2,172 202.75,172
  LAY9 w0.089: v1(171.33,107.13) 170.78,107.68 170.78,108.33 171.63,109.18 171.63,110.74 170.78,111.59 170.78,112.13 171.63,112.98 171.63,116.81 172.46,117.64 172.46,118.75 173.31,119.6 173.31,121.17 172.46,122.02 172.46,122.55 173.31,123.4 173.31,124.36 173.31,124.36 173.31,125.16 172.48,125.99 172.48,126.52 173.33,127.37 173.33,128.94 172.48,129.79 172.48,130.54 171.63,131.39 171.63,132.1 172.97,133.44 172.97,133.7 172.97,134.97 172.97,136.24 172.88,136.32 172.51,136.32 172.42,136.41 172.42,136.87 172.51,136.96 172.88,136.96 172.97,137.05 172.97,137.5 172.88,137.59 172.43,137.59 172.34,137.68 172.34,138.14 172.43,138.23 172.88,138.23 172.97,138.32 172.97,138.77 172.88,138.86 172.46,138.86 172.37,138.95 172.37,139.39 172.48,139.49 172.88,139.49 172.97,139.58 172.97,142.13 174.53,143.69 174.53,144.64 201.46,171.58 202.33,171.58 202.75,172
M_DATA_B<51>: length 101.5
  TOP w0.088: J1F2.271 170.19,108.77 170.19,108.5 170.36,108.33 170.36,107.42 170.45,107.33 170.59,107.33 170.67,107.24 170.67,107.08 170.59,106.99 170.26,106.99 170.17,106.91 170.17,106.78 170.36,106.58 170.36,105.84 v1(170.46,105.5) 169.91,104.83 169.91,104.3 170.34,103.22 J1F3.271
  TOP w0.165: J3D1.AK7 v3(209.45,172.03)
  LAY9 w0.088: 202.75,172.87 203.6,172.87 203.71,172.98 204.38,172.98 204.7,172.66 205.03,172.66 205.32,172.95 207.05,172.95 207.48,172.52 208.97,172.52 v3(209.45,172.03)
  LAY9 w0.089: 202.75,172.87 202.2,172.33 201.32,172.33 173.86,144.87 173.86,143.92 172.34,142.39 172.34,140.25 171.69,139.61 171.69,133.57 171.21,133.09 171.21,133.09 171.21,131.17 172.06,130.32 172.06,129.78 171.63,128.2 171.63,127.59 172.06,126.46 172.06,125.88 171.59,124.12 171.59,123.73 172.05,122.6 172.05,121.94 171.6,120.39 171.6,119.9 172.05,118.86 172.05,118.21 170.97,117.14 170.97,114.09 171.21,113.85 171.21,113.19 170.36,112.34 170.36,110.78 171.21,109.93 171.21,109.39 170.36,108.55 170.36,108.54 170.36,108.53 170.36,106.03 170.46,105.92 v1(170.46,105.5)
M_DATA_B<52>: length 101.5
  TOP w0.088: J1F2.117 179.07,110.86 178.12,109.92 178.12,109.33 v1(178.52,108.92) 178.95,108.92 179.11,108.77 179.11,108.54 178.99,108.42 178.99,108.25 179.08,108.15 179.08,107.96 178.97,107.86 178.97,107.66 179.05,107.58 J1F3.117
  TOP w0.165: v3(210.37,170.2) J3D1.AM8
  LAY9 w0.088: 202.68,166.11 202.95,166.11 203.79,166.95 205,166.95 205.47,167.41 205.47,167.63 205.7,167.86 206.2,167.86 206.23,167.89 206.85,167.89 207.2,168.24 207.2,168.57 207.41,168.78 208.67,168.78 208.99,169.1 208.99,169.48 209.25,169.74 209.9,169.74 v3(210.37,170.2)
  LAY9 w0.089: 202.68,166.11 183.97,147.39 183.97,147.27 184.29,146.94 184.42,146.94 185.7,148.23 185.92,148.23 186.19,147.96 186.19,147.82 184.72,146.35 182.92,146.35 181.13,144.56 181.13,138.69 181.24,138.58 181.4,138.58 182.57,139.75 182.69,139.75 183.12,139.33 183.12,139.2 181.13,137.22 181.13,134.63 178.43,131.92 178.43,131.39 179.28,130.54 179.28,129.79 180.13,128.94 180.13,127.42 180.12,127.41 180.12,127.36 179.28,126.52 179.28,125.99 180.11,125.16 180.11,123.4 179.26,122.55 179.26,122.02 180.11,121.17 180.11,119.62 180.1,119.61 180.1,119.59 179.26,118.75 179.26,118.22 179.49,117.99 179.49,117.14 178.43,116.08 178.43,112.98 177.58,112.13 177.58,111.59 178.41,110.76 178.41,109.38 v1(178.52,108.92)
M_DATA_B<53>: length 101.3
  TOP w0.088: J1F2.262 178.22,105.78 178.37,105.64 178.37,105.48 178.28,105.39 178.06,105.39 177.97,105.3 177.97,105.17 178.05,105.1 178.33,105.1 178.4,105.02 178.4,104.89 178.31,104.8 178.19,104.8 178.1,104.71 v1(178.1,103.93) 177.55,103.23 177.55,102.76 178,100.97 J1F3.262
  TOP w0.165: v3(209.45,170.2) J3D1.AM7
  LAY9 w0.088: v3(209.45,170.2) 209.12,170.2 208.64,169.72 207.45,169.72 207.12,169.39 207.12,169.08 206.9,168.86 206.62,168.86 206.16,168.41 205.59,168.12 205.17,167.71 205.09,167.71 205.03,167.77 204.7,167.77 204.61,167.68 204.24,167.68 204.11,167.81 203.79,167.81 203.55,167.58 203.55,167.47 203.03,166.95 202.62,166.95
  LAY9 w0.089: 202.62,166.95 180.49,144.81 180.49,134.97 180.37,134.85 179.97,134.85 179.85,134.97 179.85,136.91 179.73,137.03 179.34,137.03 179.22,136.91 179.22,133.61 178.01,132.41 178.01,131.17 178.86,130.32 178.86,129.59 178.87,129.58 179.71,128.09 179.71,127.59 178.86,126.74 178.86,125.88 179.69,124.12 179.69,123.62 178.85,122.77 178.85,121.74 179.69,120.28 179.69,119.82 178.85,118.97 178.85,118.2 178.29,117.65 178.29,117.4 177.38,116.49 177.38,114.37 178.01,113.73 178.01,113.19 177.16,112.34 177.16,110.78 178.01,109.93 178.01,109.39 177.49,108.88 177.49,107.81 178.1,107.2 v1(178.1,103.93)
M_DATA_B<54>: length 101.4
  TOP w0.088: J1F2.124 172.9,109.41 172.48,108.32 172.48,107.8 v1(173.03,107.13) 172.93,106.79 172.93,106.12 173.09,105.96 173.09,105.82 173,105.73 172.7,105.73 172.61,105.64 172.61,105.47 172.7,105.38 172.86,105.38 172.95,105.29 172.95,105.16 172.89,105.1 172.89,104.27 172.73,104.1 172.73,103.92 J1F3.124
  TOP w0.165: J3D1.AK6 v3(208.52,172.03)
  LAY9 w0.088: v3(208.52,172.03) 208.21,172.03 207.75,171.58 206.61,171.58 206.36,171.32 206.13,171.32 205.94,171.51 205.61,171.51 205.38,171.27 205.38,170.95 205.13,170.7 203.92,170.7 203.37,170.16 202.35,170.16
  LAY9 w0.089: 202.35,170.16 201.84,170.16 175.8,144.12 175.8,136.72 175.65,136.57 175.31,136.57 175.16,136.72 175.16,137.93 175.07,138.02 174.62,138.02 174.53,137.93 174.53,136.55 174.91,136.17 174.91,135.82 174.91,133.23 174.03,132.35 173.72,132.35 173.33,131.96 173.33,131.34 174.18,130.49 174.18,129.79 175.03,128.94 175.03,127.37 174.18,126.52 174.18,125.99 175.01,125.16 175.01,123.4 174.16,122.55 174.16,122.02 175.01,121.17 175.01,119.6 174.16,118.75 174.16,118.22 174.34,118.04 174.34,116.98 173.84,116.48 173.84,114.24 173.33,113.73 173.33,112.98 172.48,112.13 172.48,111.59 173.33,110.74 173.33,109.18 173.3,109.15 172.48,108.33 172.48,107.68 v1(173.03,107.13)
M_DATA_B<55>: length 101.3
  TOP w0.088: J1F2.269 171.89,108.77 171.89,108.5 172.06,108.33 172.06,107.42 172.15,107.33 172.29,107.33 172.37,107.24 172.37,107.08 172.29,106.99 171.96,106.99 171.87,106.91 171.87,106.78 172.06,106.58 172.06,105.84 v1(172.16,105.5) 171.61,104.83 171.61,104.3 172.04,103.22 J1F3.269
  TOP w0.165: J3D1.AK5 v3(206.69,172.03)
  LAY9 w0.088: 203.29,171.09 203.77,171.58 205,171.58 205.25,171.82 205.48,171.82 205.61,171.69 205.94,171.69 206.28,172.03 v3(206.69,172.03)
  LAY9 w0.089: v1(172.16,105.5) 172.16,105.92 172.06,106.03 172.06,108.54 172.91,109.39 172.91,109.93 172.06,110.78 172.06,112.34 172.91,113.19 172.91,117.19 173.75,118.02 173.75,118.97 174.59,119.82 174.59,120.28 173.75,121.74 173.75,122.77 174.59,123.62 174.59,124.12 173.76,125.88 173.76,126.74 174.61,127.59 174.61,128.09 173.77,129.58 173.76,129.59 173.76,130.32 172.91,131.17 172.91,132.46 173.6,133.15 173.6,140.89 173.69,140.98 174.44,140.98 174.53,140.89 174.53,139.3 174.62,139.21 175.03,139.21 175.16,139.34 175.16,144.38 201.74,170.96 203.15,170.96 203.29,171.09
M_DATA_B<56>: length 114.9
  TOP w0.088: J1F2.130 167.8,109.41 167.38,108.32 167.38,107.8 v1(167.93,107.13) 167.83,106.79 167.83,106.12 167.99,105.96 167.99,105.82 167.9,105.73 167.6,105.73 167.51,105.64 167.51,105.47 167.6,105.38 167.76,105.38 167.85,105.29 167.85,105.16 167.79,105.1 167.79,104.27 167.63,104.1 167.63,103.92 J1F3.130
  TOP w0.165: v3(208.52,173.86) J3D1.AH7
  LAY9 w0.088: v3(208.52,173.86) 208.11,174.27 207.3,174.27 206.95,174.63 206.19,174.63 205.94,174.38 205.61,174.38 205.38,174.61 205.38,174.82 205.03,175.17 203.32,175.17 203.06,174.91 202.73,174.91 202.56,175.07 202.35,175.07
  LAY9 w0.089: 202.35,175.07 201.7,174.42 200.43,174.42 169.73,143.72 169.73,143.12 169.57,142.95 168.96,142.95 168.47,142.45 168.47,141.36 168.47,136.89 168.38,136.8 167.92,136.8 167.83,136.89 167.83,140.45 167.74,140.54 167.29,140.54 167.2,140.45 167.2,137.87 167.2,134.04 167.11,133.95 166.67,133.95 166.59,133.86 166.59,133.41 166.68,133.31 167.11,133.31 167.2,133.22 167.2,133.03 167.09,132.92 167.09,132.52 166.53,131.96 166.53,131.39 167.38,130.54 167.38,129.79 168.23,128.94 168.23,127.37 167.38,126.52 167.38,125.99 168.21,125.16 168.21,123.4 167.36,122.55 167.36,122.02 168.18,121.2 168.18,121.18 168.21,121.15 168.21,119.62 167.36,118.77 167.36,118.22 167.67,117.91 167.67,114.8 168.23,114.23 168.23,112.98 167.38,112.13 167.38,111.59 168.23,110.74 168.23,109.18 167.38,108.33 167.38,107.68 v1(167.93,107.13)
M_DATA_B<57>: length 114.9
  TOP w0.088: J1F2.275 166.79,108.77 166.79,108.5 166.96,108.33 166.96,107.42 167.05,107.33 167.19,107.33 167.27,107.24 167.27,107.08 167.19,106.99 166.86,106.99 166.77,106.91 166.77,106.78 166.96,106.58 166.96,105.84 v1(167.06,105.5) 166.51,104.83 166.51,104.3 166.94,103.22 J1F3.275
  TOP w0.165: v3(207.61,174.72) J3D1.AH6
  LAY9 w0.088: v3(207.61,174.72) 207.6,174.73 207.32,174.73 206.99,175.06 206.06,175.06 205.94,175.17 205.7,175.17 205.26,175.62 203.14,175.62 203.06,175.7 202.73,175.7 202.68,175.65 202.3,175.65
  LAY9 w0.089: v1(167.06,105.5) 167.06,105.92 166.96,106.03 166.96,108.54 167.81,109.39 167.81,109.93 166.96,110.78 166.96,112.35 167.81,113.19 167.81,113.74 166.83,114.73 166.83,118.05 166.95,118.17 166.95,118.97 167.79,119.82 167.79,120.28 166.95,121.74 166.95,122.77 167.79,123.62 167.79,124.12 166.96,125.88 166.96,126.74 167.81,127.59 167.81,128.09 166.97,129.58 166.96,129.59 166.96,130.32 166.11,131.17 166.11,131.95 165.92,132.14 165.92,132.97 165.16,133.73 165.16,138.16 165.26,138.26 165.69,138.26 165.79,138.16 165.79,134.58 165.91,134.46 166.29,134.46 166.41,134.58 166.43,134.58 166.43,141.31 200.16,175.05 201.63,175.05 202.23,175.65 202.3,175.65
M_DATA_B<58>: length 114.8
  TOP w0.088: J1F2.137 162.07,110.86 161.12,109.92 161.12,109.33 v1(161.52,108.92) 161.95,108.92 162.11,108.77 162.11,108.54 161.99,108.42 161.99,108.25 162.08,108.15 162.08,107.96 161.97,107.86 161.97,107.66 162.05,107.58 J1F3.137
  TOP w0.165: v3(209.44,176.6) J3D1.AF7
  LAY9 w0.088: 202.57,177.89 203.55,177.89 203.88,177.56 206.32,177.56 206.39,177.49 207.16,177.49 207.63,177.02 207.78,177.02 208.07,176.73 208.07,176.44 208.36,176.15 208.98,176.15 v3(209.44,176.6)
  LAY9 w0.089: v1(161.52,108.92) 161.43,109.39 161.43,109.93 162.28,110.78 162.28,112.34 161.43,113.19 161.43,113.79 161.68,114.05 161.68,117.32 162.26,117.9 162.26,118.75 162.64,119.13 162.64,119.13 163.11,119.6 163.11,121.17 162.26,122.02 162.26,122.55 163.11,123.4 163.11,124.36 163.11,124.36 163.11,125.16 162.28,125.99 162.28,126.52 163.13,127.37 163.13,128.91 162.28,129.75 162.28,129.79 162.28,129.79 162.28,130.54 161.43,131.39 161.43,131.97 162.24,132.78 162.24,133.25 162.24,133.25 162.24,134.06 162.24,134.06 162.24,134.52 162.15,134.61 161.84,134.61 161.75,134.7 161.75,135.15 161.84,135.24 162.15,135.24 162.24,135.33 162.24,135.79 162.15,135.88 161.7,135.88 161.62,135.96 161.62,136.42 161.7,136.51 162.15,136.51 162.24,136.6 162.24,137.05 162.15,137.14 161.7,137.14 161.62,137.23 161.62,137.69 161.7,137.78 162.15,137.78 162.24,137.87 162.24,138.32 162.15,138.41 161.7,138.41 161.62,138.5 161.62,138.96 161.7,139.04 162.15,139.04 162.24,139.13 162.24,139.54 163.61,140.91 163.61,143.43 175.59,155.41 176.54,155.41 199,177.86 202.54,177.86 202.57,177.89
M_DATA_B<59>: length 114.7
  TOP w0.088: J1F3.282 161,100.97 160.55,102.76 160.55,103.23 v1(161.1,103.93) 161.1,104.71 161.19,104.8 161.31,104.8 161.4,104.89 161.4,105.02 161.33,105.1 161.05,105.1 160.97,105.17 160.97,105.3 161.06,105.39 161.28,105.39 161.37,105.48 161.37,105.64 161.22,105.78 J1F2.282
  TOP w0.165: v3(208.52,176.6) J3D1.AF6
  LAY9 w0.088: v3(208.52,176.6) 208.52,177.01 207.62,177.91 206.54,177.91 206.45,178 204.14,178 203.73,178.41 202.62,178.41
  LAY9 w0.089: 202.62,178.41 202.52,178.5 198.73,178.5 176.28,156.04 175.33,156.04 174.79,155.5 162.98,143.69 162.98,141.42 160.93,139.37 160.93,131.97 161.01,131.89 161.01,131.17 160.58,130.74 160.58,129.79 161.06,129.31 161.06,127.01 160.58,126.52 160.58,125.96 161.23,125.31 161.23,124.66 161.08,124.51 161.08,123.07 160.56,122.55 160.56,122.02 161.01,121.57 161.01,119.2 160.56,118.75 160.56,118.22 160.8,117.98 160.8,113.94 161.01,113.73 161.01,112.56 160.58,112.13 160.58,111.59 161.01,111.16 161.01,108.76 160.58,108.33 160.58,107.72 161.1,107.2 v1(161.1,103.93)
M_DATA_B<60>: length 114.9
  TOP w0.088: J1F3.128 169.33,103.92 169.33,104.1 169.49,104.27 169.49,105.1 169.55,105.16 169.55,105.29 169.46,105.38 169.3,105.38 169.21,105.47 169.21,105.64 169.3,105.73 169.6,105.73 169.69,105.82 169.69,105.96 169.53,106.12 169.53,106.79 v1(169.63,107.13) 169.08,107.8 169.08,108.32 169.5,109.41 J1F2.128
  TOP w0.165: v3(209.44,173.86) J3D1.AH8
  LAY9 w0.088: 202.59,173.71 202.73,173.84 203.28,173.84 203.72,173.4 204.16,173.4 204.24,173.49 205.46,173.49 205.52,173.43 207.33,173.43 207.39,173.37 208.35,173.37 208.95,173.37 v3(209.44,173.86)
  LAY9 w0.089: 202.59,173.71 202.02,173.14 200.94,173.14 171,143.2 171,133.78 170.85,133.62 170.48,133.62 170.37,133.74 170.37,138.63 170.28,138.72 169.82,138.72 169.73,138.63 169.73,132.57 169.64,132.48 168.63,132.48 168.23,132.08 168.23,131.39 169.08,130.54 169.08,129.79 169.93,128.94 169.93,127.42 169.92,127.41 169.92,127.36 169.08,126.52 169.08,125.99 169.91,125.16 169.91,123.42 169.06,122.57 169.06,122.02 169.91,121.17 169.91,119.62 169.9,119.61 169.9,119.59 169.06,118.75 169.06,118.22 169.33,117.95 169.33,115.03 169.93,114.43 169.93,112.98 169.08,112.13 169.08,111.59 169.93,110.74 169.93,109.18 169.08,108.33 169.08,107.68 v1(169.63,107.13)
M_DATA_B<61>: length 114.8
  TOP w0.088: J1F2.273 168.49,108.77 168.49,108.5 168.66,108.33 168.66,107.42 168.75,107.33 168.89,107.33 168.97,107.24 168.97,107.08 168.89,106.99 168.56,106.99 168.47,106.91 168.47,106.78 168.66,106.58 168.66,105.84 v1(168.76,105.5) 168.21,104.83 168.21,104.3 168.64,103.22 J1F3.273
  TOP w0.165: v3(207.61,173.86) J3D1.AH5
  LAY9 w0.088: 202.46,174.31 202.46,174.45 202.73,174.72 203.06,174.72 203.46,174.32 205.03,174.32 205.38,173.97 206.21,173.97 206.5,174.26 206.83,174.26 207.23,173.86 v3(207.61,173.86)
  LAY9 w0.089: 202.46,174.31 201.93,173.78 200.69,173.78 170.37,143.46 170.37,140.35 170.29,140.27 169.81,140.27 169.73,140.34 169.73,142.2 169.62,142.31 169.22,142.31 169.1,142.19 169.1,139.8 169.1,139.8 169.1,139.28 169.1,133.14 168.97,133.01 168.55,133.01 168.47,133.1 168.47,135.64 168.38,135.73 167.92,135.73 167.83,135.64 167.83,132.77 167.7,132.63 167.7,132.04 167.81,131.92 167.81,131.92 167.81,131.17 168.66,130.32 168.66,129.59 168.67,129.58 169.51,128.09 169.51,127.59 168.66,126.74 168.66,125.88 169.49,124.12 169.49,123.62 168.65,122.77 168.65,121.74 169.49,120.28 169.49,119.82 168.65,118.97 168.65,118.15 168.56,118.06 168.56,114.84 169.51,113.89 169.51,113.19 168.66,112.34 168.66,110.78 169.51,109.93 169.51,109.39 168.66,108.54 168.66,106.03 168.76,105.92 v1(168.76,105.5)
M_DATA_B<62>: length 114.8
  TOP w0.088: J1F2.135 163.77,113.46 163.77,110.87 162.82,109.92 162.82,109.33 v1(163.22,108.92) 163.65,108.92 163.81,108.77 163.81,108.54 163.69,108.42 163.69,108.25 163.78,108.15 163.78,107.96 163.67,107.86 163.67,107.66 163.75,107.58 J1F3.135
  TOP w0.165: v3(207.61,175.74) J3D1.AG5
  LAY9 w0.088: v3(207.61,175.74) 207.14,176.21 206.53,176.21 206.05,176.69 203.09,176.69 203.02,176.62 202.71,176.62 202.63,176.7 201.67,176.7
  LAY9 w0.089: 201.67,176.7 201.57,176.6 199.52,176.6 173.22,150.29 173.09,150.29 172.78,150.61 172.65,150.61 172.33,150.29 172.33,150.16 172.65,149.85 172.65,149.72 172.32,149.4 172.2,149.4 171.85,149.75 171.72,149.75 171.4,149.42 171.4,149.3 171.75,148.95 171.75,148.82 171.43,148.5 171.3,148.5 170.95,148.85 170.83,148.85 170.5,148.53 170.5,148.4 170.85,148.05 170.85,147.93 170.53,147.6 170.4,147.6 170.06,147.95 169.93,147.95 169.61,147.63 169.61,147.5 169.96,147.16 169.96,147.03 169.63,146.71 169.51,146.71 169.16,147.06 169.03,147.06 168.71,146.73 168.71,146.61 169.06,146.26 169.06,146.13 168.74,145.81 168.61,145.81 168.26,146.16 168.14,146.16 167.81,145.84 167.81,145.71 168.16,145.36 168.16,145.24 167.84,144.91 167.71,144.91 167.37,145.26 167.24,145.26 166.92,144.94 166.92,144.81 167.27,144.47 167.27,144.34 166.94,144.02 166.82,144.02 166.47,144.37 166.34,144.37 166.02,144.04 166.02,143.92 166.37,143.57 166.37,143.44 164.88,141.95 164.88,140.38 163.51,139.01 163.51,132.33 163.13,131.95 163.13,131.39 163.98,130.54 163.98,129.79 164.83,128.94 164.83,127.38 163.99,126.55 163.99,126.54 163.98,126.52 163.98,125.99 164.81,125.16 164.81,123.4 163.96,122.55 163.96,122.02 164.81,121.17 164.81,119.6 163.96,118.75 163.96,118.21 164.19,117.98 164.19,117.36 163.34,116.51 163.34,114.07 163.13,113.85 163.13,113.19 163.98,112.35 163.98,110.78 163.13,109.93 163.13,109.39 v1(163.22,108.92)
M_DATA_B<63>: length 114.5
  TOP w0.088: J1F2.280 162.92,105.78 163.07,105.64 163.07,105.48 162.98,105.39 162.76,105.39 162.67,105.3 162.67,105.17 162.75,105.1 163.03,105.1 163.1,105.02 163.1,104.89 163.01,104.8 162.89,104.8 162.8,104.71 v1(162.8,103.93) 162.25,103.23 162.25,102.76 162.7,100.97 J1F3.280
  TOP w0.165: v3(207.61,176.6) J3D1.AF5
  LAY9 w0.088: 201.56,177.23 201.6,177.27 202.48,177.27 202.67,177.46 203,177.46 203.12,177.34 203.39,177.34 203.61,177.12 206.22,177.12 206.3,177.05 206.81,177.05 207.26,176.6 v3(207.61,176.6)
  LAY9 w0.089: v1(162.8,103.93) 162.8,107.16 162.08,107.88 162.08,108.76 162.71,109.39 162.71,110.74 163.56,111.59 163.56,112.13 162.71,112.98 162.71,117.08 163.55,117.92 163.55,118.97 164.39,119.82 164.39,120.28 163.55,121.74 163.55,122.77 164.39,123.62 164.39,124.12 163.56,125.88 163.56,126.7 164.41,127.55 164.41,128.09 163.57,129.58 163.56,129.59 163.56,130.32 162.71,131.17 162.71,132.23 162.88,132.39 162.88,139.28 164.25,140.65 164.25,143.17 172.48,151.4 173.43,151.4 173.98,151.95 173.98,152.08 173.84,152.22 173.84,152.34 174.16,152.67 174.29,152.67 174.43,152.52 174.55,152.52 174.88,152.85 174.88,152.97 174.6,153.25 174.6,153.38 174.92,153.7 175.05,153.7 175.33,153.42 175.45,153.42 175.77,153.74 175.77,153.87 175.5,154.15 175.5,154.27 175.82,154.59 175.94,154.59 176.22,154.32 176.35,154.32 199.26,177.23 201.56,177.23
M_DATA_B_CB<0>: length 92.8
  TOP w0.088: J1F3.49 241.95,107.58 241.87,107.66 241.87,107.86 241.98,107.96 241.98,108.15 241.89,108.25 241.89,108.42 242.01,108.54 242.01,108.77 241.85,108.92 v1(241.42,108.92) 241.14,109.21 241.14,110.03 241.97,110.86 J1F2.49
  TOP w0.165: v3(229.92,172.07) J3D1.AK28
  BOTTOM w0.088: 237.73,132.35 236.65,133.43 235.54,133.43 235.17,133.8 234.12,133.8 229.71,138.22 229.71,153.41 228.34,154.78 228.34,162.95 228.34,163.19 228.09,163.43 228.09,165.94 227.66,166.37 227.66,166.73 228,167.06 228.26,167.06 228.54,167.33 228.54,167.56 228.91,167.93 229.14,167.93 229.48,168.27 229.48,171.63 v3(229.92,172.07)
  BOTTOM w0.165: v1(241.42,108.92) 241.18,109.16 241.18,110.15 240.37,110.97 240.37,112.37 239.55,113.18 239.55,113.76 240.69,114.89 240.69,115.13 240.46,115.35 239.69,115.35 239.52,115.52 239.52,116.11 239.69,116.28 240.67,116.28 240.84,116.44 240.84,116.68 240.47,117.04 240.47,117.77 240.24,118 240.24,118.75 241.05,119.57 241.05,120.46 240.2,121.31 240.2,122.93 240,123.13 238.82,123.13 238.54,122.85 238.54,121.42 238.37,121.26 237,121.26 236.84,121.42 236.84,122.73 237.74,123.64 237.74,124.97 237,125.71 237,126.54 237.55,127.09 237.55,129.22 236.97,129.8 236.97,130.39 237.73,131.16 237.73,132.35
M_DATA_B_CB<1>: length 91.8
  TOP w0.088: J1F3.194 240.9,100.97 240.45,102.76 240.45,103.23 v1(241,103.93) 241,104.71 241.09,104.8 241.21,104.8 241.3,104.89 241.3,105.02 241.23,105.1 240.95,105.1 240.87,105.17 240.87,105.3 240.96,105.39 241.18,105.39 241.27,105.48 241.27,105.64 241.12,105.78 J1F2.194
  TOP w0.165: J3D1.AM27 v3(229.05,170.2)
  BOTTOM w0.088: v3(229.05,170.2) 229.05,169.03 228.57,168.56 228.57,168.27 228.18,167.88 227.94,167.88 227.69,167.63 227.69,167.42 227.37,167.09 227.37,165.47 227.62,165.21 227.62,163.27 227.9,162.98 227.9,154.6 229.27,153.23 229.27,138.04 233.94,133.37 234.99,133.37 235.36,133 236.23,133 236.53,132.69 236.53,132.44 236.44,132.34
  BOTTOM w0.165: 236.44,132.34 236.05,131.95 236.05,131.2 235.18,130.33 235.18,129.92 235.97,129.13 235.97,127.29 235.34,126.66 235.34,125.6 236,124.94 236,123.63 235.25,122.87 235.25,121.35 236.07,120.53 236.07,119.72 236.47,119.32 237.27,119.32 237.53,119.59 237.96,119.59 238.23,119.32 238.37,119.32 238.54,119.16 238.54,118.2 238.26,117.92 238.26,115.29 237.85,114.89 237.85,114.69 238.19,114.35 238.19,114.12 237.85,113.79 237.85,113.21 238.7,112.35 238.7,111.25 239.44,110.51 239.44,109.36 240.16,108.64 240.16,107.56 240.32,107.4 240.51,107.4 240.68,107.23 240.68,106.83 240.51,106.66 240.22,106.66 240.05,106.5 240.05,106.15 240.33,105.87 240.33,105.63 239.36,104.66 239.36,104.25 240.22,103.39 240.46,103.39 v1(241,103.93)
M_DATA_B_CB<2>: length 93.3
  TOP w0.088: J1F2.56 235.8,109.41 235.38,108.32 235.38,107.8 v1(235.93,107.13) 235.83,106.79 235.83,106.12 235.99,105.96 235.99,105.82 235.9,105.73 235.6,105.73 235.51,105.64 235.51,105.47 235.6,105.38 235.76,105.38 235.85,105.29 235.85,105.16 235.79,105.1 235.79,104.27 235.63,104.1 235.63,103.92 J1F3.56
  TOP w0.165: v3(228.06,171.12) J3D1.AL26
  BOTTOM w0.088: v3(228.06,171.12) 227.54,170.6 227.02,170.6 226.64,170.23 226.64,170.04 226.29,169.69 226.1,169.69 225.87,169.45 225.87,169.16 225.48,168.77 225.19,168.77 224.95,168.54 224.95,168.21 225.18,167.99 225.18,164.99 225.43,164.74 225.43,162.94 226.17,162.2 226.17,153.88 227.54,152.51 227.54,137.32 230.94,133.92 230.94,133.49
  BOTTOM w0.165: 230.94,133.49 230.94,131.94 230.93,131.94 230.93,131.2 230.05,130.32 230.05,129.52 230.22,129.35 231.15,129.35 231.44,129.06 231.44,128.66 231.24,128.47 230.6,128.47 230.46,128.6 229.86,128.6 229.41,129.06 229.18,129.06 228.81,128.7 228.81,128.46 229.14,128.14 229.14,127.26 229.36,127.04 230.07,127.04 230.18,126.93 230.18,125.9 230.56,125.52 230.85,125.52 231.02,125.36 231.02,124.75 230.85,124.59 230.39,124.59 229.58,125.4 229.35,125.4 228.83,124.88 228.83,124.65 229.1,124.38 229.1,123.71 229.99,122.81 229.99,122.01 230.47,121.53 230.47,121.04 230.3,120.88 229.42,120.88 229.14,120.6 229.14,119.86 229.91,119.08 229.91,118.21 229.32,117.61 229.32,116.97 232.64,113.65 232.64,113.21 233.49,112.36 233.49,111.32 234.38,110.43 234.38,109.25 235.26,108.36 235.26,107.68 235.81,107.13 v1(235.93,107.13)
M_DATA_B_CB<3>: length 93.2
  TOP w0.088: J1F3.201 234.94,103.22 234.51,104.3 234.51,104.83 v1(235.06,105.5) 234.96,105.84 234.96,106.58 234.77,106.78 234.77,106.91 234.86,106.99 235.19,106.99 235.27,107.08 235.27,107.24 235.19,107.33 235.05,107.33 234.96,107.42 234.96,108.33 234.79,108.5 234.79,108.77 J1F2.201
  TOP w0.165: J3D1.AJ28 v3(229.92,172.95)
  BOTTOM w0.088: v3(229.92,172.95) 229.44,173.43 227.89,173.43 227.65,173.19 227.65,173.08 227.65,173.08 227.65,171.99 227.35,171.68 227.02,171.68 226.93,171.77 226.47,171.77 226.23,171.52 225.99,171.52 225.78,171.31 225.78,170.94 225.49,170.66 224.18,170.66 223.93,170.4 223.93,170.04 223.69,169.8 223.32,169.8 223.05,169.52 223.05,165.63 224.52,164.16 224.52,162.63 225.3,161.84 225.3,153.52 226.68,152.15 226.68,136.96 229.27,134.37 229.27,133.98
  BOTTOM w0.165: 229.27,133.98 229.27,133.64 227.57,131.94 227.57,131.41 226.74,130.59 226.74,129.73 225.99,128.14 225.99,127.58 226.5,126.46 226.5,125.98 225.97,124.25 225.97,123.7 226.49,122.46 226.49,122.07 225.95,120.25 225.95,119.69 226.61,118.71 226.61,118.27 227.14,117.42 227.14,115.75 229.31,113.58 229.31,113.21 230.12,112.39 230.12,111.17 231.03,110.27 231.03,108.95 231.82,108.16 231.82,107.44 233.76,105.5 v1(235.06,105.5)
M_DATA_B_CB<4>: length 92.9
  TOP w0.088: J1F3.47 243.65,107.58 243.57,107.66 243.57,107.86 243.68,107.96 243.68,108.15 243.59,108.25 243.59,108.42 243.71,108.54 243.71,108.77 243.55,108.92 v1(243.12,108.92) 242.72,109.33 242.72,109.92 243.67,110.86 J1F2.47
  TOP w0.165: v3(229.99,171.08) J3D1.AL28
  BOTTOM w0.088: v3(229.99,171.08) 230.39,170.68 231.02,170.68 231.25,170.44 231.25,168.22 230.94,167.91 230.71,167.91 230.33,167.52 230.33,167.29 230.09,167.06 229.86,167.06 229.42,166.62 229.42,163.62 229.2,163.41 229.2,155.13 230.57,153.76 230.57,138.57 234.48,134.67 235.53,134.67 235.9,134.3 237.01,134.3 238.01,133.3 239.47,133.3
  BOTTOM w0.165: v1(243.12,108.92) 243.12,109.25 242.99,109.38 242.99,109.94 243.35,110.3 243.35,111.1 243.63,111.38 243.63,112.47 242.94,113.16 242.94,113.79 243.79,114.64 243.79,115.85 243.69,115.96 243.69,116.25 243.79,116.36 243.79,118.78 244.33,119.31 244.33,120.95 243.68,121.61 243.68,122.69 244.54,123.55 244.54,125.07 244.39,125.22 244.03,125.22 243.94,125.13 243.7,125.13 243.4,125.43 243.4,125.67 243.84,126.11 243.84,126.67 244.35,127.18 244.35,128.96 244.03,129.28 242.97,129.28 242.65,128.96 242.65,127.54 242.28,127.18 241.58,127.18 241.01,127.75 241.01,129.18 240.23,129.96 240.23,130.2 241.1,131.07 241.1,132.3 240.1,133.3 239.47,133.3
M_DATA_B_CB<5>: length 91.8
  TOP w0.088: J1F2.192 242.82,105.78 242.97,105.64 242.97,105.48 242.88,105.39 242.66,105.39 242.57,105.3 242.57,105.17 242.65,105.1 242.93,105.1 243,105.02 243,104.89 242.91,104.8 242.79,104.8 242.7,104.71 v1(242.7,103.93) 242.15,103.23 242.15,102.76 242.6,100.97 J1F3.192
  TOP w0.165: J3D1.AM28 v3(229.92,170.2)
  BOTTOM w0.088: v3(229.92,170.2) 230.38,169.75 230.38,168.25 229.99,167.87 229.76,167.87 229.47,167.57 229.47,167.34 229.13,167.01 228.9,167.01 228.61,166.71 228.61,163.53 228.77,163.36 228.77,163.13 228.77,154.96 230.14,153.58 230.14,138.39 234.3,134.23 235.35,134.23 235.72,133.87 236.83,133.87 237.86,132.83 238.81,132.83 239.1,132.54
  BOTTOM w0.165: 239.1,132.54 239.39,132.25 239.39,131.05 238.57,130.23 238.57,129.87 239.39,129.05 239.39,127.34 240.44,126.29 240.44,125.98 240.94,125.48 240.94,124.44 241.25,124.13 241.25,123.55 242.05,122.75 242.05,121.45 242.71,120.79 242.71,119.43 242.02,118.74 242.02,117.96 242.42,117.56 242.42,117.03 242.02,116.64 242.02,114.55 241.09,113.62 241.09,113.34 242.01,112.42 242.01,110.58 242.65,109.94 242.65,109.38 242.06,108.79 242.06,107.62 242.32,107.36 242.95,107.36 243.11,107.19 243.11,106.82 242.93,106.63 242,106.63 241.81,106.44 241.81,106.14 241.99,105.96 242.9,105.96 243.11,105.75 243.11,105.45 242.94,105.28 242.7,105.28 242.56,105.14 242.56,104.91 242.76,104.71 242.76,104.45 242.7,104.39 v1(242.7,103.93)
M_DATA_B_CB<6>: length 93.2
  TOP w0.088: J1F3.54 237.33,103.92 237.33,104.1 237.49,104.27 237.49,105.1 237.55,105.16 237.55,105.29 237.46,105.38 237.3,105.38 237.21,105.47 237.21,105.64 237.3,105.73 237.6,105.73 237.69,105.82 237.69,105.96 237.53,106.12 237.53,106.79 v1(237.63,107.13) 237.08,107.8 237.08,108.32 237.5,109.41 J1F2.54
  TOP w0.165: v3(228.06,170.2) J3D1.AM26
  BOTTOM w0.088: v3(228.06,170.2) 227.66,169.81 227.1,169.81 226.72,169.43 226.72,169.09 226.23,168.6 226.23,167.99 225.86,167.62 225.86,163.12 226.6,162.38 226.6,154.06 227.97,152.69 227.97,137.5 232.65,132.82 232.65,132.34
  BOTTOM w0.165: v1(237.63,107.13) 237.63,106.49 237.47,106.33 236.62,106.33 236.45,106.49 236.45,107.15 237.03,107.72 237.03,108.24 236.08,109.19 236.08,110.23 235.15,111.15 235.15,112.3 234.45,113 234.45,116.28 234.29,116.44 233.84,116.44 233.68,116.28 233.68,115.28 233.51,115.12 233.07,115.12 232.9,115.28 232.9,116.61 233.91,117.62 233.91,117.85 233.56,118.2 233.32,118.2 232.78,117.65 232.23,117.65 231.33,116.75 230.96,116.75 230.65,117.06 230.65,117.5 230.93,117.77 231.16,117.77 231.75,118.36 231.75,118.73 232.48,119.46 232.48,120.35 231.89,120.94 231.89,123.07 232.43,123.6 232.43,124.17 232.14,124.45 232.14,125.58 231.94,125.78 231.94,126.98 232.47,127.51 232.47,129.2 231.92,129.74 231.92,130.37 232.65,131.09 232.65,132.34
M_DATA_B_CB<7>: length 93.3
  TOP w0.088: J1F3.199 236.64,103.22 236.21,104.3 236.21,104.83 v1(236.76,105.5) 236.66,105.84 236.66,106.58 236.47,106.78 236.47,106.91 236.56,106.99 236.89,106.99 236.97,107.08 236.97,107.24 236.89,107.33 236.75,107.33 236.66,107.42 236.66,108.33 236.49,108.5 236.49,108.77 J1F2.199
  TOP w0.165: J3D1.AK26 v3(228.06,172.03)
  BOTTOM w0.088: v3(228.06,172.03) 228.06,171.71 227.72,171.38 227.44,171.38 227.35,171.47 227.02,171.47 226.71,171.17 226.71,170.86 226.53,170.68 226.14,170.68 225.79,170.34 225.79,170.07 225.52,169.8 225.2,169.8 224.84,169.44 224.84,169.12 224.61,168.89 224.28,168.89 223.95,168.55 223.95,165.53 225,164.48 225,162.76 225.74,162.02 225.74,153.7 227.11,152.33 227.11,137.14 230.1,134.15 230.1,133.64
  BOTTOM w0.165: v1(236.76,105.5) 237.23,105.5 237.61,105.12 237.61,104.34 237.15,103.88 236.55,103.88 236.04,104.39 236.04,105.35 233.53,107.87 233.53,108.45 232.62,109.36 232.62,110.41 231.82,111.21 231.82,112.24 230.92,113.15 230.92,113.82 227.88,116.86 227.88,117.3 228.2,117.63 228.2,119.1 227.45,119.85 227.45,121.11 228.22,121.87 228.22,122.79 227.55,123.46 227.55,125.24 228.28,125.97 228.28,126.5 227.69,127.09 227.69,129.02 229.27,131.46 229.27,131.81 229.27,131.81 229.27,132.47 230.1,133.3 230.1,133.64
M_DQS_A_DN<0>: length 86.2
  TOP w0.165: J3D1.AF38 v3(239.98,175.63)
  LAY2 w0.089: v3(239.98,175.63) 240.29,175.33 240.51,175.33 240.96,174.87 241.67,174.87 241.71,174.84 242.14,174.84 242.28,174.98 252.09,174.98 259.97,167.1 259.97,159.35 272.73,146.59 272.73,140.69 276.89,136.52 276.89,136.2 276.7,136.01 276.7,135.66 276.79,135.58 277.86,135.58 278.06,135.38 278.06,134.76 277.86,134.56 276.79,134.56 276.7,134.47 276.7,133.94 276.79,133.85 277.86,133.85 278.06,133.65 278.06,133.03 277.86,132.83 276.79,132.83 276.7,132.74 276.7,132.55 276.96,132.29 276.96,131.28 276.09,130.41 276.09,129.69 276.76,129.02 276.76,127.67 276.6,127.51 276.6,126.91 276.82,126.26 J1E5.152 276.73,126.17 276.73,124.37 276.91,123.8 276.91,123.5 276.11,122.7 276.11,122.09 276.11,121.04 276.65,120.5 276.65,119.29 J1F1.152
M_DQS_A_DN<1>: length 72.1
  TOP w0.165: J3D1.AL38 v3(239.98,170.28)
  LAY2 w0.088: 266.82,128.01 266.97,127.86 J1E5.163 267.51,127.82 267.51,126.93
  LAY2 w0.089: 267.51,126.93 267.28,126.7 267.28,125.98 266.81,125.5 266.81,123.47 267.58,122.7 267.61,122.68 267.61,121.99 267.37,121.75 267.37,120.16 J1F1.163 ; v3(239.98,170.28) 240.39,169.87 240.64,169.87 241.07,170.3 241.59,170.3 241.63,170.33 242.23,170.33 242.42,170.14 243.1,170.14 244.85,168.4 250.19,168.4 253.98,164.62 253.98,156.86 259.61,151.23 259.61,150.5 259.7,150.41 260.43,150.41 260.88,149.96 260.88,149.29 261,149.17 261.67,149.17 262.15,148.69 262.15,147.98 262.24,147.89 262.95,147.89 264.03,146.81 264.03,146.45 263.46,145.88 263.46,145.72 264.03,145.14 264.03,137.01 266.74,134.31 266.74,133.27 266.92,133.08 266.92,132.6 266.74,132.42 266.74,131.27 267.04,130.96 267.58,130.96 267.73,130.81 267.73,130.52 267.49,130.27 267.49,128.79 267.38,128.68 267.16,128.68 266.95,128.89 266.82,128.89 266.72,128.79 266.72,128.11 266.82,128.01
M_DQS_A_DN<2>: length 59.6
  TOP w0.165: v3(239.98,165.65) J3D1.AT38
  LAY2 w0.089: v3(239.98,165.65) 240.02,165.65 240.35,165.31 240.54,165.31 240.64,165.22 240.64,165.2 242.54,163.3 242.54,163.3 242.9,162.94 242.9,161.97 242.97,161.77 242.97,161.73 243.25,160.99 244.22,158.31 244.38,157.89 247.62,154.65 250.95,151.31 250.95,149.79 251.05,149.69 251.19,149.69 251.63,150.13 251.92,150.13 252.22,149.83 252.22,138.16 256.45,133.93 257.96,133.93 258.21,133.68 258.21,133.24 257.96,132.99 257.62,132.99 257.54,132.9 257.54,132.56 257.63,132.48 258.05,132.48 258.25,132.28 258.25,131.28 257.39,130.41 257.39,129.69 258.06,129.02 258.06,127.67 257.9,127.51 257.9,126.91 258.12,126.26 J1E5.174 258.03,126.17 258.03,124.37 258.21,123.8 258.21,123.5 257.41,122.7 257.41,122.09 257.41,121.04 257.95,120.5 257.95,119.29 J1F1.174
M_DQS_A_DN<3>: length 52
  TOP w0.165: v3(237.29,163.8) J3D1.AV35
  LAY2 w0.088: 248.81,126.93 248.81,127.82 J1E5.185 248.61,128.01 248.12,128.01
  LAY2 w0.089: v3(237.29,163.8) 236.89,163.4 236.89,163.14 236.42,162.67 236.42,162.24 236.46,162.21 236.46,161.38 236.84,160.99 236.84,160.24 239.17,154.08 243.48,149.77 243.48,137.52 248.03,132.98 248.03,131.27 248.34,130.96 248.8,130.96 248.98,130.78 248.98,130.47 248.79,130.27 248.79,128.86 248.68,128.75 248.38,128.75 248.25,128.89 248.12,128.89 248.02,128.79 248.02,128.11 248.12,128.01 ; 248.81,126.93 248.58,126.7 248.58,125.98 248.11,125.5 248.11,123.47 248.88,122.7 248.91,122.68 248.91,121.99 248.67,121.75 248.67,120.16 J1F1.185
M_DQS_A_DN<4>: length 56.1
  TOP w0.165: v3(210.28,164.72) J3D1.AV9
  LAY2 w0.088: v3(210.28,164.72) 210.03,164.34 210.03,164.16 210.57,163.61 210.57,162.83 210.72,162.69 210.72,160.98 210.72,160.98 210.72,160.9
  LAY2 w0.089: 210.72,160.9 210.72,160.28 209.02,158.58 209.02,157.94 196.91,145.84 196.91,135.18 196.29,134.56 195.85,134.56 195.76,134.47 195.76,134.02 193.68,131.94 193.68,131.07 193.48,130.87 193.24,130.87 193.03,130.66 193.03,130.66 192.79,130.42 192.79,129.69 193.46,129.02 193.46,127.67 193.3,127.51 193.3,126.91 193.52,126.26 J1E5.244 193.43,126.17 193.43,124.37 193.61,123.8 193.61,123.5 192.81,122.7 192.81,122.09 192.81,121.04 193.35,120.5 193.35,119.29 J1F1.244
M_DQS_A_DN<5>: length 58.3
  TOP w0.15: v3(206.67,164.72) J3D1.AV4
  LAY2 w0.088: 183.52,128.01 183.67,127.86 J1E5.255 184.21,127.82 184.21,127.27 ; 204.91,162.26 204.99,162.26 205.39,162.66 205.39,163.24 206.28,164.13 206.28,164.3 v3(206.67,164.72)
  LAY2 w0.089: 183.52,128.01 183.42,128.11 183.42,128.79 183.52,128.89 183.65,128.89 183.86,128.68 184.08,128.68 184.19,128.79 184.19,130.27 184.38,130.47 184.38,130.86 184.28,130.96 183.74,130.96 183.42,131.29 183.42,131.88 190.18,138.64 190.18,148.21 204.23,162.26 204.91,162.26 ; J1F1.255 184.07,120.77 184.07,121.75 184.31,121.99 184.31,122.68 184.29,122.7 183.51,123.47 183.51,125.5 183.98,125.98 183.98,126.65 184.21,127.27
M_DQS_A_DN<6>: length 69.7
  TOP w0.15: v3(204.86,167.38) J3D1.AR3
  LAY2 w0.089: J1F1.266 174.65,119.29 174.65,120.5 174.11,121.04 174.11,122.09 174.11,122.7 174.91,123.5 174.91,123.8 174.73,124.37 174.73,126.17 J1E5.266 174.82,126.26 174.6,126.91 174.6,127.51 174.76,127.67 174.76,129.02 174.09,129.69 174.09,130.41 174.95,131.28 174.95,132.32 174.84,132.43 174.84,134.65 175,134.81 175.34,134.81 175.49,134.67 175.49,133.92 175.69,133.72 176.17,133.72 176.68,134.24 176.68,134.9 176.55,135.04 176.55,135.88 178.63,137.96 178.63,145.71 199.47,166.54 200.88,166.54 202.31,167.97 202.99,167.97 203.3,168.29 203.8,168.29 204.28,167.8 204.44,167.8 v3(204.86,167.38)
M_DQS_A_DN<7>: length 80.6
  TOP w0.165: v3(204.86,172.07) J3D1.AK3
  LAY2 w0.088: 165.51,126.93 165.51,127.82 J1E5.277
  LAY2 w0.089: 165.51,126.93 165.28,126.7 165.28,125.98 164.81,125.5 164.81,123.47 165.59,122.7 165.61,122.68 165.61,121.99 165.37,121.75 165.37,120.16 J1F1.277 ; v3(204.86,172.07) 204.86,172.08 204.45,172.49 203.92,172.49 203.57,172.85 200.86,172.85 200.76,172.95 196.98,172.95 171.71,147.69 167.42,140.08 167.42,137.04 167.22,136.84 166.71,136.84 166.62,136.75 166.62,136.07 166.71,135.98 167.22,135.98 167.42,135.78 167.42,135.08 167.22,134.88 166.75,134.88 166.66,134.79 166.66,134.19 166.75,134.1 167.11,134.1 167.31,133.9 167.31,133.43 166.92,133.05 166.48,133.05 165.84,132.41 165.17,132.41 164.73,131.96 164.73,131.28 165.2,130.8 165.52,130.8 165.61,130.71 165.61,130.53 165.49,130.41 165.49,129.7 164.72,128.93 164.72,127.37 164.82,127.27 165.07,127.27 165.2,127.4 J1E5.277
M_DQS_A_DN<8>: length 77.5
  TOP w0.165: J1F1.196 239.26,119.3 239.26,120.21 239.1,120.63 238.9,120.77 238.35,120.77 238.15,120.97 238.15,121.21 238.72,121.77 238.72,122.61 239.57,123.46 239.57,124.47 239.09,125.56 239.09,125.73 J1E5.196 ; J3D1.AJ31 v3(232.67,172.03)
  LAY8 w0.089: v3(232.67,172.03) 232.12,171.48 228.88,171.48 228.64,171.24 228.64,169.08 228.3,168.73 227,168.73 226.71,168.44 226.71,168.06 226.86,167.9 226.86,165.19 226.4,164.73 226.44,164.69 226.44,164.67 226.43,164.66
  LAY8 w0.19: J1E5.196 239.42,126.9 239.58,127.06 239.58,128.35 238.96,128.96 238.41,128.96 238.01,129.37 237.43,129.37 237.03,129.77 237.03,129.99 237.03,129.99 237.03,130.52 236.18,131.37 236.18,133.07 233.89,135.36 233.89,135.96 233.07,136.78 232.46,136.78 231.84,137.41 231.84,138.11 230.11,139.84 230.11,140.19 230.75,140.83 230.75,141.47 229.87,142.35 229.23,142.35 228.55,141.67 228.28,141.67 227.88,142.07 227.88,142.34 229.3,143.76 229.3,144.29 228.71,144.88 228.18,144.88 226.76,143.46 226.49,143.46 226.09,143.86 226.09,144.13 227.51,145.55 227.51,146.08 226.29,147.3 225.85,147.3 225.49,147.66 225.49,148.18 226.76,149.45 226.76,154.79 226.53,155.01 226.53,159.87 225.98,160.43 225.98,164.21 226.43,164.66
M_DQS_A_DP<0>: length 86.3
  TOP w0.165: J3D1.AG38 v3(239.98,174.83)
  LAY2 w0.089: v3(239.98,174.83) 240.29,175.14 240.43,175.14 240.88,174.69 241.59,174.69 241.63,174.65 242.22,174.65 242.36,174.79 252.01,174.79 259.78,167.02 259.78,159.27 272.54,146.51 272.54,140.61 272.97,140.18 272.97,140.17 272.98,140.16 272.98,139.97 273.06,139.89 273.26,139.89 276.71,136.44 276.71,136.28 276.51,136.09 276.51,135.48 276.6,135.39 277.78,135.39 277.87,135.3 277.87,134.83 277.78,134.74 276.6,134.74 276.51,134.66 276.51,133.75 276.6,133.66 277.78,133.66 277.87,133.57 277.87,133.11 277.78,133.02 276.6,133.02 276.51,132.93 276.51,132.47 276.77,132.21 276.77,131.93 276.65,131.82 276.65,131.69 276.77,131.58 276.77,131.37 276.19,130.79 276.07,130.79 275.91,130.95 275.76,130.95 275.6,130.79 275.6,130.6 275.9,130.3 275.9,129.29 275.99,129.2 276.31,129.2 276.57,128.94 276.57,127.94 276.49,127.86 J1E5.153 276.41,127.42 276.41,126.83 276.18,126.6 276.18,125.99 276.54,125.39 276.54,124.34 276.72,123.78 276.72,123.58 275.92,122.78 275.92,122.31 275.91,120.39 J1F1.153
M_DQS_A_DP<1>: length 72
  TOP w0.165: v3(239.98,169.29) J3D1.AM38
  LAY2 w0.088: 266.53,126.93 266.53,126.35 J1E5.164 266.71,126.17 266.71,125.67
  LAY2 w0.089: 266.53,126.93 266.53,129.01 267.3,129.77 267.3,130.44 266.55,131.19 266.55,132.14 266.43,132.26 266.43,132.38 266.73,132.68 266.73,133.01 266.55,133.19 266.55,134.23 263.84,136.93 263.84,145.06 263.27,145.64 263.27,146.25 263.33,146.32 263.42,146.32 263.48,146.26 263.57,146.26 263.84,146.53 263.84,146.73 262.87,147.71 262.16,147.71 261.96,147.91 261.96,148.61 261.59,148.99 260.92,148.99 260.69,149.21 260.69,149.88 260.35,150.22 259.62,150.22 259.42,150.42 259.42,151.15 253.79,156.78 253.79,164.54 250.11,168.21 244.77,168.21 243.03,169.96 242.34,169.96 242.15,170.14 241.71,170.14 241.67,170.11 241.15,170.11 240.71,169.67 240.36,169.67 v3(239.98,169.29) ; 266.71,125.67 266.62,125.58 266.62,123.39 267.39,122.62 267.39,122.05 267.18,121.83 267.18,120.79 266.61,120.22 266.61,118.5 J1F1.164
M_DQS_A_DP<2>: length 59.6
  TOP w0.165: v3(239.98,164.67) J3D1.AU38
  LAY2 w0.089: v3(239.98,164.67) 240.38,165.07 240.51,165.07 242.35,163.22 242.35,163.22 242.71,162.86 242.71,161.93 242.78,161.73 242.78,161.7 243.07,160.93 244.04,158.25 244.21,157.78 247.48,154.51 250.76,151.23 250.76,149.6 250.87,149.5 251.27,149.5 251.71,149.94 251.84,149.94 252.03,149.75 252.03,149.54 251.95,149.46 251.95,149.33 252.03,149.25 252.03,138.08 256.52,133.59 256.65,133.59 256.8,133.74 257.89,133.74 258.02,133.61 258.02,133.31 257.89,133.18 257.44,133.18 257.35,133.09 257.35,132.38 257.44,132.29 257.97,132.29 258.06,132.2 258.06,131.91 257.99,131.84 257.99,131.71 258.06,131.64 258.06,131.36 257.49,130.79 257.37,130.79 257.21,130.95 257.06,130.95 256.9,130.79 256.9,130.6 257.2,130.3 257.2,129.29 257.29,129.2 257.61,129.2 257.87,128.94 257.87,127.94 257.79,127.86 J1E5.175 257.71,127.42 257.71,126.83 257.48,126.6 257.48,125.99 257.84,125.39 257.84,124.34 258.01,123.78 258.01,123.58 257.21,122.78 257.21,122.31 257.21,120.39 J1F1.175
M_DQS_A_DP<3>: length 52
  TOP w0.165: v3(236.28,163.8) J3D1.AV34
  LAY2 w0.088: 248.01,125.67 248.01,126.17 J1E5.186 247.83,126.35 247.83,126.93
  LAY2 w0.089: 247.83,126.93 247.83,129.01 248.6,129.77 248.6,130.44 247.84,131.2 247.84,132.9 243.29,137.45 243.29,149.69 239,153.98 236.66,160.2 236.66,160.91 236.27,161.3 236.27,162.13 236.23,162.16 236.23,162.75 236.7,163.22 236.7,163.38 v3(236.28,163.8) ; J1F1.186 247.91,118.5 247.91,120.22 248.48,120.79 248.48,121.83 248.69,122.05 248.69,122.62 247.92,123.39 247.92,125.58 248.01,125.67
