# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2_COMP: length 7.6
  TOP w0.088: U6E1.F4 111.68,157.6 111.68,158.17 111.63,158.22 111.63,159.23 111.95,159.55 112.5,159.55 114.3,161.35 114.3,162.3 114.68,162.69 114.68,162.94 R6D68.2
USB2_ID: length 22.7
  TOP w0.089: U6E1.G3 111.49,157.75 111.49,158.09 111.43,158.14 111.43,159.32
  TOP w0.1: R6D51.2 116.58,176.91 R6D55.1 R6D52.1 116.58,174.62 116.37,174.41 116.37,165.52 114.3,163.45 114.3,162.74 114.04,162.49 114.04,161.37 112.42,159.75 111.87,159.75 111.43,159.32
USB2_P1_DN: length 214
  TOP w0.088: v1(111.93,164.69) 111.93,164.77 111.65,165.05 111.43,165.05 110.94,164.56 110.94,162.64 109.84,161.53 109.84,158.13 109.99,157.97 109.99,157.86 110,157.47 109.92,157.39 U6E1.J3
  TOP w0.1: v1(226.56,262.76) 226.87,263.07 226.87,263.78 226.78,263.87 226.78,264.63 L3A5.1
  BOTTOM w0.1: v1(111.93,164.69) 112.25,165.01 114.1,165.01 116.53,167.43 116.53,170.51 120.59,174.57 120.59,191.33 121.28,192.02 121.28,198.28 121.1,198.46 121.1,203.27 122.4,204.57 122.4,213.08 123,213.69 123,216.3 124.02,217.32 124.02,223.21 124.33,223.52 124.33,232.18 120.08,236.43 120.08,237.18 121.41,238.5 121.41,239.67 127.55,245.82 127.55,248.18 132.94,253.57 147.85,253.57 148.85,254.56 168.23,254.56 169.06,255.4 169.97,255.4 170.86,256.28 173.81,256.28 175.27,257.74 178.64,257.74 179.86,258.95 180.81,258.95 182.59,260.73 189.16,260.73 189.94,259.95 191.19,259.95 192.63,261.39 196.64,261.39 197.76,262.51 198.88,262.51 199.15,262.78 211.17,262.78 212.08,261.88 224.66,261.88 226.08,263.3 226.76,263.3 226.86,263.2 226.86,263.01 226.61,262.76 v1(226.56,262.76)
USB2_P1_DP: length 214
  TOP w0.088: U6E1.J2 109.81,157.83 109.81,157.89 109.65,158.05 109.65,161.61 110.76,162.71 110.76,164.64 111.36,165.24 111.65,165.24 v1(111.93,165.52)
  TOP w0.1: v1(227.35,262.76) 227.07,263.04 227.07,263.86 226.98,263.95 226.98,264.63 L3A5.2
  BOTTOM w0.1: v1(111.93,165.52) 112.25,165.21 114.02,165.21 116.33,167.51 116.33,170.59 120.39,174.65 120.39,191.42 121.08,192.1 121.08,198.19 120.9,198.37 120.9,203.35 122.2,204.65 122.2,213.16 122.8,213.77 122.8,216.38 123.82,217.4 123.82,223.3 124.13,223.6 124.13,232.1 119.88,236.35 119.88,237.26 121.21,238.59 121.21,239.76 127.35,245.9 127.35,248.26 132.86,253.77 147.77,253.77 148.76,254.76 168.14,254.76 168.98,255.6 169.89,255.6 170.78,256.48 173.73,256.48 175.18,257.94 178.56,257.94 179.77,259.15 180.73,259.15 182.5,260.93 189.24,260.93 190.03,260.15 191.11,260.15 192.55,261.59 196.56,261.59 197.68,262.71 198.79,262.71 199.07,262.98 211.26,262.98 212.16,262.08 224.58,262.08 226,263.5 226.84,263.5 227.06,263.28 227.06,263.06 v1(227.35,262.76)
USB2_P1_L_DN: length 25.7
  TOP w0.1: L3A5.4 226.79,266.88 226.79,267.61 CR3A5.1 226.85,267.87 226.85,269.56 225.04,271.37 225.04,271.91 220.72,276.22 220.47,276.22 219.45,277.24 219.45,281.78 218.53,282.7 215.07,282.7 214.58,282.21 214.58,281.81 214.79,281.6 J3A1.12
USB2_P1_L_DP: length 25.7
  TOP w0.1: L3A5.3 226.99,266.85 226.99,267.51 CR3A6.1 227.05,267.87 227.05,269.64 225.24,271.45 225.24,271.99 220.8,276.42 220.55,276.42 219.65,277.32 219.65,281.87 218.62,282.9 214.99,282.9 J3A1.13
USB2_P2_DN: length 221.2
  TOP w0.1: v1(224.68,264.03) 224.61,264.11 L3A4.2 ; U6E1.N13 v1(108.63,152.37)
  BOTTOM w0.088: 111.08,165.37 110.94,165.23 110.94,157.41 111.04,157.31 111.04,156.64 110.92,156.52 110.92,156.13 110.96,156.09 110.96,155.71 110.71,155.45 110.64,155.28 110.64,155.05 110.3,154.72 110.3,154.27 109.47,153.44 108.87,153.44 108.83,153.48 108.37,153.48 108.19,153.3 108.19,152.13 108.3,152.02 108.51,152.02 108.63,152.15 v1(108.63,152.37)
  BOTTOM w0.1: v1(224.68,264.03) 224.49,264.03 224.34,263.88 224.34,262.82 224.08,262.56 212.41,262.56 211.05,263.92 198.03,263.92 196.22,262.11 192.31,262.11 190.89,260.69 190.21,260.69 189.48,261.42 179.86,261.42 179.42,260.98 179.42,259.66 178.21,258.44 174.9,258.44 173.43,256.97 163.96,256.97 162.26,255.27 148.59,255.27 147.57,254.25 132.66,254.25 126.87,248.46 126.87,246.15 118.94,238.22 118.94,235.67 123.57,231.04 123.57,223.9 123.34,223.67 123.34,217.96 120.39,215.01 120.39,213.49 120.96,212.91 120.96,208.34 121.64,207.67 121.64,205.46 119.71,203.53 119.71,194.39 119.4,194.08 119.4,186.28 119.92,185.77 119.92,174.96 119.28,174.32 115.77,170.81 115.77,167.71 114.3,166.24 111.96,166.24 111.08,165.37
USB2_P2_DP: length 221.1
  TOP w0.1: L3A4.1 223.9,264.84 v1(223.9,264.03) ; U6E1.N15 v1(108.63,151.61)
  BOTTOM w0.088: 110.89,165.46 110.89,165.44 110.75,165.31 110.75,157.34 110.86,157.24 110.86,156.72 110.73,156.6 110.73,156.05 110.78,156.01 110.78,155.79 110.55,155.56 110.45,155.32 110.45,155.13 110.12,154.79 110.12,154.35 109.39,153.63 108.95,153.63 108.9,153.67 108.29,153.67 108,153.38 108,152.05 108.11,151.94 108.22,151.83 108.41,151.83 v1(108.63,151.61)
  BOTTOM w0.1: v1(223.9,264.03) 224.14,263.79 224.14,262.91 223.99,262.76 212.5,262.76 211.13,264.12 197.95,264.12 196.14,262.31 192.23,262.31 190.81,260.89 190.3,260.89 189.57,261.62 179.78,261.62 179.22,261.06 179.22,259.74 178.12,258.64 174.82,258.64 173.35,257.17 163.87,257.17 162.17,255.47 148.51,255.47 147.49,254.45 132.58,254.45 126.67,248.54 126.67,246.23 118.74,238.3 118.74,235.58 123.37,230.96 123.37,223.98 123.14,223.75 123.14,218.04 120.19,215.09 120.19,213.4 120.76,212.83 120.76,208.26 121.44,207.59 121.44,205.54 119.51,203.61 119.51,194.47 119.2,194.16 119.2,186.2 119.72,185.68 119.72,175.04 118.8,174.12 115.57,170.89 115.57,167.79 114.21,166.44 111.87,166.44 110.89,165.46
USB2_P2_L_DN: length 19.1
  TOP w0.1: L3A4.3 224.33,266.85 224.33,267.51 CR3A4.1 224.38,267.87 224.38,271.83 222.02,274.19 220.62,274.19 218.69,276.12 216.25,276.12 215.77,276.6 215.77,277.11 214.81,278.07 214.81,278.3 214.91,278.4 J3A1.22
USB2_P2_L_DP: length 19.1
  TOP w0.1: L3A4.4 224.13,266.88 224.13,267.61 CR3A3.1 224.18,267.87 224.18,271.75 221.94,273.99 220.54,273.99 218.61,275.92 216.17,275.92 215.57,276.52 215.57,277.03 214.61,277.99 214.61,278.25 214.46,278.4 J3A1.23
USB2_P3_DN: length 202.2
  TOP w0.088: 110.68,165.29 110.66,165.28 110.66,165.28 110.61,165.24 110.61,165.24 110.49,165.12 110.49,162.81 109.42,161.75 109.42,157.71 109.54,157.59 109.56,157.59 109.65,157.5 109.65,157.12 109.31,156.79
  TOP w0.1: v1(206,266.54) 206.22,266.31 206.22,265.8 207.28,264.75 207.87,264.75 L3A3.2 ; 110.68,165.29 112.39,167 112.39,167.47 v1(112.69,167.77)
  BOTTOM w0.1: v1(206,266.54) 206.22,266.76 206.22,266.96 206.1,267.08 205.36,267.08 204.85,266.57 199.64,266.57 199.13,266.06 196.8,266.06 195.85,265.12 192.56,265.12 191.7,264.26 178.79,264.26 178.18,263.65 175.64,263.65 174.37,262.38 174.37,261.24 172.41,259.29 163.3,259.29 161.34,257.33 154.78,257.33 152.98,259.13 150.82,259.13 149.45,257.76 148.19,257.76 146.74,256.31 131.82,256.31 124.25,248.74 124.25,246.56 116.58,238.89 116.58,234.98 119.32,232.24 119.32,226.14 119.71,225.75 120.73,225.75 121.28,225.2 121.28,218.95 116.46,214.13 116.46,207.27 115.94,206.75 115.94,205.74 117.47,204.21 117.47,199.13 116.45,198.12 116.45,197.74 115.44,196.72 115.44,193.42 116.2,192.66 116.2,189.74 115.97,189.51 115.97,185.78 117.9,183.85 117.9,177.46 116.83,176.4 116.83,175.61 116.1,174.88 116.1,174.04 112.4,170.34 112.4,168.06 v1(112.69,167.77)
USB2_P3_DP: length 202.2
  TOP w0.088: 110.53,165.43 110.3,165.19 110.3,162.89 109.23,161.83 109.23,157.63 109.4,157.46 U6E1.K3
  TOP w0.1: 110.53,165.43 111.36,166.26 112.19,167.08 112.19,167.47 v1(111.89,167.77) ; v1(206.8,266.54) 206.6,266.54 206.42,266.36 206.42,265.88 207.36,264.95 207.84,264.95 L3A3.1
  BOTTOM w0.1: v1(206.8,266.54) 206.6,266.54 206.42,266.71 206.42,267.04 206.18,267.28 205.27,267.28 204.76,266.77 199.56,266.77 199.05,266.26 196.71,266.26 195.77,265.32 192.48,265.32 191.62,264.46 178.71,264.46 178.09,263.85 175.55,263.85 174.17,262.46 174.17,261.32 172.33,259.49 163.22,259.49 161.26,257.53 154.87,257.53 153.06,259.33 150.74,259.33 149.37,257.96 148.1,257.96 146.65,256.51 131.74,256.51 124.05,248.82 124.05,246.64 116.38,238.97 116.38,234.89 119.12,232.15 119.12,226.06 119.63,225.55 120.65,225.55 121.08,225.12 121.08,219.03 116.26,214.21 116.26,207.35 115.74,206.83 115.74,205.66 117.27,204.13 117.27,199.22 116.25,198.2 116.25,197.82 115.49,197.05 115.24,196.8 115.24,193.34 116,192.57 116,189.82 115.77,189.59 115.77,185.7 117.7,183.77 117.7,177.54 116.63,176.48 116.63,175.69 115.9,174.96 115.9,174.13 112.2,170.42 112.2,168.07 v1(111.89,167.77)
USB2_P3_L_DN: length 16.1
  TOP w0.1: J3A1.32 215.11,275.2 214.91,275 214.91,274.19 216.59,272.51 216.59,271.59 214.24,269.24 214.24,267.71 CR3A9.1 214.19,267.41 214.19,267.03 211.93,264.77 210.1,264.77 L3A3.3
USB2_P3_L_DP: length 16
  TOP w0.1: L3A3.4 210.08,264.97 211.85,264.97 213.99,267.11 213.99,267.46 CR3A8.1 214.04,267.77 214.04,269.32 216.39,271.67 216.39,272.42 214.71,274.11 214.71,275.1 214.61,275.2 J3A1.33
USB2_P4_DN: length 207.1
  TOP w0.1: U6E1.M10 108.96,153.87 v1(109.16,154.07) ; v1(206.45,268.48) 206.68,268.25 206.68,267.29 206.9,267.08 207.82,267.08 L3A2.2
  BOTTOM w0.088: 109.91,166.43 109.91,166.42 109.72,166.22 109.72,157.87 109.31,157.45 109.31,155.42 109.15,155.27 109.15,155.06 109.01,154.92 109.01,154.23 v1(109.16,154.07)
  BOTTOM w0.1: v1(206.45,268.48) 206.69,268.23 206.69,268.09 206.57,267.97 204.94,267.97 204.51,267.53 199.18,267.53 198.67,267.03 196.22,267.03 195.26,266.07 192.26,266.07 191.36,265.16 180.35,265.16 179.88,265.63 175.55,265.63 173.48,263.55 173.48,261.62 172.03,260.17 162.89,260.17 161.64,258.92 154.58,258.92 153.46,260.04 150.49,260.04 149.09,258.65 147.83,258.65 147.01,257.83 137.66,257.83 137.07,257.25 131.51,257.25 122.42,248.16 122.42,246.03 115.59,239.19 115.59,234.64 118.41,231.82 118.41,224.48 120.39,222.5 120.39,219.49 115.59,214.68 115.59,207.82 115.06,207.29 115.06,205.33 116.51,203.88 116.51,199.47 115.37,198.33 115.37,198.07 114.59,197.3 114.21,197.3 113.71,196.8 113.71,193.59 115.16,192.14 115.16,185.34 117.02,183.48 117.02,177.89 115.95,176.81 115.95,176.18 114.68,174.91 114.68,173.87 110.84,170.03 110.84,167.36 109.91,166.43
USB2_P4_DP: length 207.1
  TOP w0.1: v1(109.64,154.6) 109.61,154.63 109.61,154.76 109.48,154.89 109.16,154.89 109.06,154.79 U6E1.L9 ; L3A2.1 207.89,267.28 206.98,267.28 206.88,267.38 206.88,268.22 207.13,268.48 v1(207.25,268.48)
  BOTTOM w0.088: v1(109.64,154.6) 109.62,154.58 109.58,154.58 109.49,154.49 109.34,154.49 109.2,154.62 109.2,154.84 109.34,154.98 109.34,155.19 109.49,155.34 109.49,157.38 109.91,157.79 109.91,166.15 110.11,166.34
  BOTTOM w0.1: 110.11,166.34 111.04,167.28 111.04,169.95 114.88,173.78 114.88,174.82 116.15,176.09 116.15,176.73 117.22,177.8 117.22,183.56 115.36,185.42 115.36,192.22 113.91,193.67 113.91,196.72 114.3,197.1 114.68,197.1 115.57,197.99 115.57,198.25 116.71,199.39 116.71,203.96 115.26,205.41 115.26,207.21 115.79,207.74 115.79,214.6 120.59,219.4 120.59,222.58 118.61,224.56 118.61,231.9 115.79,234.73 115.79,239.11 122.62,245.94 122.62,248.08 131.59,257.05 137.16,257.05 137.74,257.63 147.09,257.63 147.91,258.45 149.17,258.45 150.57,259.84 153.38,259.84 154.5,258.72 161.72,258.72 162.97,259.97 172.11,259.97 173.68,261.54 173.68,263.47 175.64,265.43 179.8,265.43 180.26,264.96 191.44,264.96 192.35,265.87 195.34,265.87 196.3,266.83 198.75,266.83 199.26,267.33 204.59,267.33 205.03,267.77 206.65,267.77 206.89,268.01 206.89,268.24 207.13,268.48 v1(207.25,268.48)
USB2_P4_L_DN: length 9.2
  TOP w0.1: L3A2.3 210.09,267.04 210.44,267.04 210.53,266.95 211.66,266.95 211.9,267.19 211.9,267.41 CR3A10.1 211.96,267.71 211.96,268.22 214.91,271.17 214.91,271.8 215.11,272 J3A1.36
USB2_P4_L_DP: length 9.2
  TOP w0.1: L3A2.4 210.09,267.24 210.52,267.24 210.62,267.15 211.58,267.15 211.7,267.28 211.7,267.46 CR3A7.1 211.76,267.77 211.76,268.31 214.71,271.26 214.71,271.9 214.61,272 J3A1.37
USB2_P5_DN: length 207.5
  TOP w0.088: 110.16,166.02 110.15,166.01 110.15,166 110.11,165.96 110.11,165.95 109.79,165.63 109.79,163.04 108.76,162.01 108.76,158.82 108.82,158.75 108.82,158.59 U6E1.M1
  TOP w0.1: 110.16,166.02 110.96,166.81 110.96,168.67 111.35,169.06 113.28,169.06 113.87,168.48 114.17,168.48 114.32,168.63 v1(114.32,168.86) ; v1(205.99,272.4) 205.85,272.54 205.3,272.54 LP4A1.1
  BOTTOM w0.1: v1(114.32,168.86) 114.32,168.63 114.47,168.48 114.76,168.48 114.86,168.58 114.86,171.16 117.34,173.64 117.34,174.37 119.04,176.07 119.04,185.34 118.51,185.87 118.51,195.63 118.82,195.94 118.82,206.61 119.05,206.84 119.05,208.1 118.55,208.59 118.55,214.47 122.45,218.37 122.45,227.91 121.72,228.64 121.72,231.56 117.98,235.3 117.98,238.53 125.78,246.33 125.78,248.62 132.3,255.14 147.21,255.14 148.66,256.59 149.93,256.59 150.89,257.55 152.78,257.55 154.18,256.15 161.89,256.15 163.67,257.94 172.97,257.94 175.33,260.29 177.97,260.29 178.53,260.86 178.53,261.37 178.59,261.43 179.49,262.33 189.93,262.33 190.59,262.99 195.8,262.99 197.63,264.82 207.79,264.82 209.22,266.24 209.22,269.28 208.53,269.97 208.53,270.35 208.19,270.69 207.71,270.69 207.06,271.34 207.06,272.58 206.67,272.98 206.45,272.98 205.99,272.52 v1(205.99,272.4)
USB2_P5_DP: length 207.5
  TOP w0.088: 110.31,165.88 109.98,165.55 109.98,162.96 108.95,161.93 108.95,158.89 109.01,158.83 109.01,158.67 109.01,158.34 108.91,158.24 U6E1.L2
  TOP w0.1: LP4A1.2 205.94,273.12 v1(205.99,273.18) ; 110.31,165.88 111.16,166.73 111.16,168.59 111.43,168.86 113.2,168.86 113.79,168.28 114.08,168.28 v1(114.32,168.04)
  BOTTOM w0.1: v1(114.32,168.04) 114.56,168.28 114.84,168.28 115.06,168.49 115.06,171.07 117.54,173.56 117.54,174.29 119.24,175.99 119.24,185.42 118.71,185.96 118.71,195.55 119.02,195.86 119.02,206.53 119.25,206.75 119.25,208.18 118.75,208.67 118.75,214.39 122.65,218.29 122.65,227.99 121.92,228.73 121.92,231.65 118.18,235.38 118.18,238.45 125.98,246.25 125.98,248.54 132.38,254.94 147.3,254.94 148.75,256.39 150.01,256.39 150.98,257.35 152.69,257.35 154.09,255.95 161.97,255.95 163.75,257.74 173.05,257.74 175.41,260.09 178.05,260.09 178.74,260.78 178.74,261.29 179.57,262.13 190.01,262.13 190.68,262.79 195.88,262.79 197.71,264.62 207.87,264.62 209.42,266.16 209.42,269.37 208.73,270.05 208.73,270.44 208.28,270.89 207.8,270.89 207.26,271.43 207.26,272.67 206.75,273.18 v1(205.99,273.18)
USB2_P5_L_DN: length 23.1
  TOP w0.1: LP4A1.4 203.17,272.62 202.26,272.62 CR4A9.1 202,272.72 201.46,272.72 200.83,273.36 199.18,273.36 198.8,273.73 198.8,275.79 191.77,282.83 188.28,282.83 187.8,282.34 187.8,281.81 188.01,281.6 J4A2.2
USB2_P5_L_DP: length 23.1
  TOP w0.1: J4A2.3 187.01,281.6 187.6,282.19 187.6,282.43 188.2,283.03 191.85,283.03 199,275.87 199,273.81 199.26,273.56 200.91,273.56 201.54,272.92 202.05,272.92 CR4A8.1 202.41,272.82 203.14,272.82 LP4A1.3
USB2_P6_DN: length 208
  TOP w0.089: U6E1.K7 v1(109.95,155.29)
  TOP w0.1: LP4A2.2 205.33,270.48 205.63,270.48 206.24,269.87 206.59,269.87 206.7,269.98 206.7,270.08 v1(206.4,270.38)
  BOTTOM w0.088: 110.45,165.99 110.44,165.97 110.44,165.97 110.4,165.92 110.4,165.92 110.23,165.75 110.23,157.75 109.69,157.2 109.69,155.96 109.95,155.69 v1(109.95,155.29)
  BOTTOM w0.1: 110.45,165.99 111.6,167.13 113,167.13 113.53,167.67 113.53,170.79 116.58,173.84 116.58,174.62 117.34,175.39 117.34,176.18 118.37,177.2 118.37,185 117.9,185.46 117.9,189.56 117.02,190.44 117.02,197.95 118.03,198.96 118.03,204.39 116.64,205.78 116.64,206.58 116.94,206.89 116.94,213.87 121.77,218.7 121.77,227.6 121.03,228.34 121.03,231.27 117.09,235.2 117.09,238.66 124.85,246.42 124.85,248.66 132.02,255.83 146.93,255.83 148.38,257.28 149.65,257.28 150.82,258.44 152.93,258.44 154.54,256.84 161.59,256.84 163.55,258.8 172.69,258.8 174.87,260.98 174.87,261.32 175.63,262.07 178.09,262.07 179.8,263.78 191.98,263.78 192.82,264.62 196.39,264.62 197.27,265.5 207.43,265.5 208.51,266.58 208.51,269.03 208.17,269.37 206.98,269.37 206.7,269.64 206.7,270.08 v1(206.4,270.38)
USB2_P6_DP: length 208
  TOP w0.089: U6E1.K6 v1(110.28,155.98)
  TOP w0.1: v1(207.2,270.38) 207.13,270.38 206.9,270.15 206.9,269.9 206.67,269.67 206.16,269.67 205.55,270.28 205.26,270.28 205.02,270.05 LP4A2.1
  BOTTOM w0.088: v1(110.28,155.98) 110.23,155.93 109.98,155.93 109.88,156.04 109.88,157.13 110.42,157.67 110.42,165.67 110.6,165.84
  BOTTOM w0.1: v1(207.2,270.38) 207.06,270.38 206.9,270.22 206.9,269.73 207.06,269.57 208.25,269.57 208.71,269.11 208.71,266.49 207.51,265.3 197.35,265.3 196.47,264.42 192.9,264.42 192.06,263.58 179.88,263.58 178.18,261.87 175.71,261.87 175.07,261.24 175.07,260.9 172.77,258.6 163.63,258.6 161.67,256.64 154.45,256.64 152.85,258.24 150.9,258.24 149.73,257.08 148.47,257.08 147.02,255.63 132.1,255.63 125.05,248.58 125.05,246.34 117.29,238.58 117.29,235.29 121.23,231.35 121.23,228.43 121.97,227.69 121.97,218.62 117.14,213.79 117.14,206.8 116.84,206.5 116.84,205.87 118.23,204.47 118.23,198.88 117.22,197.86 117.22,190.53 118.1,189.64 118.1,185.55 118.57,185.08 118.57,177.12 117.54,176.09 117.54,175.3 116.78,174.54 116.78,173.76 116.48,173.46 116.48,173.46 113.73,170.71 113.73,167.58 113.08,166.93 111.68,166.93 110.6,165.84
USB2_P6_L_DN: length 21.5
  TOP w0.1: LP4A2.3 203.03,270.55 202.63,270.55 202.54,270.45 202.36,270.45 CR4A10.1 202.06,270.51 201.82,270.51 201.7,270.64 201.7,271.37 200.2,272.87 196.29,272.87 193.7,275.46 189.61,275.46 188.84,276.22 188.84,277.24 189.77,278.16 189.77,278.52 189.53,278.76 189.14,278.76 J4A2.11
USB2_P6_L_DP: length 21.5
  TOP w0.1: LP4A2.4 203.03,270.35 202.72,270.35 202.62,270.25 202.31,270.25 ; 202.31,270.25 202.3,270.25 202.18,270.14 202,270.31 201.74,270.31 201.5,270.56 201.5,271.29 200.12,272.67 196.21,272.67 193.62,275.26 189.52,275.26 188.64,276.14 188.64,277.31 187.56,278.4 J4A2.12 ; 202.31,270.25 CR4A11.1
USB2_P7_DN: length 172.9
  TOP w0.088: 109.52,166.45 109.52,166.43 109.28,166.19 109.28,163.27 108.29,162.28 108.29,158.31 108.49,158.11 108.49,157.68 108.71,157.47 108.71,157.15 U6E1.L4
  TOP w0.1: v1(164.69,278.54) 164.77,278.61 L5A1.3 ; 109.52,166.45 110.28,167.2 110.28,169.24 113.33,172.29 113.33,174.29 112.62,175 112.62,175.72 112.49,175.85 112.29,175.85 v1(112.06,175.62)
  BOTTOM w0.1: v1(112.06,175.62) 111.84,175.85 111.69,175.85 111.33,176.21 111.33,177.49 109.94,178.87 108.5,178.87 108,179.37 108,182.42 108.05,182.48 108.33,182.75 108.33,185.77 106.7,187.39 106.7,190.4 108.07,191.77 108.07,193.26 106.93,194.41 106.93,200.02 105.94,201.01 105.94,219.86 108.51,222.43 108.51,227.75 107.87,228.39 107.87,230.59 108.62,231.34 111.8,231.34 113.46,233 113.46,239.35 119.94,245.83 119.94,248.37 127.42,255.85 128.06,255.85 130.85,258.64 133.9,258.64 134.79,259.53 136.6,259.53 136.86,259.28 146.54,259.28 147.01,259.75 147.01,260.46 148.39,261.83 148.39,264.2 147.88,264.71 147.88,266.91 148.63,267.66 151.45,267.66 151.94,268.15 156.38,268.15 158.75,270.51 158.75,272.82 162.91,276.99 164.81,276.99 165.05,277.22 165.05,277.8 164.9,277.95 164.9,278.33 v1(164.69,278.54)
USB2_P7_DP: length 173
  TOP w0.088: U6E1.L3 108.68,157.76 108.68,158.19 108.48,158.39 108.48,162.2 109.47,163.19 109.47,166.11 109.71,166.36
  TOP w0.1: v1(165.48,278.51) 165.45,278.53 165.45,279.3 L5A1.4 ; v1(112.06,176.42) 112.06,176.22 112.24,176.05 112.58,176.05 112.82,175.8 112.82,175.08 113.53,174.37 113.53,172.21 110.48,169.16 110.48,167.12 109.71,166.36
  BOTTOM w0.1: v1(165.48,278.51) 165.3,278.51 165.1,278.31 165.1,278.03 165.25,277.88 165.25,277.14 164.9,276.79 162.99,276.79 158.95,272.74 158.95,270.43 156.47,267.95 152.02,267.95 151.53,267.46 148.71,267.46 148.08,266.83 148.08,264.79 148.59,264.29 148.59,261.75 147.21,260.37 147.21,259.67 146.63,259.08 136.77,259.08 136.52,259.33 134.87,259.33 133.98,258.44 130.93,258.44 128.14,255.65 127.5,255.65 120.14,248.28 120.14,245.74 113.66,239.27 113.66,232.92 111.88,231.14 108.71,231.14 108.07,230.5 108.07,228.47 108.33,228.21 108.71,227.84 108.71,222.35 106.14,219.78 106.14,201.09 107.13,200.11 107.13,194.49 108.27,193.35 108.27,191.69 106.9,190.32 106.9,187.48 108.53,185.85 108.53,182.67 108.2,182.34 108.2,179.45 108.58,179.07 110.03,179.07 111.53,177.57 111.53,176.29 111.77,176.05 111.89,176.05 112.06,176.22 v1(112.06,176.42)
USB2_P8_DN: length 73.9
  TOP w0.088: U6E1.G4 110.88,157.22 110.88,158.18 110.7,158.36 110.7,161.1 112.01,162.41 112.01,162.9 112.96,163.85 112.98,163.85
  TOP w0.1: v1(112.01,178.73) 112.31,178.43 113.31,178.43 114.18,177.56 114.18,176.93 114.91,176.19 114.91,174.13 115.82,173.23 115.82,166.7 112.98,163.85 ; L6C1.3 105.61,219.94 105.61,219.29 105.83,219.07 107.92,219.07 108.05,218.94 v1(108.05,218.69)
  BOTTOM w0.1: v1(108.05,218.69) 108.05,218.94 107.92,219.07 107.66,219.07 107.51,218.92 107.51,201.86 110.69,198.68 110.69,186.13 110.43,185.87 110.43,182.17 111.5,181.1 111.5,178.57 111.6,178.47 111.79,178.47 112.01,178.68 v1(112.01,178.73)
USB2_P8_DP: length 73.9
  TOP w0.088: 112.89,164.05 111.82,162.98 111.82,162.48 110.52,161.18 110.52,158.28 110.66,158.13 110.66,158.13 110.7,158.1 110.7,157.14 110.84,157 U6E1.G5
  TOP w0.1: L6C1.4 105.81,219.91 105.81,219.37 105.91,219.27 107.81,219.27 v1(108.05,219.51) ; 112.89,164.05 115.62,166.78 115.62,173.14 114.71,174.05 114.71,176.11 113.98,176.85 113.98,177.48 113.23,178.23 112.31,178.23 v1(112.01,177.93)
  BOTTOM w0.1: v1(108.05,219.51) 107.81,219.27 107.58,219.27 107.31,219.01 107.31,201.77 110.49,198.6 110.49,186.21 110.23,185.96 110.23,182.09 111.3,181.02 111.3,178.48 111.52,178.27 111.68,178.27 v1(112.01,177.93)
USB2_P8_L_DN: length 7.7
  TOP w0.1: L6C1.2 105.42,221.96 CR6C1.2 105.56,222.89 105.56,223.47 106.1,224 110.24,224 J6B5.2
USB2_P8_L_DP: length 7.7
  TOP w0.1: L6C1.1 105.89,222.09 CR6C2.2 105.76,222.89 105.76,223.38 106.18,223.8 110.28,223.8 111.01,223.07 J6B5.3
USB2_P9_CMC_ESD_DN: length 8.7
  TOP w0.1: R6D2.1 115.58,192.13 115.58,192.95 CR6D4.2 115.57,193.15 115.57,194.28 116.85,195.57 116.85,198.29 117.2,198.64 J6C4.P18
USB2_P9_CMC_ESD_DP: length 8.7
  TOP w0.1: J6C4.P19 116.4,198.55 116.65,198.3 116.65,195.65 115.37,194.36 115.37,193.2 CR6D3.2 115.38,192.86 115.38,192.09 R6D1.1
USB2_P9_DN: length 69.9
  TOP w0.1: v1(108.85,155.98) 108.51,155.65 108.4,155.65 108.3,155.75 U6E1.M6 ; v1(114.45,188.48) 114.45,188.62 114.68,188.85 115.32,188.85 115.59,189.12 115.59,189.76 R6D2.2
  BOTTOM w0.088: 109.41,166.72 109.4,166.71 109.39,166.71 109.34,166.66 109.34,157.86 108.87,157.39 108.87,156.65 108.46,156.25 108.46,156.03 108.51,155.98 v1(108.85,155.98)
  BOTTOM w0.1: v1(114.45,188.48) 114.1,188.82 113.5,188.82 113.15,189.16 113.15,190.5 113.53,190.88 114.3,190.88 114.42,191.01 114.42,191.51 113.03,192.91 113.03,193.93 112.9,194.05 112.24,194.05 112.14,193.95 112.14,188.34 112.36,188.12 113.82,188.12 114.04,187.9 114.04,187.33 113.82,187.11 112.94,187.11 112.84,187.01 112.84,186.6 112.94,186.5 114.41,186.5 114.62,186.29 114.62,185.71 114.41,185.5 112.18,185.5 112.08,185.4 112.08,184.99 112.18,184.89 112.81,184.89 113.1,184.6 113.1,184.07 112.85,183.82 112.06,183.82 111.96,183.71 111.96,183.19 112.06,183.08 113.7,183.08 113.84,183.22 113.84,184.67 114.06,184.89 114.91,184.89 115.22,184.58 115.22,183.89 115.37,183.74 115.8,183.74 116.55,183 116.55,178.41 114.88,176.74 114.88,176.19 114.19,175.51 114.19,174.06 110.36,170.23 110.36,167.66 109.41,166.72
USB2_P9_DP: length 69.9
  TOP w0.1: R6D1.2 115.39,189.79 115.39,189.2 115.24,189.05 114.67,189.05 v1(114.45,189.28) ; U6E1.N8 v1(108.66,155.2)
  BOTTOM w0.088: 109.27,166.86 109.15,166.75 109.15,157.94 108.68,157.47 108.68,156.73 108.28,156.32 108.28,155.95 108.66,155.57 v1(108.66,155.2)
  BOTTOM w0.1: 109.27,166.86 110.16,167.75 110.16,170.31 113.99,174.14 113.99,175.59 114.68,176.27 114.68,176.82 116.35,178.49 116.35,182.92 115.72,183.54 115.28,183.54 115.02,183.8 115.02,184.49 114.83,184.69 114.14,184.69 114.04,184.59 114.04,183.13 113.79,182.88 111.98,182.88 111.76,183.1 111.76,183.8 111.98,184.02 112.77,184.02 112.9,184.15 112.9,184.51 112.72,184.69 112.1,184.69 111.88,184.9 111.88,185.48 111.99,185.59 112.1,185.7 114.32,185.7 114.42,185.8 114.42,186.2 114.32,186.3 112.86,186.3 112.64,186.52 112.64,187.09 112.86,187.31 113.74,187.31 113.84,187.41 113.84,187.82 113.74,187.92 112.27,187.92 111.94,188.26 111.94,194.04 112.15,194.25 112.98,194.25 113.23,194.01 113.23,192.99 114.38,191.84 114.62,191.6 114.62,190.92 114.38,190.68 113.62,190.68 113.35,190.42 113.35,189.25 113.58,189.02 114.19,189.02 v1(114.45,189.28)
USB2_P10_CMC_ESD_DN: length 11.4
  TOP w0.1: J6C3.P9 105.96,191.23 105.82,191.1 105.65,191.1 105.53,190.98 105.53,190.63 108.58,187.58 110.23,187.58 112.04,185.77 CR6C7.1 112.94,185.1 L6C4.1
USB2_P10_CMC_ESD_DP: length 11.4
  TOP w0.1: L6C4.2 112.49,184.83 CR6C5.1 111.91,185.61 110.15,187.38 108.5,187.38 105.33,190.55 105.33,191.02 105.16,191.18 J6C3.P8
USB2_P10_DN: length 64.9
  TOP w0.088: 111.6,163.73 111.59,163.72 111.59,163.71 111.55,163.67 111.55,163.66 111.31,163.42 111.31,162.61 110.09,161.39 110.09,158.15 110.19,158.06 110.19,157.62 U6E1.H3
  TOP w0.1: 111.6,163.73 113.38,165.51 113.38,165.76 112.77,166.37 112.77,166.7 113.25,167.18 113.61,167.18 114.22,166.57 114.44,166.57 114.83,166.96 114.83,170.15 114.04,170.95 114.04,175.79 113.75,176.07 113.58,176.07 v1(113.33,175.82) ; v1(115.22,181.82) 115.39,181.99 116.12,181.99 123.68,174.43 123.99,174.43 124.25,174.69 124.25,175.11 116,183.36 114.38,183.36 114.21,183.53 L6C4.4
  BOTTOM w0.1: v1(115.22,181.82) 115.04,181.99 113.83,181.99 113.53,181.69 113.53,181.11 113.83,180.81 115.66,180.81 115.87,180.59 115.87,180.02 115.66,179.8 114.21,179.8 114.11,179.7 114.11,179.3 114.21,179.2 115.37,179.2 115.59,178.98 115.59,178.41 115.37,178.19 114.21,178.19 114.11,178.09 114.11,176.38 113.79,176.06 113.57,176.06 v1(113.33,175.82)
USB2_P10_DP: length 64.9
  TOP w0.088: 111.74,163.59 111.5,163.35 111.5,162.53 110.28,161.32 110.28,158.23 110.37,158.14 110.37,158 110.38,157.93 U6E1.H2
  TOP w0.1: L6C4.3 114.08,183.38 114.29,183.16 115.91,183.16 124.05,175.03 124.05,174.77 123.91,174.63 123.77,174.63 116.21,182.19 115.52,182.19 115.22,182.49 v1(115.22,182.62) ; v1(113.33,176.65) 113.33,176.42 113.48,176.27 113.84,176.27 114.24,175.87 114.24,171.03 115.03,170.23 115.03,166.87 114.52,166.37 114.14,166.37 113.53,166.98 113.33,166.98 112.97,166.62 112.97,166.45 113.58,165.84 113.58,165.43 111.74,163.59
  BOTTOM w0.1: v1(115.22,182.62) 115.22,182.5 114.9,182.19 113.75,182.19 113.33,181.77 113.33,181.03 113.75,180.61 115.57,180.61 115.67,180.51 115.67,180.1 115.57,180 114.13,180 113.91,179.79 113.91,179.21 114.13,179 115.29,179 115.39,178.9 115.39,178.49 115.29,178.39 114.13,178.39 113.91,178.17 113.91,176.47 113.71,176.26 113.49,176.26 113.33,176.42 v1(113.33,176.65)
USB2_P11_DN: length 73.2
  TOP w0.1: R7C48.1 v1(87.12,196.47) R7C40.1 ; U6E1.R10 107.48,154.05 107.67,154.05 v1(107.85,153.87)
  LAY6 w0.089: 109.41,155.52 109.41,155 108.8,154.39 108.8,154.35 108.7,154.26 108.7,154.15 108.49,153.94 107.92,153.94 v1(107.85,153.87)
  LAY6 w0.115: 109.41,155.52 109.57,155.68 109.57,158.14 109.2,158.51 109.2,158.67 109.9,159.37 109.9,159.72 109.36,160.26 109,160.26 107.77,159.03 107.61,159.03 107.33,159.31 107.33,159.47 108.56,160.7 108.56,161.05 107.42,162.2 105.16,162.2 104.08,161.12 103.92,161.12 103.64,161.4 103.64,161.56 104.57,162.49 104.57,165.3 103.45,166.42 101.61,166.42 87.75,180.28 87.75,183.71 87.87,183.82 90.15,183.82 90.4,184.07 90.4,184.65 90.15,184.9 87.87,184.9 87.75,185.02 87.75,185.41 87.87,185.53 89.41,185.53 89.66,185.78 89.66,186.36 89.41,186.61 87.87,186.61 87.75,186.73 87.75,194.82 87.12,195.45 v1(87.12,196.47)
USB2_P11_DP: length 73.2
  TOP w0.1: R7C39.1 86.38,197.2 v1(86.38,196.47) 86.38,195.73 R7C47.1 ; v1(108.14,154.63) 108.1,154.6 U6E1.P9
  LAY6 w0.089: v1(108.14,154.63) 108.02,154.52 108.02,154.34 108.21,154.15 108.41,154.15 108.5,154.24 108.5,154.34 108.59,154.44 108.59,154.48 109.2,155.09 109.2,155.41 109.19,155.43 109.19,155.61 109.24,155.65 109.24,155.67 109.25,155.68
  LAY6 w0.115: v1(86.38,196.47) 86.46,196.47 86.89,196.04 86.89,195.36 87.52,194.72 87.52,186.63 87.77,186.38 89.31,186.38 89.43,186.27 89.43,185.87 89.31,185.76 87.77,185.76 87.52,185.51 87.52,184.92 87.77,184.67 90.05,184.67 90.17,184.56 90.17,184.17 90.05,184.05 87.77,184.05 87.52,183.8 87.52,180.19 101.52,166.19 103.35,166.19 104.34,165.21 104.34,162.58 103.41,161.66 103.41,161.3 103.83,160.89 104.18,160.89 105.25,161.97 107.32,161.97 108.33,160.96 108.33,160.79 107.1,159.56 107.1,159.21 107.52,158.8 107.87,158.8 109.1,160.03 109.26,160.03 109.67,159.62 109.67,159.46 108.97,158.77 108.97,158.41 109.34,158.04 109.34,155.78 109.25,155.68
USB2_P11_ESD_DN: length 12
  TOP w0.1: LP7C2.3 86.79,201.57 86.79,202.38 CR7C6.2 86.86,202.67 86.86,203.96 86.23,204.6 82.64,204.6 82.08,205.15 82.08,206.48 81.43,207.14 80.94,207.14 80.77,207.31 J7C7.8
USB2_P11_ESD_DP: length 12
  TOP w0.1: LP7C2.4 86.59,201.61 86.59,202.47 CR7C5.2 86.66,202.73 86.66,203.88 86.15,204.4 82.56,204.4 81.88,205.07 81.88,206.4 81.35,206.94 80.9,206.94 80.77,206.81 J7C7.6
USB2_P11_R_DN: length 1.8
  TOP w0.1: R7C40.2 86.8,198.44 86.8,199.38 LP7C2.2
USB2_P11_R_DP: length 1.8
  TOP w0.1: LP7C2.1 86.6,199.32 86.6,198.36 R7C39.2
USB2_P11_TTK3_DN: length 160.3
  TOP w0.1: R7H5.1 63.37,63.35 v1(63.43,63.28) ; v1(92.58,190.93) 92.27,190.63 91.97,190.63 90.38,192.22 88.78,192.22 86.84,194.17 86.84,194.54 R7C48.2
  LAY5 w0.115: v1(92.58,190.93) 92.91,190.6 93.37,190.6 93.66,190.3 93.66,187.38 94.97,186.08 94.97,180.56 95.86,179.67 95.86,173.64 92.19,169.97 92.19,161.02 90.41,159.24 90.41,150.79 89.76,150.14 89.76,139.93 87.88,138.05 87.88,136.14 88.38,135.64 88.38,123.11 82.46,117.19 82.46,112.93 83.43,111.96 83.43,99.95 83.92,99.46 83.92,97.51 83.79,97.38 83.79,94.59 83.08,93.88 82.19,93.88 79.51,91.19 72.25,91.19 70.78,89.72 69.04,89.72 v1(68.73,89.41)
  LAY6 w0.115: v1(63.43,63.28) 63.24,63.48 63.24,64.62 68.68,70.06 68.68,76.35 68.24,76.78 68.24,89.62 68.36,89.74 68.62,89.74 68.73,89.62 v1(68.73,89.41)
USB2_P11_TTK3_DP: length 160.3
  TOP w0.1: v1(92.58,190.12) 92.27,190.43 91.89,190.43 90.29,192.02 88.7,192.02 86.64,194.09 86.64,194.54 R7C47.2 ; v1(62.62,63.28) 62.61,63.3 R7H4.1
  LAY5 w0.115: v1(68.73,90.25) 69.03,89.95 70.69,89.95 72.16,91.42 79.41,91.42 82.09,94.11 82.98,94.11 83.56,94.68 83.56,97.48 83.69,97.61 83.69,99.37 83.2,99.85 83.2,111.86 82.23,112.84 82.23,117.28 88.15,123.2 88.15,135.54 87.65,136.04 87.65,138.14 89.53,140.02 89.53,150.24 90.18,150.89 90.18,159.34 91.96,161.12 91.96,170.07 95.63,173.73 95.63,179.58 94.74,180.47 94.74,185.98 93.43,187.29 93.43,190.21 93.27,190.37 92.83,190.37 v1(92.58,190.12)
  LAY6 w0.115: v1(68.73,90.25) 68.73,90.16 68.54,89.97 68.26,89.97 68.01,89.72 68.01,76.69 68.45,76.25 68.45,70.15 63.01,64.72 63.01,63.5 62.8,63.28 v1(62.62,63.28)
USB2_P12_DN: length 66.1
  TOP w0.088: v1(113.13,163.4) 113.13,163.17 112.96,163 112.68,163 112.28,162.6 112.28,162.32 110.99,161.04 110.99,158.85 111.03,158.81 111.03,158.57 U6E1.G1
  TOP w0.1: v1(89.56,198.37) 89.35,198.37 89.15,198.58 89.15,198.75 89.27,198.88 89.27,199.41 89.51,199.64 LP7C3.2
  LAY6 w0.115: v1(113.13,163.4) 113.13,163.22 112.95,163.04 111.47,163.04 111.21,163.3 110.86,163.3 109.34,161.78 109.18,161.78 108.9,162.06 108.9,162.22 110.42,163.74 110.42,164.09 108.93,165.58 107.33,165.58 106.45,166.47 104.74,166.47 103.2,168.02 101.12,168.02 91.18,177.95 91.18,186.25 90.01,187.42 90.01,188.58 90.13,188.7 90.7,188.7 90.95,188.95 90.95,189.53 90.7,189.78 90.13,189.78 89.4,190.51 89.4,195.61 89.52,195.73 90.7,195.73 90.95,195.98 90.95,196.56 90.7,196.81 89.52,196.81 89.4,196.93 89.4,198.21 v1(89.56,198.37)
USB2_P12_DP: length 66.1
  TOP w0.088: U6E1.G2 111.22,158.06 111.22,158.57 111.22,158.57 111.22,158.89 111.18,158.93 111.18,160.96 112.47,162.25 112.47,162.53 112.75,162.81 112.89,162.81 v1(113.13,162.58)
  TOP w0.1: LP7C3.1 89.07,199.39 89.07,198.96 88.95,198.83 88.95,198.58 v1(88.74,198.37)
  LAY6 w0.115: v1(88.74,198.37) 89.17,197.93 89.17,196.83 89.42,196.58 90.6,196.58 90.72,196.47 90.72,196.07 90.6,195.96 89.42,195.96 89.17,195.71 89.17,190.41 90.03,189.55 90.6,189.55 90.72,189.44 90.72,189.04 90.6,188.93 90.03,188.93 89.78,188.68 89.78,187.32 90.95,186.16 90.95,177.86 101.02,167.79 103.1,167.79 104.65,166.24 106.35,166.24 107.24,165.35 108.83,165.35 110.19,164 110.19,163.83 108.67,162.31 108.67,161.96 109.08,161.55 109.44,161.55 110.96,163.07 111.12,163.07 111.37,162.81 112.89,162.81 v1(113.13,162.58)
USB2_P12_ESD_DN: length 10.9
  TOP w0.1: J7C7.7 83.31,207.26 83.46,207.11 85.65,207.11 89.28,203.48 89.28,202.67 89.38,202.56 89.25,202.43 89.25,202.08 89.35,201.98 89.35,201.55 LP7C3.3
USB2_P12_ESD_DP: length 10.9
  TOP w0.1: J7C7.5 83.31,206.78 83.44,206.91 85.56,206.91 89.08,203.4 89.08,202.73 CR7C7.2 89.05,202.43 89.05,202 89.15,201.9 89.15,201.62 LP7C3.4
USB2_P13_CMC_ESD_DN: length 9.7
  TOP w0.1: L6C3.1 98.67,194.94 98.67,194.38 CR6C3.1 98.67,194.13 98.67,190.55 101.06,188.16 101.06,188.02 100.96,187.92 100.86,187.92 100.76,187.82 J6C3.P19
USB2_P13_CMC_ESD_DP: length 9.7
  TOP w0.1: J6C3.P18 101.56,187.82 101.46,187.92 101.36,187.92 101.26,188.02 101.26,188.24 98.87,190.63 98.87,194.07 CR6C4.1 98.87,194.43 98.87,195.01 L6C3.2
USB2_P13_DN: length 69
  TOP w0.088: 108.94,166.86 108.94,166.85 108.77,166.68 108.77,163.53 107.84,162.6 107.84,158.2 108,158.04 108,157.7 108.23,157.47 U6E1.N3
  TOP w0.1: R6C14.2 98.17,197.42 98.47,197.72 98.47,198.81 104.72,205.05 108.64,205.05 v1(108.81,205.22) ; 108.94,166.86 109.6,167.52 109.6,169.7 112.64,172.75 112.64,173.57 112.54,173.67 v1(112.06,173.67)
  BOTTOM w0.1: v1(112.06,173.67) 112.3,173.92 112.6,173.92 112.82,174.13 112.82,177.93 113.41,178.51 113.41,180.24 111.12,182.53 111.12,185.52 111.37,185.77 111.37,199.01 110.36,200.02 110.36,204.47 109.8,205.03 109,205.03 v1(108.81,205.22)
USB2_P13_DP: length 68.9
  TOP w0.088: U6E1.N2 108.19,157.91 108.19,158.12 108.03,158.28 108.03,162.52 108.96,163.45 108.96,166.6 109.14,166.77
  TOP w0.1: 109.14,166.77 109.8,167.43 109.8,169.62 112.84,172.67 112.84,173.66 112.63,173.87 112.53,173.87 112.06,174.34 v1(112.06,174.47) ; v1(108.81,204.42) 108.81,204.57 108.53,204.85 104.8,204.85 98.67,198.72 98.67,197.68 98.84,197.52 99.21,197.52 99.31,197.42 R6C15.2
  BOTTOM w0.1: v1(112.06,174.47) 112.06,174.27 112.22,174.12 112.52,174.12 112.62,174.22 112.62,178.01 112.68,178.07 113.21,178.6 113.21,180.16 110.92,182.44 110.92,185.6 111.17,185.85 111.17,198.92 110.16,199.94 110.16,204.39 109.72,204.83 109.04,204.83 108.81,204.6 v1(108.81,204.42)
USB2_P14_DN: length 106.2
  TOP w0.1: v1(69.34,221.99) 69.1,221.76 69.1,221.58 68.81,221.29 67.35,221.29 66.9,221.73 66.9,222.45 LP7C1.1 ; U6E1.E5 v1(111.9,155.78)
  LAY6 w0.115: v1(111.9,155.78) 111.9,156.45 111.63,156.72 111.63,158.5 114.65,161.52 114.65,164.41 113.78,165.28 113.78,165.71 112.99,166.5 107.51,166.5 106.64,167.36 105.56,167.36 104.14,168.78 101.39,168.78 91.94,178.23 91.94,187.04 91.67,187.32 91.67,197.71 90.01,199.36 87.12,199.36 86.14,198.38 77.2,198.38 76.33,199.24 75.32,199.24 71.47,203.1 71.47,216.56 69.72,218.31 69.72,220.34 69.11,220.95 69.11,221.77 v1(69.34,221.99)
USB2_P14_DP: length 106.2
  TOP w0.1: U6E1.F6 v1(111.35,156.32) ; LP7C1.2 67.1,222.48 67.1,221.81 67.43,221.49 68.73,221.49 68.9,221.66 68.9,221.84 68.75,221.99 v1(68.52,221.99)
  LAY6 w0.115: v1(68.52,221.99) 68.65,221.99 68.88,221.77 68.88,220.86 69.49,220.25 69.49,218.22 71.24,216.46 71.24,203 75.23,199.01 76.23,199.01 77.1,198.15 86.23,198.15 87.22,199.13 89.91,199.13 91.44,197.61 91.44,187.22 91.71,186.94 91.71,178.13 101.29,168.55 104.04,168.55 105.46,167.13 106.55,167.13 107.41,166.27 112.9,166.27 113.55,165.62 113.55,165.19 114.42,164.31 114.42,161.61 111.4,158.59 111.4,156.87 111.32,156.79 110.99,156.79 110.87,156.67 110.87,156.31 110.97,156.21 111.24,156.21 v1(111.35,156.32)
USB2_P14_M.2_BT_L_DN: length 5.4
  TOP w0.1: J7C1.5 69.05,227.32 68.29,226.57 68.04,226.57 66.83,225.35 66.83,224.64 LP7C1.4
USB2_P14_M.2_BT_L_DP: length 5.4
  TOP w0.1: LP7C1.3 67.2,224.41 67.03,224.58 67.03,225.27 68.12,226.37 68.38,226.37 69.13,227.12 69.33,227.12 69.43,227.02 69.43,226.92 69.53,226.82 J7C1.3
USB2_TTK_DN: length 3.6
  TOP w0.1: J7G1.3 63.28,66.93 62.75,66.39 62.75,66.15 63.11,65.78 63.11,65.15 63.37,64.9
USB2_TTK_DP: length 3.6
  TOP w0.1: J7G1.1 62.01,66.93 62.52,66.42 62.52,66.1 62.91,65.7 62.91,65.2 62.61,64.9
USB2_USBC_BP_CMC_ESD_DN: length 18.7
  TOP w0.1: J4A1.A7 170.37,284.1 170.37,284.84 170.3,284.9 v2(170.3,284.9) ; J4A1.B7 171.1,286.33 v2(171.19,286.42) 171.19,287.54 170.18,288.56 169.03,288.56 168.4,287.92 166.75,287.92 164.91,286.09 164.91,282.24 CR5A3.2 164.95,282.1 164.95,281.24 L5A1.2
  BOTTOM w0.1: v2(171.19,286.42) 170.81,286.81 170.38,286.81 170.18,286.6 170.18,285.03 v2(170.3,284.9)
USB2_USBC_BP_CMC_ESD_DP: length 18.6
  TOP w0.1: J4A1.A6 170.85,284.81 170.94,284.9 v2(170.94,284.9) ; J4A1.B6 170.6,286.38 v2(170.56,286.42) 170.48,286.5 170.48,286.71 170.58,286.81 170.89,286.81 170.99,286.91 170.99,287.46 170.09,288.36 169.12,288.36 168.48,287.72 166.83,287.72 165.11,286 165.11,282.48 165.33,282.25 CR5A4.2 165.15,282.02 165.15,281.75 165.28,281.62 165.34,281.62 165.55,281.41 L5A1.1
  BOTTOM w0.1: v2(170.94,284.9) 171.12,284.9 171.23,285.01 171.23,285.23 171.13,285.33 170.48,285.33 170.38,285.44 170.38,285.95 170.45,286.02 170.71,286.02 170.82,286.13 170.82,286.28 170.67,286.42 v2(170.56,286.42)
USB2_VBUSSENSE: length 26.2
  TOP w0.089: U6E1.F3 111.96,158.16 111.82,158.3 111.82,159.15 112.03,159.36 112.59,159.36 114.72,161.5
  TOP w0.1: R6D45.1 114.68,178.94 R6D48.2 115.73,177.89 116.36,177.89 117.04,177.21 117.04,175.56 R6D53.1 ; 114.72,161.5 114.72,162.38 116.6,164.26 116.6,174.01 117.47,174.88 R6D53.1 ; R6D56.1 R6D53.1
USB31_P1_RX_DN: length 83.6
  TOP w0.089: 113.87,153.66 113.79,153.66 113.78,153.65 113.54,153.65 113.48,153.59 113.05,153.59 112.95,153.69 112.58,153.69 U6E1.D11
  TOP w0.115: v1(127.7,219.56) 127.4,219.86 124.7,219.86 124.58,219.97 121.17,219.97 R6C13.1 ; 113.87,153.66 115.24,153.66 119.4,157.83 119.4,159.15 120.82,160.58 120.82,162.45 v1(120.52,162.75)
  BOTTOM w0.115: v1(120.52,162.75) 120.88,163.1 120.88,165.08 123.92,168.12 123.92,178.03 125.73,179.83 125.73,189.32 125.88,189.47 125.88,197.58 127.4,199.1 127.4,204.66 128.37,205.62 128.37,214.64 127.3,215.71 127.3,217.64 128.22,218.56 128.22,219.76 128.11,219.86 127.92,219.86 127.7,219.65 v1(127.7,219.56)
USB31_P1_RX_DP: length 83.6
  TOP w0.089: U6E1.C11 112.78,153.47 112.89,153.47 112.97,153.39 113.57,153.39 113.63,153.45 113.85,153.45 113.86,153.43 113.87,153.43
  TOP w0.115: v1(121.35,162.75) 121.05,162.45 121.05,160.48 119.63,159.06 119.63,157.73 115.33,153.43 113.87,153.43 ; v1(127.7,220.39) 127.4,220.09 124.79,220.09 124.68,220.2 121.17,220.2 R6C10.1
  BOTTOM w0.115: v1(127.7,220.39) 128,220.09 128.21,220.09 128.45,219.85 128.45,218.47 127.53,217.55 127.53,215.81 128.6,214.74 128.6,205.53 127.63,204.56 127.63,199.01 126.11,197.48 126.11,189.38 125.96,189.23 125.96,179.74 124.15,177.93 124.15,168.03 121.11,164.98 121.11,162.99 v1(121.35,162.75)
USB31_P1_RX_ESD_DN: length 7.5
  TOP w0.115: 120.01,219.71 v1(119.25,219.71)
  BOTTOM w0.115: v1(119.25,219.71) 118.74,220.22 U6C1.10 U6C1.1 117.39,220.22 117.22,220.39 115.51,220.39 115.32,220.59 113.75,220.59 113.51,220.34 J6B5.5
USB31_P1_RX_ESD_DP: length 7.5
  TOP w0.115: 120.01,220.47 v1(119.25,220.47)
  BOTTOM w0.115: v1(119.25,220.47) 119,220.72 U6C1.9 U6C1.2 117.31,220.72 117.22,220.62 115.6,220.62 115.41,220.82 113.75,220.82 113.51,221.06 J6B5.6
USB31_P1_TX_C_DN: length 1.4
  TOP w0.115: R6C9.1 120.89,221.86 121.54,221.86 C6C2.2
USB31_P1_TX_C_DP: length 1.4
  TOP w0.115: C6C1.2 121.63,222.09 120.95,222.09 R6C7.2
USB31_P1_TX_DN: length 82
  TOP w0.115: v1(110.77,154.51) 110.97,154.71 U6E1.F9 ; v1(127.19,221.49) 127.07,221.61 125.92,221.61 125.73,221.81 123.13,221.81 C6C2.1
  BOTTOM w0.115: v1(127.19,221.49) 126.89,221.79 126.73,221.79 126.61,221.67 126.61,199.57 125.24,198.2 125.24,195.61 124.58,194.94 124.58,192.4 125.07,191.92 125.07,180.95 123.29,179.17 123.29,168.38 119.86,164.95 119.86,162.13 119.07,161.34 118.46,161.34 117.09,159.97 117.09,158.42 114.77,156.11 114.12,156.11 113.01,155 111.99,155 111.7,154.71 110.96,154.71 v1(110.77,154.51)
USB31_P1_TX_DP: length 82
  TOP w0.115: U6E1.F7 111.49,155.43 111.33,155.43 v1(111.11,155.22) ; C6C1.1 123.14,222.04 125.82,222.04 126.02,221.84 126.72,221.84 v1(127.19,222.32)
  BOTTOM w0.115: v1(127.19,222.32) 127.19,222.2 127.01,222.02 126.63,222.02 126.38,221.77 126.38,199.67 125.01,198.3 125.01,195.7 124.35,195.04 124.35,192.31 124.84,191.82 124.84,181.04 123.06,179.27 123.06,168.47 119.63,165.04 119.63,162.22 118.97,161.57 118.36,161.57 116.86,160.06 116.86,158.52 114.68,156.34 114.02,156.34 112.92,155.23 111.89,155.23 111.6,154.94 111.22,154.94 111.11,155.05 111.11,155.22 v1(111.11,155.22)
USB31_P1_TX_ESD_DN: length 11.3
  TOP w0.115: R6C9.2 119.83,222.04 119.3,222.04 v1(119.25,221.99)
  BOTTOM w0.115: J6B5.8 113.51,226.55 113.62,226.66 114.33,226.66 115.31,225.68 115.31,223.14 116.58,221.87 117.22,221.87 117.37,221.72 U6C1.4 U6C1.7 118.97,221.72 v1(119.25,221.99)
USB31_P1_TX_ESD_DP: length 11.3
  TOP w0.115: R6C7.1 120.14,222.27 119.73,222.27 v1(119.25,222.76)
  BOTTOM w0.115: v1(119.25,222.76) 118.71,222.22 U6C1.6 U6C1.5 117.34,222.22 117.22,222.1 116.68,222.1 115.54,223.23 115.54,225.77 114.43,226.89 113.87,226.89 113.51,227.25 J6B5.9
USB31_P2_RX_C_DN: length 2
  TOP w0.115: EU3B4.9 220.06,254.4 219.93,254.27 219.93,253.9 219.76,253.73 219.76,253.44 C3B13.1
USB31_P2_RX_C_DP: length 2
  TOP w0.115: C3B12.1 219.53,253.44 219.53,253.82 219.7,253.99 219.7,254.29 219.56,254.42 EU3B4.8
USB31_P2_RX_DN: length 211.2
  TOP w0.089: 115.16,154.84 115.15,154.83 115.13,154.83 115.08,154.79 115.06,154.79 114.78,154.5 113.36,154.5 U6E1.B9
  TOP w0.115: C3B13.2 219.69,251.82 219.69,251.62 219.42,251.36 213.39,251.36 213.04,251.7 213.04,252.03 212.85,252.22 v1(212.7,252.22) ; v1(118.94,162.24) 118.59,161.89 118.59,160.76 117.47,159.64 117.47,157.16 115.16,154.84
  BOTTOM w0.115: v1(118.94,162.24) 118.61,162.56 118.61,164.91 122.42,168.72 122.42,187.7 123.57,188.85 123.57,195.2 124.33,195.96 124.33,199.13 122.93,200.53 122.93,202.31 124.33,203.71 125.34,203.71 125.73,204.09 125.73,222.25 126.49,223.01 126.49,232.79 123.11,236.17 123.11,238.75 130.68,246.32 130.68,248.28 134.25,251.86 148.55,251.86 149.37,252.68 169.86,252.68 171.06,253.87 177.41,253.87 178.84,255.29 179.24,255.29 181.12,257.17 181.88,257.17 182.76,258.05 184.27,258.05 184.81,258.59 188.57,258.59 188.92,258.24 192.29,258.24 192.83,258.78 195.6,258.78 196.06,258.32 197.73,258.32 198.47,259.05 198.47,259.67 199.88,261.07 208.95,261.07 210.05,259.97 211.45,259.97 212.47,258.95 212.47,256.72 213.02,256.16 213.02,252.55 v1(212.7,252.22)
USB31_P2_RX_DP: length 211.1
  TOP w0.089: 114.99,155 114.7,154.71 113.16,154.71 112.92,154.47 U6E1.C9
  TOP w0.115: v1(213.53,252.22) 213.27,251.96 213.27,251.8 213.48,251.59 219.32,251.59 219.46,251.72 219.46,251.96 C3B12.2 ; 114.99,155 117.24,157.25 117.24,159.73 118.36,160.85 118.36,161.99 v1(118.11,162.24)
  BOTTOM w0.115: v1(213.53,252.22) 213.25,252.5 213.25,256.26 212.7,256.82 212.7,259.05 211.55,260.2 210.15,260.2 209.04,261.3 199.78,261.3 198.24,259.77 198.24,259.15 197.64,258.55 196.16,258.55 195.7,259.01 192.73,259.01 192.19,258.47 189.02,258.47 188.67,258.82 184.72,258.82 184.18,258.28 182.66,258.28 181.79,257.4 181.03,257.4 179.15,255.52 178.74,255.52 177.32,254.1 170.96,254.1 169.77,252.91 149.27,252.91 148.45,252.09 134.16,252.09 130.45,248.38 130.45,246.41 122.88,238.84 122.88,236.07 126.26,232.69 126.26,223.11 125.5,222.34 125.5,204.18 125.25,203.94 124.23,203.94 122.7,202.4 122.7,200.44 124.1,199.04 124.1,196.05 123.34,195.29 123.34,188.94 122.19,187.8 122.19,168.82 118.38,165.01 118.38,162.51 v1(118.11,162.24)
USB31_P2_RX_ESD_DN: length 30.6
  TOP w0.115: C3A30.2 220.08,260.82 220.08,261.49 218.11,263.47 218.11,264.69 R3A32.1 218.03,265.73 218.03,266.58 U3A7.5 U3A7.6 218.15,267.64 v1(218.66,268.14)
  BOTTOM w0.115: v1(218.66,268.14) 218.41,267.9 218.41,267.64 217.61,266.84 214.8,266.84 210.2,271.43 210.2,274.48 209.57,275.11 209.57,277.33 210.03,277.79 210.03,278.74 210.64,279.35 211.08,279.35 211.24,279.51 211.24,279.98 211.13,280.1 J3A1.15
USB31_P2_RX_ESD_DP: length 30.6
  TOP w0.115: v1(217.84,268.17) 217.65,267.98 U3A7.7 U3A7.4 217.8,266.55 217.8,265.58 R3A31.1 217.88,264.69 217.88,263.38 219.85,261.4 219.85,261.02 C3A29.2
  BOTTOM w0.115: J3A1.16 211.59,280.1 211.47,279.98 211.47,279.42 211.17,279.12 210.73,279.12 210.26,278.64 210.26,277.7 209.8,277.24 209.8,275.21 210.43,274.57 210.43,271.52 214.89,267.07 217.51,267.07 218.18,267.74 218.18,268.01 218.02,268.17 v1(217.84,268.17)
USB31_P2_RX_RD_DN: length 1.9
  TOP w0.115: EU3B4.30 220.06,258.47 219.96,258.57 219.96,259.36 C3A30.1
USB31_P2_RX_RD_DP: length 1.9
  TOP w0.115: EU3B4.31 219.56,258.4 219.73,258.57 219.73,259.41 C3A29.1
USB31_P2_TX_C_DN: length 3.6
  TOP w0.115: EU3B4.5 218.06,254.51 217.93,254.38 217.93,254.13 218.44,253.62 218.44,252.6 218.18,252.35 217.8,252.35 C3B19.2
USB31_P2_TX_C_DP: length 3.6
  TOP w0.115: C3B16.2 217.43,252.87 217.43,252.71 217.56,252.58 218.09,252.58 218.21,252.7 218.21,253.52 218.02,253.71 217.7,254.03 217.7,254.38 217.56,254.52 EU3B4.4
USB31_P2_TX_CMC_DN: length 4.8
  TOP w0.115: C3A28.2 217.95,260.93 217.95,261.72 216.26,263.41 216.26,264.25 R3A30.2
USB31_P2_TX_CMC_DP: length 4.8
  TOP w0.115: R3A42.1 216.03,264.27 216.03,263.31 217.72,261.62 217.72,260.93 C3A27.2
USB31_P2_TX_DN: length 205.6
  TOP w0.115: U6E1.C3 v1(112.42,157.69) ; v1(214.98,253.24) 215.28,252.94 215.28,252.68 215.54,252.42 216.33,252.42 C3B19.1
  BOTTOM w0.115: v1(214.98,253.24) 215.08,253.24 215.28,253.04 215.28,252.77 215.17,252.66 214.82,252.66 214.24,253.24 214.24,258.77 210.85,262.17 199.43,262.17 197.97,260.71 194.72,260.71 194.4,260.39 192.82,260.39 191.76,259.33 189.62,259.33 189.18,259.77 184.38,259.77 183.81,259.2 182.19,259.2 181.29,258.29 180.7,258.29 178.82,256.41 175.51,256.41 174.75,255.65 171.25,255.65 169.47,253.87 149.03,253.87 148.11,252.95 133.2,252.95 128.17,247.93 128.17,245.5 122.03,239.36 122.03,235.66 125.37,232.31 125.37,223.49 124.64,222.76 124.64,217.05 123.69,216.1 123.69,214.18 124.61,213.26 124.61,210.15 123.59,209.14 123.59,207.87 123.06,207.33 123.06,204.16 121.84,202.94 121.84,199.04 122.19,198.68 122.19,191.23 121.28,190.32 121.28,174.37 117.22,170.31 117.22,163.52 113.86,160.16 113.86,158.34 112.85,157.33 112.51,157.33 112.42,157.42 v1(112.42,157.69)
USB31_P2_TX_DP: length 205.6
  TOP w0.115: v1(215.81,253.24) 215.51,252.94 215.51,252.77 215.64,252.65 216.33,252.65 C3B16.1 ; U6E1.D4 v1(112.1,156.99)
  BOTTOM w0.115: v1(215.81,253.24) 215.51,252.94 215.51,252.68 215.26,252.43 214.73,252.43 214.01,253.14 214.01,258.67 210.75,261.94 199.52,261.94 198.06,260.48 194.82,260.48 194.5,260.16 192.92,260.16 191.86,259.1 189.53,259.1 189.09,259.54 184.48,259.54 183.91,258.97 182.29,258.97 181.38,258.06 180.79,258.06 178.91,256.18 175.6,256.18 174.84,255.42 171.34,255.42 169.56,253.64 149.13,253.64 148.2,252.72 133.29,252.72 128.4,247.83 128.4,245.41 122.26,239.26 122.26,235.75 125.6,232.41 125.6,223.39 124.87,222.66 124.87,216.95 123.92,216 123.92,214.27 124.84,213.36 124.84,210.06 123.82,209.04 123.82,207.77 123.29,207.24 123.29,204.06 122.07,202.84 122.07,199.13 122.42,198.78 122.42,191.13 121.51,190.22 121.51,174.27 117.45,170.21 117.45,163.42 114.09,160.07 114.09,158.25 112.94,157.1 112.21,157.1 v1(112.1,156.99)
USB31_P2_TX_ESD_DN: length 20.5
  TOP w0.115: R3A30.1 216.3,265.18 216.3,265.89 216.52,266.11 216.52,266.57 U3A7.2 U3A7.9 216.53,267.59 216.53,269.87 217.45,270.79 217.45,273.51 v1(217.75,273.81)
  BOTTOM w0.115: v1(217.75,273.81) 217.45,273.51 217.45,273.13 217.13,272.82 216.43,272.82 216.05,273.21 216.05,274.41 216.43,274.79 216.43,275.69 215.67,276.45 215.67,277.33 217.34,279.01 217.34,279.56 216.8,280.1 J3A1.18
USB31_P2_TX_ESD_DP: length 20.5
  TOP w0.115: v1(216.91,273.81) 217.22,273.51 217.22,270.88 216.3,269.97 216.3,267.62 U3A7.10 U3A7.1 216.29,266.56 216.29,266.21 216.07,265.98 216.07,265.22 R3A42.2
  BOTTOM w0.115: J3A1.19 217.68,280.1 217.57,279.98 217.57,278.91 215.9,277.24 215.9,276.55 216.66,275.79 216.66,274.7 216.28,274.32 216.28,273.3 216.53,273.05 217.04,273.05 217.22,273.23 217.22,273.51 v1(216.91,273.81)
USB31_P2_TX_RD_DN: length 1.9
  TOP w0.115: C3A28.1 217.94,259.37 217.94,258.46 218.06,258.34 EU3B4.34
USB31_P2_TX_RD_DP: length 1.9
  TOP w0.115: C3A27.1 217.71,259.4 217.71,258.48 217.56,258.33 EU3B4.35
USB31_P3_RX_C_DN: length 2.2
  TOP w0.115: EU3B4.16 223.56,254.41 223.69,254.28 223.69,254.01 224.2,253.51 224.2,253.26 224.2,253.26 224.05,253.11 C3B14.1
USB31_P3_RX_C_DP: length 2.2
  TOP w0.115: EU3B4.17 224.06,254.42 223.92,254.28 223.92,254.1 224.43,253.6 224.43,253.35 224.67,253.11 C3B15.1
USB31_P3_RX_DN: length 217.8
  TOP w0.115: v1(226.26,252.13) 226.03,251.9 226.03,251.64 225.78,251.39 224.51,251.39 224.25,251.65 224.25,251.86 C3B14.2 ; v1(118.8,158.92) 118.52,159.2 118.22,159.2 118.11,159.09 118.11,156.99 115.06,153.95 113.38,153.95 U6E1.B10
  BOTTOM w0.115: v1(118.8,158.92) 119,159.13 119.76,159.13 120.26,159.64 120.26,160.11 121.23,161.08 121.97,161.08 123.14,162.26 123.14,163.34 124.56,164.75 124.56,166.01 125.88,167.33 125.88,177.18 128.65,179.95 128.65,188.59 127.88,189.36 127.88,190.78 128.65,191.54 128.65,196.85 129.41,197.61 129.41,203.45 130.35,204.39 130.35,220.4 129.53,221.22 129.53,227.08 128.27,228.34 128.27,234.44 127.25,235.46 127.25,240.29 132.7,245.74 133.73,245.74 138.11,250.13 146.74,250.13 147.44,249.43 155.7,249.43 157.22,250.95 170.72,250.95 171.86,252.09 179.34,252.09 181.83,254.59 182.99,254.59 183.59,255.18 183.59,255.63 184.25,256.29 191.83,256.29 192.23,255.89 195.31,255.89 195.96,256.54 198.57,256.54 200.2,258.17 200.2,258.9 200.66,259.36 208.12,259.36 209.7,257.78 209.7,254.03 210.88,252.85 210.88,251.7 211.93,250.65 219.36,250.65 220.18,249.83 222.32,249.83 223.13,250.65 225.12,250.65 226.03,251.56 226.03,251.9 v1(226.26,252.13)
USB31_P3_RX_DP: length 217.8
  TOP w0.115: v1(225.47,252.13) 225.69,252.13 225.8,252.01 225.8,251.73 225.69,251.62 224.61,251.62 224.48,251.74 224.48,251.92 C3B15.2 ; v1(118.8,159.75) 118.8,159.73 118.5,159.43 118.12,159.43 117.88,159.18 117.88,157.09 114.96,154.18 112.91,154.18 U6E1.C10
  BOTTOM w0.115: v1(118.8,159.75) 118.8,159.52 118.96,159.36 119.66,159.36 120.03,159.73 120.03,160.21 121.14,161.31 121.87,161.31 122.91,162.35 122.91,163.43 124.33,164.84 124.33,166.1 125.65,167.42 125.65,177.27 128.42,180.04 128.42,188.5 127.65,189.26 127.65,190.87 128.42,191.63 128.42,196.94 129.18,197.71 129.18,203.55 130.12,204.48 130.12,220.3 129.3,221.12 129.3,226.99 128.04,228.25 128.04,234.35 127.02,235.36 127.02,240.39 132.6,245.97 133.63,245.97 138.02,250.36 146.84,250.36 147.54,249.66 155.6,249.66 157.13,251.18 170.62,251.18 171.76,252.32 179.24,252.32 181.73,254.82 182.9,254.82 183.36,255.27 183.36,255.72 184.15,256.52 191.92,256.52 192.32,256.12 195.21,256.12 195.86,256.77 198.47,256.77 199.97,258.27 199.97,258.99 200.56,259.59 208.22,259.59 209.93,257.88 209.93,254.13 211.11,252.94 211.11,251.8 212.03,250.88 219.46,250.88 220.27,250.06 222.22,250.06 223.04,250.88 225.02,250.88 225.8,251.66 225.8,252.01 225.69,252.13 v1(225.47,252.13)
