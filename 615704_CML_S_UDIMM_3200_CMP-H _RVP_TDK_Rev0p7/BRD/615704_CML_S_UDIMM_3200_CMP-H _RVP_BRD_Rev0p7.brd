# Allegro board 615704_CML_S_UDIMM_3200_CMP-H _RVP_BRD_Rev0p7.brd (continued)
## Nets (continued)
S4_LED_DRV: DS8H5.2(C) EU8H1.11
S5_LED_DRV: DS8H4.2(C) EU8H1.10
S_RAILS_PWRGD: C8D3.1 Q8D3.1 Q8D4.1 R8D11.1 R8D12.1
SA_SET1_H: R5B81.1 R5M12.2(B)
SA_SET1_L: R5B84.2(B) R5B86.1
SA_SET2_H: R5B78.1 R5M11.2(B)
SA_SET2_L: R5B77.2(B) R5M7.1
SA_SET3_H: R5B75.1 R5B76.2(B)
SA_SET3_L: R5B74.2(B) R5M9.1
SA_TSEN_H: R5B57.1 R5B61.2(B)
SA_TSEN_L: R5B62.2(B) R5B68.1
SATA1B_DIRECT_RX_DN: C5W3.2(B) J5J2.5
SATA1B_DIRECT_RX_DP: C5W4.2(B) J5J2.6
SATA1B_DIRECT_TX_CMC_DN: J5J2.3 R5W1.2(B) U5W1.4(P4)
SATA1B_DIRECT_TX_CMC_DP: J5J2.2 R5W2.1 U5W1.3
SATA1B_DIRECT_TX_DN: C5W2.2(B) R5W1.1 U5W1.1
SATA1B_DIRECT_TX_DP: C5W1.2(B) R5W2.2(B) U5W1.2
SATA1B_RX_DN: C6G12.2(B) J6H1.5
SATA1B_RX_DP: C6G11.2(B) J6H1.6
SATA1B_RX_R_DN: C5W3.1 R6G10.2(B)
SATA1B_RX_R_DP: C5W4.1 R6G9.2(B)
SATA1B_TX_CMC_DN: J6H1.3 L6G3.3 R6G11.2(B)
SATA1B_TX_CMC_DP: J6H1.2 L6G3.4(P4) R6G13.1
SATA1B_TX_DN: C6G9.2(B) L6G3.2 R6G11.1
SATA1B_TX_DP: C6G10.2(B) L6G3.1 R6G13.2(B)
SATA1B_TX_R_DN: C5W2.1 R6G5.2(B)
SATA1B_TX_R_DP: C5W1.1 R6G6.2(B)
SATA2_RX_DN: C6G8.2(B) J6G2.5
SATA2_RX_DP: C6G7.2(B) J6G2.6
SATA2_TX_CMC_DN: J6G2.3 L6G2.3 R6G4.2(B)
SATA2_TX_CMC_DP: J6G2.2 L6G2.4(P4) R6G8.1
SATA2_TX_DN: C6G5.2(B) L6G2.2 R6G4.1
SATA2_TX_DP: C6G6.2(B) L6G2.1 R6G8.2(B)
SATA3_RX_DN: C6G4.1 J6G1.5
SATA3_RX_DP: C6G3.1 J6G1.6
SATA3_TX_CMC_DN: J6G1.3 L6G1.3 R6G1.2(B)
SATA3_TX_CMC_DP: J6G1.2 L6G1.4(P4) R6G3.1
SATA3_TX_DN: C6G1.2(B) L6G1.2 R6G1.1
SATA3_TX_DP: C6G2.2(B) L6G1.1 R6G3.2(B)
SATA_DIRECT_DEVSLP: J5J2.10 R7T12.2(B)
SD3_CD_R_N: CR9C1.1 J9D1.10 R9C14.2(B) R9C15.2(B) R9C16.2(B)
SD3_CDB: R9C16.1 U6E1.BE8
SD3_CLK: R9C21.1 U6E1.BD8
SD3_CLK_R: CR9C4.1(C) J9D1.5 R9C21.2(B) R9C22.1
SD3_CMD: R9D1.1 U6E1.AW13
SD3_CMD_R: CR9D1.1(C) J9D1.3 R9D1.2(B)
SD3_D0: R9C20.1 U6E1.BE9
SD3_D0_R: CR9C3.1(C) J9D1.7 R9C20.2(B)
SD3_D1: R9C19.1 U6E1.BF8
SD3_D1_R: CR9C2.1(C) J9D1.8 R9C19.2(B)
SD3_D2: R9D3.1 U6E1.BF9
SD3_D2_R: CR9D3.1(C) J9D1.1 R9D3.2(B)
SD3_D3: R9D2.1 U6E1.BG8
SD3_D3_R: CR9D2.1(C) J9D1.2 R9D2.2(B)
SD3_RCOMP_1P8: R7R7.1 U6E1.BE5
SD3_RCOMP_3P3: R7R6.1 U6E1.BE4
SD3_WP: R9C12.2(B) R9C13.1 R9C17.2(B) U6E1.AV13
SD_PWR_EN_N: Q8D2.1 R7E48.1 R7R63.2(B) R8D9.1
SD_PWR_EN_R: Q8D2.3 R8D7.2(B) R8D9.2(B) U8C6.2
SD_VDD1_PWR_EN_N_ISH_GP_7: R7R63.1 R8H25.1 U6E1.BD38
SD_VDD2_PWR_EN_N: R7E48.2(B) U6E1.BE36
SER_CTS_N: FB9C2.1 U9C1.8
SER_CTS_N_FB: FB9C2.2(B) J9B7.6
SER_RTS_N: FB9C1.1 U9C1.7
SER_RTS_N_FB: FB9C1.2(B) J9B7.4
SER_RX_IN: FB9B2.1 U9C1.13
SER_RX_IN_FB: FB9B2.2(B) J9B7.3
SER_TX_OUT: FB9B1.1 U9C1.14
SER_TX_OUT_FB: FB9B1.2(B) J9B7.5
SERIRQ_ESPI_ALERT0_EC: R7U2.2(B) R7U3.2(B) U8F6.55
SERIRQ_ESPI_CS1_HDR_N: J7J1.16 R7U6.2(B)
SERIRQ_ESPI_CS1_MECC_N: J6J2.179 R7U7.2(B)
SERIRQ_ESPI_CS1_N: R7T6.2(B) R7T7.2(B) R7U3.1 R7U6.1 R7U7.1 U6E1.AW35
SERIRQ_TPM_R: J7G1.46 J7G2.16 R7G34.1 R7G36.1
SET1_H: R2B40.2(B) R2B42.1
SET1_L: R2B41.1 R2B46.2(B)
SET2_H: R2B45.2(B) R2B48.1
SET2_L: R2B47.1 R2B50.2(B)
SET3_H: R2B61.2(B) R2B62.1
SET3_L: R2B59.1 R2B60.2(B)
SET4_H: R2C2.2(B) R2C3.1
SET4_L: R2C4.1 R2C5.2(B)
SET5_H: R2C14.1 R2C19.2(B)
SET5_L: R2C11.2(B) R2C16.1
SHM_TRIG_PLT_RST_R: J7J1.5 R7W3.2(B) R7W4.2(B) R9G7.2(B)
SLEEVE_CONN: C5A7.1 FB5A4.2(B) J5A1.6
SLEEVE_FB_CONN: FB5A4.1 R5A9.2(B) R5A15.2(B)
SLG_OUT_SMC_INITCLK_J: EU8F1.6 R9F1.1
SLG_OUT_SMC_RST_N: EU8F1.7 R9F2.1
SLOT2_WAKE_N: J7B1.B11(WAKE_N) R7B65.1 R8B24.1
SLOT3_LAN_WAKE_N: J8B1.B30 R7B24.2(B)
SLOT3_LANPHYPC: J8B1.A32 R8C30.1 R8C32.1
SLOT3_SLP_LAN_N_R: J8B1.A19 R8C10.1
SLOT3_SMBCLK: J8B1.B5 R8B15.2(B) R8B18.2(B)
SLOT3_SMDAT: J8B1.B6 R9B26.2(B) R9B29.2(B)
SLOT3_WAKE_N: J8B1.B11(WAKE_N) R8B19.1 R8B21.1 R8B22.1
SLOTM_EN: R8G70.2(B) U8G3.2
SLP_A_EC_N: J6J2.128 R8E17.2(B) U8E3.9
SLP_LAN_N: C7E14.1 R4B6.1 R6A41.1 R6J20.2(B) R7E51.1 R8C10.2(B) U6E1.BF40
SLP_LAN_N_SLG: EU4B2.2 R4B6.2(B)
SLP_M_N_PULLUP: J8J10.3(IO3) R8J23.2(B)
SLP_S0_EC_N: J6J2.90 J6J2.194 R7E28.2(B) R9F22.2(B) U8F6.33
SLP_S0_LED_D: DS7H1.1 R7H69.2(B)
SLP_S0_LED_DRV: DS7H1.2(C) EU8H2.3
SLP_S0_N: EU8H2.2 J8J13.32 R2A56.1 R7E26.1 R7E28.1 R7E31.1 R7G30.2(B) R8D64.1 R8D70.1 R8D71.1 TP8D2.1(TP) U8D8.3
SLP_S0_PLT_EC_N: R9G1.1 U8F6.51
SLP_S0_PLT_N: R8D70.2(B) R8D78.2(B) R9G1.2(B) U3A4.2 U5C2.6 U8C1.6 U8C3.6 U8D11.6 U8N1.6
SLP_S0_PLT_N_R: R8D78.1 U8D8.4(Y)
SLP_S3_AIC: J6J1.16 R6H45.1
SLP_S3_APS_N: J9H3.2 R9H13.1
SLP_S3_EC_N: J6J2.55 R8G3.2(B) U8F6.113
SLP_S3_LAN_RR_N: Q8C6.1 R8C53.2(B) R8C54.1
SLP_S3_N: J8J11.2 J9J5.1 Q8C9.5 Q8D6.1 R2G19.1 R2G32.1 R6A21.1 R6A26.1 R7E58.2(B) R8C52.1 R8C53.1 R8C58.1 R8C65.1 R8D76.1 R8D80.1 R8D93.1 R8D98.1 R9H13.2(B) U8D9.1
SLP_S3_N_1P8S: R8D22.2(B) U8D2.2
SLP_S3_N_AUX: R8D76.2(B) U8D5.1
SLP_S3_N_PULLUP: J8J11.3(IO3) R8J24.2(B)
SLP_S3_N_XSTR_PIN1: Q4J1.1 R4J6.2(B) R4J7.1 R4J8.2(B)
SLP_S3_N_XSTR_PIN1_R: J4J3.2(IO2) R4J6.1
SLP_S3_N_XSTR_Q19LH_PIN3: Q8C10.5 Q8C10.6 R8C63.2(B)
SLP_S3_N_XSTR_Q19LH_PIN5: C8C20.1 Q8C10.2 R8C65.2(B)
SLP_S3_N_XSTR_Q19LH_PIN6: Q8C10.3 R8C66.1
SLP_S3_PCH_N: C8H18.1 EU8H1.2 J5J1.15 J8J13.9(IO9) J9J5.2(IO2) Q8H4.3 R5A43.2(B) R6H45.2(B) R7E58.1 R7H9.1 R8D22.1 R8G3.1 R8H40.1 R9B6.1 U6E1.BF42
SLP_S4_APS_N: J9H3.5 R9H18.2(B)
SLP_S4_EC_N: J6J2.71 R8G1.2(B) U8F6.114
SLP_S4_N: C8H19.1 EU8H1.3 J8J7.2 J8J13.11 Q8H6.3 R6H47.2(B) R7H10.1 R8D97.1 R8D99.1 R8G1.1 R8H45.1 R9H18.1 U2G2.10 U6E1.BE42
SLP_S4_N_PULLUP: J8J7.3(IO3) R8J20.2(B)
SLP_S5_EC_N: J6J2.39 R9G16.2(B) U8F6.71
SLP_S5_PCH_N: C8H20.1 EU8H1.4 J8J13.5 R5L1.2(B) R6H46.2(B) R7G31.2(B) R8H49.1 R9G16.1 U6E1.BC42
SLP_S5_S4_AIC: J6J1.18 R6H46.1 R6H47.1
SLP_SUS_EC_N: C8F19.1 J6J2.98 J8J13.22 R8F52.2(B) U8F6.120
SLP_SUS_FET2_EC: J6J2.141 R6J15.1
SLP_SUS_FET_EC: J6J2.149 R5J7.1
SLP_SUS_N: C8H21.1 CR8D1.3(C) CR8F4.3(C) EU8H1.5 J8J4.1 J8J13.33 Q8H7.3 R4H12.1 R4H22.1 R5G9.1 R6A22.1 R6A27.1 R6J3.1 R6J4.1 R8D36.2(B) R8D45.1 R8D89.1 R8E28.1 R8E44.1 R8F44.1 R8F52.1 R8H53.1 R9B5.1 TP7F1.1(TP) U6E1.BD39
SLP_SUS_N_EV: J8J4.2(IO2) R8J9.2(B)
SLP_WLAN_N: C7F1.1 R6J12.2(B) R7B1.1 R7F3.1 U6E1.BD42
SLP_WLAN_N_R: Q7B1.2 Q7B6.1 R7B1.2(B)
SLTA_MAIN_PWR_EN: J5J1.1 R5H6.2(B) R5V6.2(B)
SLTB_MAIN_PWR_EN: J5J1.2 R5H11.2(B) R5V5.2(B) R6H36.2(B)
SLTC_MAIN_PWR_EN: J5J1.9(IO9) R5V2.2(B) R6H5.2(B)
SLTD_MAIN_PWR_EN: J5J1.10 R5H11.1
SMB_CLK_EC: J6J2.184 J7G1.16 J8J13.6 R2C24.1 R4H54.2(B) R8G10.2(B) U8E3.22 U8F6.97 U8L1.2 U8L2.6
SMB_CLK_MAIN: J1C1.53 J1E5.141 J1F1.141 J1F2.141 J1F3.141 J7J1.13 Q7B9.2(S) R2A42.1 R4H53.2(B) R7B73.1 R7J13.1 U2G3.5
SMB_CLK_MAIN_FRU: J8J13.37 R7J12.2(B) R7J13.2(B) U8J2.6
SMB_CLK_RESUME: C7E13.2(B) J5B2.B5 J7B1.B5 J9F6.1 Q7B9.3 R7B76.1 R7E24.1 R7H13.1 R8B18.1
SMB_CLK_RESUME_R: R7E24.2(B) U6E1.BE26
SMB_CLK_TTK: J7G1.27 R7H13.2(B)
SMB_DATA_EC: J6J2.192 J7G1.14 J8J13.4 R2C25.1 R4J3.2(B) R8G14.2(B) U8E3.23 U8F6.96 U8L1.1 U8L2.5
SMB_DATA_MAIN: J1C1.51 J1E5.285 J1F1.285 J1F2.285 J1F3.285 J7J1.14 Q7B10.2(S) R2A40.1 R4J1.2(B) R7C1.1 R7J15.1 U2G3.4
SMB_DATA_MAIN_FRU: J8J13.35 R7J14.2(B) R7J15.2(B) U8J2.5
SMB_DATA_RESUME: C7E11.2(B) J5B2.B6 J7B1.B6 J9F6.3(IO3) Q7B10.3 R7B81.2(B) R7E23.1 R7H12.1 R9B29.1
SMB_DATA_RESUME_R: R7E23.2(B) U6E1.BF26
SMB_DATA_TTK: J7G1.25 R7H12.2(B)
SMB_HDMI_CLK: EU2A7.29 R2A39.2(B) R2A42.2(B)
SMB_HDMI_DATA: EU2A7.28 R2A38.2(B) R2A40.2(B)
SMB_THRM_CK: J6J2.72
SMB_THRM_DATA: J6J2.80
SMB_USBC_CLK_EC: J6J2.89 Q8G2.3 R8G23.2(B) U8F6.91
SMB_USBC_DATA_EC: J6J2.97 Q8G3.3 R8G22.2(B) U8F6.89
SMC_RST_EC_N: C8F10.1 J6J2.70 J9F4.1 R8F25.2(B) R9F10.1 U8F6.13
SMC_RST_N: R9F2.2(B) R9F10.2(B)
SMC_RUNTIME_SCI_EC_N: J6J2.103 R6F32.1 U8F6.41
SMC_RUNTIME_SCI_N: R6F12.2(B) R6F32.2(B) U6E1.U47
SMC_SHUTDOWN: J6J2.143 R6J4.2(B)
SMC_WAKE_SCI_N: J6J2.111 J8J13.19 Q9F1.2(SRC) R9F35.1 R9F36.2(B) U8F6.45
SML0_CLK: R4A23.1 R5B11.1 R5B12.1 R8J15.2(B) R8J16.1 U6E1.BF25
SML0_CLK_FOX_LAN: EU7A3.11 R5B12.2(B) R7B14.2(B) R8B15.1
SML0_CLK_LAN: EU4B1.28 R4A23.2(B)
SML0_CLK_TR: R5A39.1 R5B11.2(B)
SML0_DATA: R4B1.1 R5B9.1 R5B10.1 R8J17.2(B) R8J18.1 U6E1.BE24
SML0_DATA_FOX_LAN: EU7A3.10 R5B9.2(B) R7B13.2(B) R7M2.1 R9B26.1
SML0_DATA_LAN: EU4B1.31 R4B1.2(B)
SML0_DATA_TR: R5B10.2(B) R5L12.1
SML1_CLK: J8J13.14 R8J8.2(B) R8J13.1 R8J14.1 U6E1.BF27
SML1_CLK_EC: J6J2.168 R8J13.2(B) U8F6.9
SML1_CLK_HDR: J8J8.1 R8J14.2(B)
SML1_DATA: J8J13.12 R8J10.2(B) R8J12.1 R8J21.1 U6E1.BE27
SML1_DATA_EC: J6J2.160 R8J12.2(B) U8F6.8
SML1_DATA_HDR: J8J8.3(IO3) R8J21.2(B)
SMLINK0_CLK_HDR: J8J12.1 R8J16.2(B)
SMLINK0_DATA_HDR: J8J12.3(IO3) R8J18.2(B)
SNDW1_CLK_HDR: J9A1.2(IO2) R9A7.2(B)
SNDW1_DATA_HDR: J9A1.1 R9A6.2(B)
SNDW2_CLK: EU6A1.9 R9A18.2(B)
SNDW2_DATA: EU6A1.8 R8C27.2(B)
SOC_DMIC0_SDW3_DATA: R7R19.2(B) R8B12.1
SOC_DMIC0_SDW4_CLK: C7E7.1 C7E9.1 C8B1.1 C9D1.1 R7E15.1 R7E18.2(B) R8B3.1
SOC_DMIC0_SDW4_DATA: C7E5.1 C7E6.1 C9D2.1 R7E17.2(B) R9B9.1
SOC_DMIC1_SDW3_CLK: C7R1.1 R7R8.1 R7R16.2(B) R8B17.1
SPD_PRSNT: J9G2.2(IO2) R9G6.1 U8E3.7
SPD_PRSNT_PU: J9G2.1 R9G5.2(B)
SPI1_TCHPNL_CLK: R9D20.2(B) U6E1.BE19
SPI1_TCHPNL_CS_N: R9D26.1 U6E1.BF19
SPI1_TCHPNL_IO2: R9D28.2(B) U6E1.BD17
SPI1_TCHPNL_IO2_R: C9D8.1 J9D2.8 R9D28.1
SPI1_TCHPNL_IO3: R9D30.2(B) U6E1.BC17
SPI1_TCHPNL_IO3_R: C9D9.1 J9D2.9(IO9) R9D30.1
SPI1_TCHPNL_MISO: R9D6.2(B) U6E1.BE18
SPI1_TCHPNL_MOSI: R9D5.2(B) U6E1.BF18
SPI_CLK: R7G7.1 U6E1.AW47 U7G1.12
SPI_CLK_EC: R9U9.2(B) U7U1.2
SPI_CLK_FLASH: EU7G3.6 R7G8.1 U7G4.16
SPI_CLK_PCON: R2A66.1 U2B1.6 U3A5.D2
SPI_CLK_SW: R7G8.2(B) R7G9.1 U7G1.11 U7U1.3
SPI_CLK_TPM: J7G1.37 J7G2.7 R7G9.2(B)
SPI_CS0_EC_N: R9U7.2(B) U7U1.9
SPI_CS0_FLASH_N: EU7G3.1 R7G10.1 U7G4.7
SPI_CS0_N: U6E1.AY47 U7G1.5
SPI_CS0_SW_N: R7G10.2(B) R7G12.2(B) U7G1.6 U7U1.8
SPI_CS0_TPM_N: J7G1.32 J7G2.2 R7G12.1
SPI_CS1_N: R7G33.2(B) U6E1.AW48
SPI_CS1_TPM_N: J7G1.34 J7G2.4 R7G33.1
SPI_CS2_N: R7H16.1 U6E1.AT40
SPI_CS2_TPM_N: J7G1.43 J7G2.13 R7H16.2(B) R7H19.2(B)
SPI_CSN_PCON: R2A62.2(B) U2B1.1 U3A5.C1
SPI_DI_PCON: U2B1.2 U3A5.C2
SPI_DO_PCON: U2B1.5 U3A5.D1
SPI_DQ2_TPM: J7G1.38 J7G2.8 R7G24.1
SPI_DQ3_TPM: J7G1.39 J7G2.9(IO9) R7G17.2(B)
SPI_HOLD0_FLASH_N: EU7G3.7 R7G16.2(B) U7G4.1
SPI_HOLD_PCON: R2A60.2(B) U2B1.7
SPI_HOLD_TPM_N: J7G1.41 J7G2.11 R7H15.2(B)
SPI_IO2: R7F33.2(B) R7F34.2(B) R7F39.1 U6E1.AY48 U7G2.5
SPI_IO2_EC: R9U3.2(B) U7U2.9
SPI_IO2_SW: R7G19.1 R7G24.2(B) R7U35.2(B) U7G2.6 U7U2.8
SPI_IO3: R7F31.2(B) R7F38.1 U6E1.BA46 U7G2.2
SPI_IO3_EC: R9U1.2(B) U7U2.12
SPI_IO3_SW: R7G16.1 R7G17.1 R7U33.2(B) R7U34.1 U7G2.3 U7U2.11
SPI_MISO: R7F32.2(B) U6E1.BA45 U7G2.9
SPI_MISO_EC: R9U6.2(B) U7U2.5
SPI_MISO_FLASH: EU7G3.2 R7G20.2(B) U7G4.8
SPI_MISO_SW: R7G20.1 R7G21.2(B) U7G2.8 U7U2.6
SPI_MISO_TPM: J7G1.40 J7G2.10 R7G21.1
SPI_MOSI: R7T14.2(B) R7T15.2(B) R7T17.1 U6E1.AU41 U7G1.9
SPI_MOSI_EC: R9U12.2(B) U7U1.5
SPI_MOSI_FLASH: EU7G3.5 R7G11.2(B) U7G4.15
SPI_MOSI_SW: R7G11.1 R7G13.2(B) U7G1.8 U7U1.6
SPI_MOSI_TPM: J7G1.42 J7G2.12 R7G13.1
SPI_TPM_GPIO: R8E3.1 R8G57.2(B) R8G62.2(B)
SPI_TPM_GPIO_LT: R7H14.1 R8G57.1 R8G83.1
SPI_TPM_GPIO_R1: EU8G3.3 R8G76.1 R8G83.2(B)
SPI_TPM_GPIO_R2: EU8G3.14 R8G62.1
SPI_TPM_GPIO_RST_N: J7G1.33 J7G2.3 R7H14.2(B)
SPI_TPM_PIRQ: R8G52.2(B) R8G58.2(B) R8G63.2(B) U6E1.T45
SPI_TPM_PIRQ_LT: R7H17.1 R8G58.1 R8G84.1
SPI_TPM_PIRQ_LT_R: J7G1.47 J7G2.17 R7H17.2(B)
SPI_TPM_PIRQ_R1: EU8G3.4 R8G77.1 R8G84.2(B)
SPI_TPM_PIRQ_R2: EU8G3.13 R8G63.1
SPI_WP0_FLASH_N: EU7G3.3 R7G19.2(B) U7G4.9(WP_N_IO2)
SPI_WP_TPM_N: J7G1.45 J7G2.15 R7H2.1 R7H20.2(B)
SPI_WPN_PCON: J2A2.2(IO2) R2A67.1 U2B1.3(WP_IO2_N) U3A5.E2
SPI_WPN_PCON_J: J2A2.1 R2A35.2(B)
SPKR_OUT: J9G7.1 Q9G5.2(E) R9G30.1
SPKR_PD_N: J9A5.8 R8A30.2(B)
SRAIL_DIS_GATE: J4J1.1 Q3G2.5 Q4H2.2 Q4H2.5 R4H23.1
SRCCLKREQ0_WLAN_N: R7B29.1 R7E35.1 U6E1.BF31
SRCCLKREQ1_LAN_N: R4B15.1 R7E40.2(B) U6E1.BE31
SRCCLKREQ2_M.2_SSD_N: R8G73.1 R8G81.2(B) U6E1.AR32
SRCCLKREQ3_CPU_SSD_N: R5C9.1 R5C12.1 U6E1.BB30
SRCCLKREQ4_PCIEX4_SLOT3_N: Q8C1.3 R8C11.2(B) R8C12.1 U6E1.BA30
SRCCLKREQ5_PCIEX4_SLOT2_N: Q8C2.3 R8C8.2(B) R8C9.1 U6E1.AN29
SRCCLKREQ6_TR_N: R6F23.2(B) U5A2.Y6
SRCCLKREQ6_TR_U2_N: R6F7.2(B) R6F23.1 R6F24.1 U6E1.AE47
SRCCLKREQ6_U2_N: R5G22.1 R5G23.1 R6F24.2(B)
SRCCLKREQ7_PCIEX16_N: Q6C1.3 R5B19.2(B) R5B20.2(B) R5C6.1 U6E1.AC48
SRCCLKREQ8_FOX_N: R7B11.1 R7B21.2(B) U6E1.AE41
SRCCLKREQ9_2ND_PCIEX16_N: Q5B1.3 R5B23.2(B) R5B25.1 U6E1.AF48
SRCCLKREQ9_PEG_N: J5B2.A6 Q5B1.2(S) R5B25.2(B)
SRCCLKREQ10_3RD_PCIEX16_N: Q5D2.3 R5E2.1 R5E3.2(B) U6E1.AC41
SRCCLKREQ10_PEG_N: J5B2.B82 Q5D2.2(S) R5E2.2(B)
SRCCLKREQ14_M.2_SSD_2ND_N: R8G72.1 R8G78.2(B) U6E1.AC44
SSD_CPU_PCIE_CLKREQ_N: J5B3.52 R5C12.2(B)
SSD_CPU_PE_WAKE_N: J5B3.54 R5C13.2(B)
SSD_PCIE_CLKREQ2_N: J8H1.6 R8G72.2(B)
SSD_PCIE_CLKREQ_N: J8H1.52 R8G73.2(B)
SSD_PE_WAKE_N: J8H1.54 R8G79.1
SSD_PERST_N: J8H1.50 R8G80.1
SSD_RST_N: R8G33.2(B) R8G36.2(B) R8G40.1 R8G80.2(B)
SSD_RST_R_N: R8G36.1 U8G1.4(Y)
SSD_SATA_DEVSLP: Q8H2.1 R8H39.1
SSD_SATA_DEVSLP_R: J8H1.38 R8G82.1
SSD_SUS_CLK: J8H1.68(SUSCLK) R7F18.2(B)
SSP1_TXD_SDW2_DATA_POST1_OUT: J9A5.11 R9B1.2(B)
STARTUP_LATCH_SET: J6J2.68 R6J3.2(B)
SUS_CLK_CODEC: R6A52.1 R7F20.2(B)
SUS_STAT_ESPI_RST_EC_AIC_N: J6J2.123 R6J7.2(B)
SUS_STAT_ESPI_RST_EC_N: R7E60.2(B) U8F6.53
SUS_STAT_ESPI_RST_HDR_N: J7J1.19 R6J6.2(B)
SUS_STAT_ESPI_RST_N: R6J6.1 R6J7.1 R7E55.1 R7E60.1 U6E1.BF38
SUSACK_EC: J6J2.96 R7E47.2(B) U8F6.21
SUSACK_N: R7E47.1 R7E50.2(B) R7E53.2(B) U6E1.BE35
SUSWARN_EC: J6J2.20 R7E56.2(B) U8F6.111
SUSWARN_N_SUSPWRDNACK: R7E53.1 R7E56.1 U6E1.BC37
SV_ADVANCE_GP48: J9E8.1 R7F50.1 R9E26.2(B)
SV_DETECT: R6F1.2(B) R6F5.1 U6E1.N47
SVR_EN: EU4B1.6 R4B3.1 R4B8.2(B)
SW_I2C1_SCL_1.2K: R8A6.2(B) SW8A2.3
SW_I2C1_SCL_2.7K: R8A7.2(B) SW8A2.2
SW_I2C1_SCL_10K: R8A8.2(B) SW8A2.1
SW_I2C1_SCL_22K: R8A5.2(B) SW8A2.4
SW_I2C1_SDA_1.2K: R8A2.2(B) SW8A1.3
SW_I2C1_SDA_2.7K: R8A3.2(B) SW8A1.2
SW_I2C1_SDA_10K: R8A4.2(B) SW8A1.1
SW_I2C1_SDA_820: R8A1.2(B) SW8A1.4
SW_I2C2_SCL_1.2K: R8A16.2(B) SW8A3.3
SW_I2C2_SCL_2.7K: R8A15.2(B) SW8A3.2
SW_I2C2_SCL_10K: R8A14.2(B) SW8A3.1
SW_I2C2_SCL_820: R8A17.2(B) SW8A3.4
SW_I2C2_SDA_1.2K: R8A20.2(B) SW8A4.3
SW_I2C2_SDA_2.7K: R8A19.2(B) SW8A4.2
SW_I2C2_SDA_10K: R8A18.2(B) SW8A4.1
SW_I2C2_SDA_22K: R8A21.2(B) SW8A4.4
SW_ON_N: R1C43.1 R5H8.2(B) R5H9.2(B) R5H15.1 R7F29.2(B) U6E1.BE46
SX_EXIT_HOLDOFF_N: R8G59.2(B) R8G64.2(B) U8F6.67
SX_EXIT_HOLDOFF_N_ISH_GP_6: R7E49.2(B) R8H3.1 U6E1.BF36
SX_EXIT_HOLDOFF_PCH_N: R7E49.1 R8G55.1 R8G59.1
SX_EXIT_HOLDOFF_R1_N: EU8G3.6 R8G55.2(B)
SX_EXIT_HOLDOFF_R2_N: EU8G3.11 R8G64.1 R8G65.1
TBT_BATLOW_N: CR5A7.2 R5A40.1 U5A2.U2
TBT_CIO_PLUG_EVENT_AIC_N: J6J1.14 R6F4.1 R6F9.2(B) R6F41.2(B)
TBT_CIO_PLUG_EVENT_N: R6F4.2(B) R6F28.2(B) U6E1.Y46
TBT_CIO_PWR_EN: R6F20.2(B) R6H44.2(B) U6E1.M45
TBT_FRC_PWR: R6F26.2(B) R6F36.2(B) U6E1.Y47
TBT_FRC_PWR_AIC: J6J1.12 R6F36.1
TBT_FRC_PWR_BP: R5L14.1 R5L15.1 R6F26.1 U5A2.V4
TBT_PA_HPD: EU5A1.30 R5A30.1
TBT_PB_HPD: EU5A1.31 R5L11.1
TBT_PCIE_RBIAS: R5L10.1 U5A2.N16
TBT_PD_I2C_CLK: R5A37.1 U5A2.V2
TBT_PD_I2C_DATA: R5A32.1 U5A2.V1
TBT_PLUG_EVENT_N: R6F28.1 R6F35.2(B) R6F40.2(B) U5A2.AA1
TBT_RBIAS: R5L6.2(B) U5A2.J6
TBT_RSENSE: R5L6.1 U5A2.J5
TBT_RST_N: EU5A1.16 R5L2.2(B)
TBT_RST_R_N: R5A26.2(B) R5L1.1 R5L2.1 U5A2.E5
TBT_SLP_S3_N: R5A43.1 R5A44.1 U5A2.U1
TBT_TCK: R5L22.1 TP5L2.1(TP) U5A2.W19
TBT_TDI: R5L18.1 TP4L2.1(TP) U5A2.W20
TBT_TDO: R5L17.1 TP5L1.1(TP) U5A2.Y19
TBT_TMS: R4L2.1 TP4L1.1(TP) U5A2.Y20
TBT_TMU_CLK_OUT: R5A64.1 U5A2.Y1
TBT_TMU_CLKIN: R5L16.1 R5L21.1 U5A2.W6
TBT_USB_FORCE_PWR: R5L23.1 R5L24.1 U5A2.V5
TBT_WAKE_AIC_N: J6J1.10 R7F44.1 R7F48.1
TBT_WAKE_N: R5A57.1 R5A58.2(B) R5A63.2(B) U5A2.Y2
TBT_XTAL_25_IN: R4A5.1 U5A2.D22
TBT_XTAL_25_IN_R: C4A7.1 R4A5.2(B) Y4A1.1
TBT_XTAL_25_OUT: R4A6.1 U5A2.D23
TBT_XTAL_25_OUT_R: C4A8.1 R4A6.2(B) Y4A1.3
TBTA_RX1_ESD_N: CR4A4.1 J4A1.B10 U5A2.A21
TBTA_RX1_ESD_P: CR4A3.1 J4A1.B11 U5A2.B21
TBTA_RX2_ESD_N: CR5A2.1 J4A1.A10 U5A2.B15
TBTA_RX2_ESD_P: CR5A1.1 J4A1.A11 U5A2.A15
TBTA_SBU1: R5L4.2(B) U5A2.H4
TBTA_SBU2: R5L7.2(B) U5A2.J4
TBTA_TX1_C_N: C5A16.2(B) U5A2.B19
TBTA_TX1_C_P: C5A17.2(B) U5A2.A19
TBTA_TX1_ESD_N: C5A16.1 CR4A1.1 J4A1.A3
TBTA_TX1_ESD_P: C5A17.1 CR4A2.1 J4A1.A2
TBTA_TX2_C_N: C5A13.2(B) U5A2.B17
TBTA_TX2_C_P: C5A12.2(B) U5A2.A17
TBTA_TX2_ESD_N: C5A13.1 CR5A6.1 J4A1.B3
TBTA_TX2_ESD_P: C5A12.1 CR5A5.1 J4A1.B2
TCH_PNL_I2C_EN: Q8E5.1 Q8E6.1 Q8E7.1 Q8E8.1 R8E39.2(B)
TCH_PNL_INTR_N: CR9D4.2 R9D8.2(B) R9D11.2(B) U6E1.AT10
TCH_PNL_INTR_R_N: CR9D4.1(CATHODE) J9D2.3 R9D10.2(B) R9D11.1
TCH_PNL_RST_N: CR9D5.1(CATHODE) R9D15.2(B) U6E1.W47
TCH_PNL_RST_R_N: CR9D5.2 J9D2.4 R9D13.1 R9D14.2(B) R9D15.1
TCH_PNL_SCL: Q8E7.2(S) Q8E8.2(S) R8E16.1 R8E40.2(B) R9D4.2(B)
TCH_PNL_SDA: Q8E5.2(S) Q8E6.2(S) R8E13.1 R8E31.2(B) R9D7.2(B)
TCH_PNL_SPI1_CLK_I2C_MODE_SEL: C9D5.1 J9D2.5 R9D19.1 R9D20.1
TCH_PNL_SPI1_CS_N: J9D2.7 R9D22.2(B) R9D25.2(B) R9D26.2(B)
TCH_PNL_SPI1_MISO_I2C1_SDA: C9D4.1 J9D2.2 R9D6.1 R9D7.1 R9D9.2(B)
TCH_PNL_SPI1_MOSI_I2C1_SCL: C9D3.1 J9D2.1 R9D4.1 R9D5.1
TCHPNL_I2C_DIVIDER_EN: Q8E1.1 Q8E2.3 Q8E3.1 Q8E4.3 R8E11.2(B)
TCHPNL_IO_EN_G_N: C8C24.1 Q8C14.1 R8C69.2(B)
TCHPNL_IO_EN_N: Q8C15.3 R8C69.1 R8C70.2(B)
TCHPNL_PWREN: R8C74.1 U6E1.AW3
TCHPNL_PWREN_N: Q8C15.2(S) Q8D7.3 Q8D8.1 R8D14.2(B)
TCHPNL_PWREN_R: Q8D7.1 R8C74.2(B) R8C77.2(B) U8C5.A1
TCHPNL_PWRSEL: R8C81.2(B) R8C84.2(B) U8C5.B1
TCHPNL_PWRSEL_3V3_N: Q8E2.1 R8C84.1 SW7C1.8
TCHPNL_PWRSEL_DIPSW: R7C30.2(B) SW7C1.1
TCHPNL_SCL_DIVIDER: Q8E3.3 R8E16.2(B)
TCHPNL_SDA_DIVIDER: Q8E1.3 R8E13.2(B)
TEST_D8: R3A28.1 U3A5.D8
TEST_SETUP_MENU: J9G6.1 R9G23.2(B) U6E1.T46
TP3: U2G2.12
TP_3G16_JTAG1: J5B2.B9
TP_3G16_RSVD_A50: J5B2.A50
TP_+V1P8A_NC: EU8F2.7
TP_+V3P3DSW_NC: EU8G1.7
TP_A4WP_I2C_CLK: J7C1.60
TP_A4WP_I2C_DATA: J7C1.58
TP_A4WP_INT_N: J7C1.62
TP_A17_CHADIMM0: J1E5.234
TP_A17_CHADIMM1: J1F1.234
TP_A17_CHBDIMM0: J1F2.234
TP_A17_CHBDIMM1: J1F3.234
TP_C_2_CHADIMM0: J1E5.235
TP_C_2_CHADIMM1: J1F1.235
TP_C_2_CHBDIMM0: J1F2.235
TP_C_2_CHBDIMM1: J1F3.235
TP_CEC_HDMID: J3A2.13
TP_CHADIMM0_PIN1: J1E5.1
TP_CHADIMM0_PIN145: J1E5.145
TP_CHADIMM1_PIN1: J1F1.1
TP_CHADIMM1_PIN145: J1F1.145
TP_CHBDIMM0_PIN1: J1F2.1
TP_CHBDIMM0_PIN145: J1F2.145
TP_CHBDIMM1_PIN1: J1F3.1
TP_CHBDIMM1_PIN145: J1F3.145
TP_CLK_ITPXDP_DN: TP6D1.1(TP) U6E1.Y3
TP_CLK_ITPXDP_DP: TP6D2.1(TP) U6E1.Y4
TP_CLKOUT_SRC12_DN: U6E1.AC7
TP_CLKOUT_SRC12_DP: U6E1.AC6
TP_CLKOUT_SRC13_DN: U6E1.AA1
TP_CLKOUT_SRC13_DP: U6E1.Y2
TP_CLKOUT_SRC14_DN: U6E1.T2
TP_CLKOUT_SRC14_DP: U6E1.T1
TP_CLKOUT_SRC15_DN: U6E1.V2
TP_CLKOUT_SRC15_DP: U6E1.V3
TP_CLKREQ1_N: J7C1.68
TP_CLRCMOS: J8J9.1
TP_CLRRTC: J9E6.1
TP_CS2_CHADIMM0: J1E5.93
TP_CS2_CHADIMM1: J1F1.93
TP_CS2_CHBDIMM0: J1F2.93
TP_CS2_CHBDIMM1: J1F3.93
TP_CS3_CHADIMM0: J1E5.237
TP_CS3_CHADIMM1: J1F1.237
TP_CS3_CHBDIMM0: J1F2.237
TP_CS3_CHBDIMM1: J1F3.237
TP_DBL_CLK: J1B2.35
TP_DDI2_AUX_DN: J3D1.H35
TP_DDI2_AUX_DP: J3D1.H36
TP_DEVELOPER_MODE: J6J2.155 TP5J1.1(TP)
TP_DPSRC_AUX_N: U5A2.N5
TP_DPSRC_AUX_P: U5A2.N4
TP_DPSRC_ML0_N: U5A2.AC21
TP_DPSRC_ML0_P: U5A2.AB21
TP_DPSRC_ML1_N: U5A2.AB19
TP_DPSRC_ML1_P: U5A2.AC19
TP_DPSRC_ML2_N: U5A2.AC17
TP_DPSRC_ML2_P: U5A2.AB17
TP_DPSRC_ML3_N: U5A2.AB15
TP_DPSRC_ML3_P: U5A2.AC15
TP_DQS9_CHADIMM0: J1E5.8
TP_DQS9_CHADIMM1: J1F1.8
TP_DQS9_CHBDIMM0: J1F2.8
TP_DQS9_CHBDIMM1: J1F3.8
TP_DQS10_CHADIMM0: J1E5.19
TP_DQS10_CHADIMM1: J1F1.19
TP_DQS10_CHBDIMM0: J1F2.19
TP_DQS10_CHBDIMM1: J1F3.19
TP_DQS11_CHADIMM0: J1E5.30
TP_DQS11_CHADIMM1: J1F1.30
TP_DQS11_CHBDIMM0: J1F2.30
TP_DQS11_CHBDIMM1: J1F3.30
TP_DQS12_CHADIMM0: J1E5.41
TP_DQS12_CHADIMM1: J1F1.41
TP_DQS12_CHBDIMM0: J1F2.41
TP_DQS12_CHBDIMM1: J1F3.41
TP_DQS13_CHADIMM0: J1E5.100
TP_DQS13_CHADIMM1: J1F1.100
TP_DQS13_CHBDIMM0: J1F2.100
TP_DQS13_CHBDIMM1: J1F3.100
TP_DQS14_CHADIMM0: J1E5.111
TP_DQS14_CHADIMM1: J1F1.111
TP_DQS14_CHBDIMM0: J1F2.111
TP_DQS14_CHBDIMM1: J1F3.111
TP_DQS15_CHADIMM0: J1E5.122
TP_DQS15_CHADIMM1: J1F1.122
TP_DQS15_CHBDIMM0: J1F2.122
TP_DQS15_CHBDIMM1: J1F3.122
TP_DQS16_CHADIMM0: J1E5.133
TP_DQS16_CHADIMM1: J1F1.133
TP_DQS16_CHBDIMM0: J1F2.133
TP_DQS16_CHBDIMM1: J1F3.133
TP_DQS17_CHADIMM0: J1E5.52
TP_DQS17_CHADIMM1: J1F1.52
TP_DQS17_CHBDIMM0: J1F2.52
TP_DQS17_CHBDIMM1: J1F3.52
TP_DSX: J8J13.10
TP_EC_ENTERING_RW: J6J2.102
TP_EC_GPIO30: U8F6.34
TP_EC_GPIO35: U8F6.90
TP_EC_GPIO103: U8F6.69
TP_EC_GPIO153: U8F6.109
TP_EC_GPIO154: U8F6.110
TP_EC_GPIO166: U8F6.26
TP_EC_RSVD: J7J1.26
TP_FP1_CONN_SBU1: J6C4.P9
TP_FP1_CONN_SBU2: J6C4.P10
TP_FPF_MON: TP6T3.1(TP) U6E1.AN35
TP_FPF_VREF: TP6T1.1(TP) U6E1.AL37
TP_GPP_A_16_CLKOUT_48: TP7E1.1(TP) U6E1.BE33
TP_GSPI2_CS1_N_SNSR_HDR: J8H2.7
TP_HDMI_ESD_PIN2: CR2A1.5
TP_HDMI_TESTMODE: EU2A7.2
TP_HDMIC_ALS_CEC: J2A1.B13
TP_HDMIC_CEC: EU2A7.9
TP_HDMIC_CEC_EN: EU2A7.12
TP_HDMIC_RSV1: EU2A7.10
TP_HDMIC_RSV2: EU2A7.26
TP_HDMID_CEC: U3A5.F2
TP_I2C_CLK_R: TP3L2.1(TP) U3A5.F6
TP_I2C_DATA_R: TP3L1.1(TP) U3A5.E6
TP_KBC_SCANIN_0: J6J2.173 U8F6.98
TP_KBC_SCANIN_1: J6J2.181 U8F6.99
TP_KBC_SCANIN_2: J6J2.189 U8F6.6
TP_KBC_SCANIN_3: J6J2.198 U8F6.7
TP_KBC_SCANIN_4: J6J2.205 U8F6.104
TP_KBC_SCANIN_5: J6J2.213 U8F6.105
TP_KBC_SCANOUT_0: J6J2.237 U8F6.2
TP_KBC_SCANOUT_8: J6J2.206 U8F6.46
TP_KBC_SCANOUT_11: J6J2.238 U8F6.74
TP_KBD_BKLT_CTRL: J6J2.94
TP_LED_SEG9: U8L1.3
TP_LPSS_GSPI0_IO2: J9J2.6
TP_LPSS_GSPI0_IO3: J9J2.7
TP_LPSS_GSPI1_IO2: J9H2.6
TP_LPSS_GSPI1_IO3: J9H2.7
TP_LPSS_GSPI2_IO2: J9D5.6
TP_LPSS_GSPI2_IO3: J9D5.7
TP_ME_G3_TO_M3_N: J6J2.137 TP6J3.1(TP)
TP_MECC_ALS_INTR_N: J6J2.92 TP6J2.1(TP)
TP_MECC_AMBIENT_TEMP: J6J2.53
TP_MECC_DDIB_OB_HPD_EC: J6J2.118
TP_MECC_DNX_FORCE_RELOAD: J6J2.86
TP_MECC_DPSRC_TBT_HPD: J6J2.110
TP_MECC_EC_SENSORHUB_N: J6J2.93 TP6J1.1(TP)
TP_MECC_EC_THRM_ALERT_N: J6J2.66
TP_MECC_PCIE_WAKE_N: J6J2.21
TP_MECC_RSVD_PIN38: J6J2.38
TP_MECC_RSVD_PIN76: J6J2.76
TP_MECC_RSVD_PIN81: J6J2.81
TP_MECC_RSVD_PIN85: J6J2.85
TP_MECC_RSVD_PIN108: J6J2.108
TP_MECC_RSVD_PIN146: J6J2.146
TP_MECC_RSVD_PIN147: J6J2.147
TP_MECC_RSVD_PIN170: J6J2.170
TP_MECC_RVSD_PIN15: J6J2.15
TP_MECC_RVSD_PIN19: J6J2.19
TP_MECC_RVSD_PIN23: J6J2.23
TP_MECC_RVSD_PIN27: J6J2.27
TP_MECC_RVSD_PIN31: J6J2.31
TP_MECC_RVSD_PIN35: J6J2.35
TP_MECC_RVSD_PIN43: J6J2.43 J6J2.51
TP_MECC_RVSD_PIN59: J6J2.59
TP_MECC_RVSD_PIN60: J6J2.60
TP_MECC_SENSOR_ALERT: J6J2.119
TP_MECC_STD_ADP_PRSNT: J6J2.151
TP_MECC_SYS_VMON_EC: J6J2.52
TP_MECC_USB_WAKEOUT_R_N: J6J2.100
TP_MECC_USBC_LDO_ENABLE: J6J2.28
TP_MECCSMB_BS_ALRT_N: J6J2.207 TP5J2.1(TP)
TP_NC2_CHADIMM0: J1E5.230
TP_NC2_CHADIMM1: J1F1.230
TP_NC2_CHBDIMM0: J1F2.230
TP_NC2_CHBDIMM1: J1F3.230
TP_PA_USB2_D_N: U5A2.D20
TP_PA_USB2_D_P: U5A2.E20
TP_PASL_DRQ1_N: J7J1.28
TP_PB_I2C_INT: U5A2.M5
TP_PB_USB2_D_N: U5A2.D19
TP_PB_USB2_D_P: U5A2.E19
TP_PCIE_SLOT2_A19: J7B1.A19
TP_PCIE_SLOT2_A32: J7B1.A32
TP_PCIE_SLOT2_B30: J7B1.B30
TP_PCIE_SLOT2_JTAG1: J7B1.B9
TP_PCIE_SLOT2_JTAG2: J7B1.A5
TP_PCIE_SLOT2_JTAG3: J7B1.A6
TP_PCIE_SLOT2_JTAG4: J7B1.A7
TP_PCIE_SLOT2_JTAG5: J7B1.A8
TP_PCIE_SLOT3_JTAG1: J8B1.B9
TP_PCIE_SLOT3_JTAG2: J8B1.A5
TP_PCIE_SLOT3_JTAG3: J8B1.A6
TP_PCIE_SLOT3_JTAG4: J8B1.A7
TP_PCIE_SLOT3_JTAG5: J8B1.A8
TP_PCON_FUNC2: TP3L5.1(TP) U3A5.D7
TP_PCON_FUNC4: TP3L3.1(TP) U3A5.F3
TP_PCON_FUNC5: TP3L4.1(TP) U3A5.E7
TP_PD_GPIO15: EU5A1.43
TP_PD_GPIO17: EU5A1.49
TP_PD_GPIO18: EU5A1.50
TP_PERST1_N: J7C1.66
TP_PEWAKE1_N: J7C1.70
TP_PMIC_EC_CORE_CLK: J6J2.115
TP_RECOV_MODE_SW: J6J2.142 TP5J3.1(TP)
TP_RFU144_CHADIMM0: J1E5.144
TP_RFU144_CHADIMM1: J1F1.144
TP_RFU144_CHBDIMM0: J1F2.144
TP_RFU144_CHBDIMM1: J1F3.144
TP_RFU205_CHADIMM0: J1E5.205
TP_RFU205_CHADIMM1: J1F1.205
TP_RFU205_CHBDIMM0: J1F2.205
TP_RFU205_CHBDIMM1: J1F3.205
TP_RFU227_CHADIMM0: J1E5.227
TP_RFU227_CHADIMM1: J1F1.227
TP_RFU227_CHBDIMM0: J1F2.227
TP_RFU227_CHBDIMM1: J1F3.227
TP_RSVD_B39: J3D1.B39 TP5J4.1(TP)
TP_RSVD_SCREEN_LOCK: J9D4.4
TP_RSVD_VOL_CONN: J9D4.1
TP_SAR_NIRQ: J8H2.34 TP8G1.1(TP)
TP_SERIRQ_TPM: R7G34.2(B) TP7G1.1(TP)
TP_SMB_PCH_CK: J6J2.177
TP_SMC_LID: J6J2.135 R9F15.2(B) U8F6.24
TP_SPARE2: J5J1.16
TP_SPARE3: J5J1.18
TP_TBTB_HPD: J6J2.126
TP_TYPEC_PG_BP: EU6A2.14
TP_TYPEC_SPI_CON_3: J6B1.3
TP_TYPEC_SPI_CON_4: J6B1.4
TP_TYPEC_SPI_CON_8: J6B1.8
TP_TYPEC_SPI_CON_9: J6B1.9
TP_TYPEC_SPI_CON_13: J6B1.13
TP_TYPEC_SPI_CON_16: J6B1.16
TP_TYPEC_SPI_CON_17: J6B1.17
TP_TYPEC_SPI_CON_19: J6B1.19
TP_TYPEC_SPI_CON_20: J6B1.20
TP_U2_SB2: J5H1.C2
TP_U2_SB5: J5H1.D1
TP_U2_SB6: J5H1.D2
TP_USBC_FP3_CTL1: R6D7.1
TP_USBC_FP_ACTVSW_SBU1: EU6D1.27
TP_USBC_FP_ACTVSW_SBU2: EU6D1.26
TP_USBC_PD_I2C2_CLK: J6J2.144
TP_USBC_PD_I2C2_DATA: J6J2.136
TP_USBC_TBT_RT_I2C2_ALRT_N: J6J2.139
TP_UTILITY: J2A1.B14(UTILITY)
TP_UTL_HDMID: J3A2.14(UTILITY)
TP_V1P8A_CSN: R8F38.4(SENB)
TP_V1P8A_CSP: R8F38.3
TP_V3P3_SLOTM_CSN: R3H44.1 R8G86.4(SENB)
TP_V3P3_SLOTM_CSP: R3H45.1 R8G86.3
TP_V3P3_SLOTM_EAC_CSN: R3H44.2(B) U3H2.D2
TP_V3P3_SLOTM_EAC_CSP: R3H45.2(B) U3H2.D3
TP_V3P3A_CSN: R8G8.4(SENB)
TP_V3P3A_CSP: R8G8.3
TP_V3P3DSW_CSN: R7G4.4(SENB)
TP_V3P3DSW_CSP: R7G4.3
TP_V3P3DX_CPU_SSD2_CSN: R4H19.1 R5C17.4(SENB)
TP_V3P3DX_CPU_SSD2_CSP: R4H20.1 R5C17.3
TP_V3P3DX_CPU_SSD2_EAC_CSN: R4H19.2(B) U4H2.A2
TP_V3P3DX_CPU_SSD2_EAC_CSP: R4H20.2(B) U4H2.A3
TP_V3P3S_ALS_CSN: R2A34.3
TP_V3P3S_ALS_CSP: R2A34.4(SENB)
TP_V3P3S_CSN: R3H30.1 R4G19.4(SENB)
TP_V3P3S_CSP: R3H37.1 R4G19.3
TP_V3P3S_DP1_PWR_CSN: R2A6.4(SENB)
TP_V3P3S_DP1_PWR_CSP: R2A6.3
TP_V3P3S_EAC_CSN: R3H30.2(B) U3H1.C1
TP_V3P3S_EAC_CSP: R3H37.2(B) U3H1.D1
TP_V5A_CSN: R8G35.4(SENB)
TP_V5A_CSP: R8G35.3
TP_V5DSW_CSN: R3G34.4(SENB) R3H15.1
TP_V5DSW_CSP: R3G34.3 R3H16.1
TP_V5DSW_EAC_CSN: R3H15.2(B) U3H1.A2
TP_V5DSW_EAC_CSP: R3H16.2(B) U3H1.A3
TP_V5S_CSN: R3H13.1 R4G20.4(SENB)
TP_V5S_CSP: R3H14.1 R4G20.3
TP_V5S_EAC_CSN: R3H13.2(B) U3H1.B1
TP_V5S_EAC_CSP: R3H14.2(B) U3H1.A1
TP_V12S_CSN: R3G41.4(SENB) R3H42.1
TP_V12S_CSP: R3G41.3 R3H43.1
TP_V12S_EAC_CSN: R3H42.2(B) U3H1.D2
TP_V12S_EAC_CSP: R3H43.2(B) U3H1.D3
TP_VCCCORE_PH1_CSN: R2E6.1 R2M19.4(SENB)
TP_VCCCORE_PH1_CSP: R2E7.1 R2M19.3
TP_VCCCORE_PH1_EAC_CSN: R2E6.2(B) U1E2.C1
TP_VCCCORE_PH1_EAC_CSP: R2E7.2(B) U1E2.D1
TP_VCCCORE_PH2_CSN: R1E21.1 R3M40.4(SENB)
TP_VCCCORE_PH2_CSP: R1E22.1 R3M40.3
TP_VCCCORE_PH2_EAC_CSN: R1E21.2(B) U1E2.D2
TP_VCCCORE_PH2_EAC_CSP: R1E22.2(B) U1E2.D3
TP_VCCCORE_PH3_CSN: R1E28.1 R3M41.4(SENB)
TP_VCCCORE_PH3_CSP: R1E29.1 R3M41.3
TP_VCCCORE_PH3_EAC_CSN: R1E28.2(B) U1E3.A2
TP_VCCCORE_PH3_EAC_CSP: R1E29.2(B) U1E3.A3
TP_VCCCORE_PH4_CSN: R1E26.1 R3M42.4(SENB)
TP_VCCCORE_PH4_CSP: R1E27.1 R3M42.3
TP_VCCCORE_PH4_EAC_CSN: R1E26.2(B) U1E3.B1
TP_VCCCORE_PH4_EAC_CSP: R1E27.2(B) U1E3.A1
TP_VCCCORE_PH5_CSN: R1E36.1 R2N1.4(SENB)
TP_VCCCORE_PH5_CSP: R1E37.1 R2N1.3
TP_VCCCORE_PH5_EAC_CSN: R1E36.2(B) U1E3.C1
TP_VCCCORE_PH5_EAC_CSP: R1E37.2(B) U1E3.D1
TP_VCCCORE_PH6_CSN: R1E41.1 R2M18.4(SENB)
TP_VCCCORE_PH6_CSP: R1E42.1 R2M18.3
TP_VCCCORE_PH6_EAC_CSN: R1E41.2(B) U1E3.D2
TP_VCCCORE_PH6_EAC_CSP: R1E42.2(B) U1E3.D3
TP_VCCCORE_PH7_CSN: R1D12.1 R4M28.4(SENB)
TP_VCCCORE_PH7_CSP: R1D13.1 R4M28.3
TP_VCCCORE_PH7_EAC_CSN: R1D12.2(B) U1E1.A2
TP_VCCCORE_PH7_EAC_CSP: R1D13.2(B) U1E1.A3
TP_VCCCORE_PH8_CSN: R1D10.1 R4M27.4(SENB)
TP_VCCCORE_PH8_CSP: R1D11.1 R4M27.3
TP_VCCCORE_PH8_EAC_CSN: R1D10.2(B) U1E1.B1
TP_VCCCORE_PH8_EAC_CSP: R1D11.2(B) U1E1.A1
TP_VCCCORE_VIN_CSN: R1B1.4(SENB) R1E10.1
TP_VCCCORE_VIN_CSP: R1B1.3 R1E11.1
TP_VCCCORE_VIN_EAC_CSN: R1E10.2(B) U1E2.A2
TP_VCCCORE_VIN_EAC_CSP: R1E11.2(B) U1E2.A3
TP_VCCDDQ_CSN: R4H33.1
TP_VCCDDQ_CSP: R4H37.1
TP_VCCDDQ_EAC_CSN: R4H33.2(B) U4H2.C1
TP_VCCDDQ_EAC_CSP: R4H37.2(B) U4H2.D1
TP_VCCGT_PH1_CSN: R1E5.1 R2P3.4(SENB)
TP_VCCGT_PH1_CSP: R1E7.1 R2P3.3
TP_VCCGT_PH1_EAC_CSN: R1E5.2(B) U1E1.C1
TP_VCCGT_PH1_EAC_CSP: R1E7.2(B) U1E1.D1
TP_VCCGT_PH2_CSN: R1E13.1 R2P5.4(SENB)
TP_VCCGT_PH2_CSP: R1E14.1 R2P5.3
TP_VCCGT_PH2_EAC_CSN: R1E13.2(B) U1E1.D2
TP_VCCGT_PH2_EAC_CSP: R1E14.2(B) U1E1.D3
TP_VCCGT_VIN_CSN: R2C32.4(SENB) R3H26.1
TP_VCCGT_VIN_CSP: R2C32.3 R3H34.1
TP_VCCGT_VIN_EAC_CSN: R3H26.2(B) U3H2.C1
TP_VCCGT_VIN_EAC_CSP: R3H34.2(B) U3H2.D1
TP_VCCIO_0_EAC_NEG: R3H11.2(B) U3H2.A2
TP_VCCIO_0_EAC_POS: R3H12.2(B) U3H2.A3
TP_VCCIO_0_NEG: R3H11.1 R4D1.4(SENB)
TP_VCCIO_0_POS: R3H12.1 R4D1.3
TP_VCCIO_1_2_EAC_NEG: R3H24.2(B) U3H2.B1
TP_VCCIO_1_2_EAC_POS: R3H20.2(B) U3H2.A1
TP_VCCIO_1_2_NEG: R3H24.1 R5E1.4(SENB)
TP_VCCIO_1_2_POS: R3H20.1 R5E1.3
TP_VCCSA_CSN: R2E2.1 R4B41.4(SENB)
TP_VCCSA_CSP: R1E9.1 R4B41.3
TP_VCCSA_EAC_CSN: R2E2.2(B) U1E2.B1
TP_VCCSA_EAC_CSP: R1E9.2(B) U1E2.A1
TP_VCCSA_VIN_CSN: R5B54.3
TP_VCCSA_VIN_CSP: R5B54.4(SENB)
TP_VDD_LPP: J1B2.44
TP_VDDQ_CSN: R2G2.4(SENB) R4H17.1
TP_VDDQ_CSP: R2G2.3 R4H18.1
TP_VDDQ_EAC_CSN: R4H17.2(B) U4H2.B1
TP_VDDQ_EAC_CSP: R4H18.2(B) U4H2.A1
TP_VIRTUAL_BATTERY: J6J2.116
TP_VPP_CSN: R4H45.1 R5F13.4(SENB)
TP_VPP_CSP: R4H46.1 R5F13.3
TP_VPP_EAC_CSN: R4H45.2(B) U4H2.D2
TP_VPP_EAC_CSP: R4H46.2(B) U4H2.D3
TPEV_A_XTAL_RTC1_TPOUT: J8H4.2(IO2) U8J1.2 U8J1.6
TPEV_A_XTAL_RTC2_TPOUT: J8H4.1 U8H6.2 U8H6.6
TPEV_CML_PCUSTB_0_DN: J1C1.6 J3D1.J36
TPEV_CML_PCUSTB_0_DP: J1C1.4 J3D1.J37
TPEV_CML_PCUSTB_1_DN: J1C1.24 J3D1.R34
TPEV_CML_PCUSTB_1_DP: J1C1.22 J3D1.R35
TPEV_GPP_G0_R: R7R13.2(B)
TPEV_GPP_G1_R: R7R18.2(B)
TPEV_LAN_JTCK: EU4B1.35 J5B1.1 R4B12.2(B)
TPEV_LAN_JTDI: EU4B1.32 J5B1.4 R4B2.2(B)
TPEV_LAN_JTDO: EU4B1.34 J5B1.2
TPEV_LAN_JTMS: EU4B1.33 J5B1.6(IO6) R4B4.2(B)
TPEV_PEG_VIEW_0: J3D1.L4 TP5J8.1(TP)
TPEV_PEG_VIEW_1: J3D1.J4 TP5J7.1(TP)
TPEV_PEG_VIEW_2: J3D1.R33 TP5J6.1(TP)
TPEV_PEG_VIEW_3: J3D1.P33 TP5J5.1(TP)
TPEV_PWRGD_PS_JUMPER: J9G8.2(IO2) R9G25.1
TPEV_USB2_PLLMON: U6E1.U13
TPEV_XTAL_RTC1_TST: R8J1.2(B) U8J1.3
TPEV_XTAL_RTC2_TST: R8J1.1 U8H6.3
TR_SNK2_HPD: R5L20.1 U5A2.Y4
TX_OUT: J9B5.2 U9C1.11
TYPEC_COMP: EU6A2.8 R6A79.1
TYPEC_HV_BP_VSEL: EU5A1.23 R5A52.1
TYPEC_HV_COMP_R_BP: C6A50.1 R6A79.2(B)
TYPEC_HV_EN: Q6A1.6 R6A60.2(B) R6A68.2(B)
TYPEC_HV_EN_R: EU6A2.10 R6A68.1
TYPEC_HV_RT_BP: EU6A2.1 R6A71.2(B)
TYPEC_HV_SS_BP: C6A48.1 EU6A2.9
TYPEC_MODE_BIT0: R8G19.1 R8G29.2(B) U8F6.83
TYPEC_MODE_BIT1: R5J22.1 R9F26.1 R9F29.2(B) U8F6.37
TYPEC_SPI_CLK: EU5A1.38 R6B4.1 U5A2.Y16
TYPEC_SPI_CLK_R: J6B1.7 R6B4.2(B) U5B1.6
TYPEC_SPI_CS_N: EU5A1.39 R5B5.1 U5A2.W18
TYPEC_SPI_CS_R_N: J6B1.2 R5B5.2(B) R5B15.2(B) U5B1.1
TYPEC_SPI_HOLD_N: J6B1.11 R6B7.1
TYPEC_SPI_HOLD_R_N: R6B7.2(B) R6B8.2(B) U5B1.7
TYPEC_SPI_MISO: EU5A1.36 R5B4.1 U5A2.W16
TYPEC_SPI_MISO_R: J6B1.10 R5B4.2(B) R5B14.2(B) U5B1.2
TYPEC_SPI_MOSI: EU5A1.37 R6B3.1 U5A2.Y18
TYPEC_SPI_MOSI_R: J6B1.12 R6B3.2(B) U5B1.5
TYPEC_SPI_WP_N: J6B1.15(WP_N) R5B3.1 U5A2.W4
TYPEC_SPI_WP_R_N: R5B3.2(B) R5B13.2(B) U5B1.3(WP_IO2_N)
U2_CLKREQ_R_9: J5H1.B2 R5G22.2(B)
U2_DRV_ACT_LED: J5H1.C1 R9G38.1
U2LH_PIN4: R8C39.1 U8C2.4(Y_N)
U6LH_PIN2: R8C62.1 R8C68.2(B) U8C4.2
U31RD_1_EN_AB: EU4B5.2 R4B19.2(B)
U31RD_1_EN_CD: EU4B5.20 R3B9.2(B)
U31RD_1_EQA: EU4B5.42 R4B5.1 R4B9.2(B)
U31RD_1_EQB: EU4B5.29 R4M2.1 R4M4.2(B)
U31RD_1_EQC: EU4B5.11 R4M5.1 R4M7.2(B)
U31RD_1_EQD: EU4B5.18 R3B20.2(B) R3B23.1
U31RD_1_FGA: EU4B5.1 R4B11.2(B) R4B14.1
U31RD_1_FGB: EU4B5.28 R4M1.1 R4M3.2(B)
U31RD_1_FGC: EU4B5.10 R4M6.1 R4M8.2(B)
U31RD_1_FGD: EU4B5.19 R3B13.1 R3B17.2(B)
U31RD_2_EN_AB: EU3B4.2 R3B25.2(B)
U31RD_2_EN_CD: EU3B4.20 R3B10.2(B)
U31RD_2_EQA: EU3B4.42 R3B8.1 R3B12.2(B)
U31RD_2_EQB: EU3B4.29 R3M2.2(B) R3M4.1
U31RD_2_EQC: EU3B4.11 R3M5.1 R3M7.2(B)
U31RD_2_EQD: EU3B4.18 R3B21.2(B) R3B24.1
U31RD_2_FGA: EU3B4.1 R3B18.2(B) R3B22.1
U31RD_2_FGB: EU3B4.28 R3M1.2(B) R3M3.1
U31RD_2_FGC: EU3B4.10 R3M6.1 R3M8.2(B)
U31RD_2_FGD: EU3B4.19 R3B14.1 R3B19.2(B)
UART1_DIR1: EU7H1.1 R7H45.2(B) R7H46.1
UART1_DIR2: EU7H1.2 R7H39.1 R7H41.2(B)
UART1_DIR3: EU7H1.7 R7H28.1 R7H30.2(B)
UART1_DIR4: EU7H1.8 R7H22.1 R7H23.2(B)
UART1_OE_N: EU7H1.9 R7H21.2(B) R7H24.1
UART1_VREF: J6J2.134 R6J22.1 R6J23.2(B)
UART2_VREF: J6J2.163 R5J5.2(B) R5J6.1
UART_1V8_P56: J5B3.56 U7C1.4
UART_1V8_P58: J5B3.58 U7C1.5
UART_BT_WAKE_N: R7E38.2(B) U6E1.BE32
UART_IN: CR7C3.1 J7C3.1 U7C1.1
UART_IN_LP: CR7C2.1 J7C2.1 U7C1.8
UART_OE: R7C2.1 R7C3.2(B) U7C1.6
UART_VCCA: C7C5.2(B) R7C5.2(B) U7C1.3
UART_VCCB: C7C2.1 R7C4.2(B) U7C1.7(VCCB)
UNNAMED_100_PCIEX42X372M_I433_GND: J8H1.1 R8H7.2(B)
UNNAMED_115_RES_I229_A: R8A13.1 SW8A2.5(S4B) SW8A2.6 SW8A2.7 SW8A2.8
UNNAMED_115_RES_I230_A: R8A12.1 SW8A1.5(S4B) SW8A1.6 SW8A1.7 SW8A1.8
UNNAMED_118_RES_I121_A: R9B11.1 SW8A3.5(S4B) SW8A3.6 SW8A3.7 SW8A3.8
UNNAMED_118_RES_I124_A: R9B7.1 SW8A4.5(S4B) SW8A4.6 SW8A4.7 SW8A4.8
UNNAMED_131_HDR1X22_I246_IO2: J9F4.2(IO2) R9F13.1
UNNAMED_160_FET_I184_D: Q3G2.2 Q3G3.3 R3G32.2(B) R3G33.2(B)
UNNAMED_161_CAP_I30_A: C4G20.1 C4G25.2(B) Q4G4.1 R4G16.2(B)
UNNAMED_161_CAP_I178_A: C8D16.1 U8D2.7
UNNAMED_161_RES_I234_B: R8G13.1 R8G15.2(B)
UNNAMED_161_RES_I236_A: R8F46.2(B) R8F48.1
UNNAMED_162_RES_I410_B: R4G1.1 R5G2.2(B)
UNNAMED_163_RES_I203_A: R2G33.2(B) R2G36.1
UNNAMED_163_RES_I230_B: R2G35.2(B) R2G40.2(B) U2G3.2
UNNAMED_164_RES_I139_B: R5F19.2(B) R5F21.1 R5F22.2(B)
UNNAMED_164_RES_I186_A: R7G25.1 R8D97.2(B) R8D98.2(B) U7G5.1
UNNAMED_165_RES_I52_A: R5D3.1 U5D1.4(Y)
UNNAMED_165_RES_I83_B: R8D94.2(B) R8D95.2(B) U8D12.2
UNNAMED_165_RES_I86_B: R8D93.2(B) R8D99.2(B) U8D12.1
UNNAMED_166_CAP_I131_B: C8G11.2(B) Q8G7.1 R8G44.2(B)
UNNAMED_166_RES_I162_A: R5C24.1 R5C29.2(B)
UNNAMED_168_MOSFETNDUAL_I416_D: Q5E1.5 Q5E1.6 Q5E2.6 R5D40.2(B)
UNNAMED_168_MOSFETNDUAL_I418_G: Q5D1.5 Q5D1.6 R5D38.2(B)
UNNAMED_169_BAT54C_I156_A1: C1B2.1 CR1B1.1 CR1B1.2 R1B2.2(B) U1B1.1(V_P)
UNNAMED_169_CAP_I154_A: C1B16.1 EU1B1.59 R1B29.1
UNNAMED_169_CAP_I234_A: C2B22.1 R2B55.2(B)
UNNAMED_169_CAP_I283_A: C1B9.1 R1B21.2(B)
UNNAMED_169_CAP_I299_A: C1C7.1 R1C6.2(B)
UNNAMED_169_CAP_I369_B: C1B6.2(B) Q1B1.4 R1B17.2(B)
UNNAMED_169_CAP_I371_B: C1C6.2(B) R1C7.2(B) R1C10.1
UNNAMED_169_MOSFETN1D2S_I353_G: J1B1.2(IO2) Q1B1.1 R1B3.2(B)
UNNAMED_169_RES_I214_A: R2C15.1 R2C17.1
UNNAMED_169_RES_I236_A: R2B49.2(B) R2B53.2(B) R2B54.1
UNNAMED_169_RES_I242_A: R2B56.1 R2C1.2(B) R2C9.2(B)
UNNAMED_169_RES_I272_A: C1B10.2(B) Q1B1.2 Q1B1.3(S2) R1B19.2(B) R2B25.1
UNNAMED_169_RES_I309_B: EU1B1.58 R1B34.2(B) R1B36.1
UNNAMED_170_CAP_I174_A: C3M24.1 R3M25.2(B)
UNNAMED_170_RES_I265_B: R3M31.1 R3M35.2(B)
UNNAMED_170_RES_I267_A: R3M32.1 R3M39.2(B)
UNNAMED_170_SIC634CD_I115_GL1: EU2B3.27 EU2B3.33 TP2B2.1(TP)
UNNAMED_170_SIC634CD_I131_GL1: EU3B2.27 EU3B2.33 TP3B3.1(TP)
UNNAMED_171_CAP_I203_A: C3M23.1 R3M24.2(B)
UNNAMED_171_RES_I227_B: R3M30.1 R3M34.2(B)
UNNAMED_171_RES_I229_B: R3M33.1 R3M38.2(B)
UNNAMED_171_SIC634CD_I113_GL1: EU3B3.27 EU3B3.33 TP3B2.1(TP)
UNNAMED_171_SIC634CD_I128_GL1: EU3B1.27 EU3B1.33 TP3B1.1(TP)
UNNAMED_172_CAP_I189_A: C2M7.1 R2M9.2(B)
UNNAMED_172_RES_I236_B: R2M12.1 R2M14.2(B)
UNNAMED_172_RES_I238_B: R2M13.1 R2M15.2(B)
UNNAMED_172_SIC634CD_I110_GL1: EU2B4.27 EU2B4.33 TP2B4.1(TP)
UNNAMED_172_SIC634CD_I125_GL1: EU2B2.27 EU2B2.33 TP2B3.1(TP)
UNNAMED_173_CAP_I153_A: C4M18.1 R4M17.2(B)
UNNAMED_173_RES_I197_B: R4M20.1 R4M22.2(B)
UNNAMED_173_RES_I199_B: R4M21.1 R4M26.2(B)
UNNAMED_173_SIC634CD_I22_GL1: EU4B3.27 EU4B3.33 TP4B1.1(TP)
UNNAMED_173_SIC634CD_I99_GL1: EU4B4.27 EU4B4.33 TP4B2.1(TP)
UNNAMED_174_RES_I292_A: EU1B1.1 EU1B1.2 R1B31.1
UNNAMED_174_RES_I293_A: EU1B1.11 EU1B1.12 R1B20.1
UNNAMED_174_RES_I302_B: R1C11.1 R1C20.2(B)
UNNAMED_174_RES_I304_B: R1C8.1 R1C17.2(B)
UNNAMED_174_SIC634CD_I99_GL1: EU1D1.27 EU1D1.33 TP1D1.1(TP)
UNNAMED_174_SIC634CD_I263_GL1: EU1D2.27 EU1D2.33 TP1D2.1(TP)
UNNAMED_177_CAP_I51_A: C6A10.1 U6A2.7
UNNAMED_177_DIODETVSUNI_I16_C: CR6A1.1(C) FB6A1.1 R6A4.2
UNNAMED_178_CAP_I24_A: C4B4.1 EU4B2.7
UNNAMED_178_RES_I136_B: R8B30.1 R8B33.2(B) R8B34.2(B)
UNNAMED_179_CAPP_I69_A: C7B2.1 EU7B1.5 Q7B4.5 R7B17.1
UNNAMED_179_FET_I188_G: Q7B2.1 R7A9.1
UNNAMED_179_MOSFETN1G1D3S2_I217_S3: C7A11.1 EU7B1.1 EU7B1.2 EU7B1.3(S3) EU7B2.1 EU7B2.2 EU7B2.3(S3) R7A14.1
UNNAMED_181_CAP_I2_A: C8D19.1 Q8D11.1 R8D45.2(B)
UNNAMED_181_NPN_I176_C: Q4H5.3 R4H49.2(B)
UNNAMED_181_NPNDUAL_I179_B: Q4H3.5 R4H22.2(B)
UNNAMED_181_PNP_I134_B: Q4H4.1 R4H29.2(B)
UNNAMED_182_RES_I34_B: R8E1.2(B) R8E2.2(B) R8E3.2(B) R8E4.2(B) U8D14.2
UNNAMED_182_RES_I83_B: R8D68.2(B) U8D8.1
UNNAMED_182_RES_I192_B: R8D69.1 R8D80.2(B) U8D10.3
UNNAMED_182_RES_I193_B: R8D79.2(B) U8D10.1
UNNAMED_182_RES_I194_B: R8D71.2(B) U8D10.6
UNNAMED_182_RES_I201_A: R8D65.1 U8D10.4(Y)
UNNAMED_183_BAT54C_I184_C: CR5E1.3(C) R8D11.2(B)
UNNAMED_184_RES_I135_B: R8N1.2(B) U8N1.1
UNNAMED_185_MOSFETNDUAL_I78_D: Q4G1.6 R4G7.1 R4G8.2(B)
UNNAMED_187_CAP_I6_A: C8G21.1 U8G3.7
UNNAMED_187_CAP_I52_B: C5C42.2(B) EU5C1.1 EU5C1.2 EU5C1.3(S3) EU5C5.1 EU5C5.2 EU5C5.3(S3) R5C69.2(B)
UNNAMED_187_MOSFETNDUAL_I21_D: Q5C3.6 Q5C4.1(S)
UNNAMED_187_MOSFETNDUAL_I28_D: CR5C1.1(C) Q5C4.6 R5C18.2(B) R5C19.1
UNNAMED_189_RES_I148_A: R8E63.2(B) R8E66.1
UNNAMED_189_RES_I169_A: R8E41.2(B) R8E43.1
UNNAMED_189_RES_I191_A: R8E6.2(B) R8E8.1
UNNAMED_190_RES_I101_B: R8E22.2(B) R8E26.1
UNNAMED_192_CAP_I10_A: C6A24.1 U6A3.7
UNNAMED_194_CAP_I97_A: C6A40.1 Q6A3.1 Q6A3.2 Q6A3.3(S3) Q6A4.1 Q6A4.2 Q6A4.3(S3) R6A70.1 R6A76.1
UNNAMED_194_CAP_I97_B: C6A40.2(B) Q6A3.4 Q6A4.4 R6A74.1 R6A76.2(B)
UNNAMED_194_MOSFETNDUAL_I94_D: Q6A2.6 R6A74.2(B)
UNNAMED_194_RES_I30_B: R5D27.1 R6D58.2(B) R6D63.2(B) R6D64.2(B)
UNNAMED_202_LED_I439_A: DS8H3.1 R8H58.2(B)
UNNAMED_202_LED_I440_A: DS8H5.1 R8H60.2(B)
UNNAMED_202_LED_I441_A: DS8H4.1 R8H59.2(B)
UNNAMED_202_LED_I442_A: DS8H6.1 R8H61.2(B)
UNNAMED_202_LED_I443_A: DS8H2.1 R8H57.2(B)
UNNAMED_218_CAP_I149_A: C4H11.1 R3H33.1 R4H28.2(B) U4H2.B3
UNNAMED_222_CAP_I325_A: C5B37.1 R5B66.2(B)
UNNAMED_222_MOSFETN_I372_DRN: Q5M2.3 R5M8.2(B)
UNNAMED_222_MOSFETN_I373_DRN: Q5M3.3 R5B79.2(B)
UNNAMED_222_MOSFETN_I397_DRN: Q5M1.3 R5B69.2(B)
UNNAMED_222_RES_I140_B: R5M4.2(B) R5M5.2(B) RT5B1.2(B)
UNNAMED_222_RES_I369_B: R5M1.2(B) R5M3.1
USB2_COMP: R6D68.2(B) U6E1.F4
USB2_ID: R6D51.2(B) R6D52.1 R6D55.1 U6E1.G3
USB2_P1_DN: L3A5.1 R3A38.1 U6E1.J3
USB2_P1_DP: L3A5.2(OUT_2) R3A39.1 U6E1.J2
USB2_P1_L_DN: CR3A5.1 J3A1.12 L3A5.4 R3A38.2(B)
USB2_P1_L_DP: CR3A6.1 J3A1.13 L3A5.3 R3A39.2(B)
USB2_P2_DN: L3A4.2(OUT_2) R3A37.1 U6E1.N13
USB2_P2_DP: L3A4.1 R3A36.1 U6E1.N15
USB2_P2_L_DN: CR3A4.1 J3A1.22 L3A4.3 R3A37.2(B)
USB2_P2_L_DP: CR3A3.1 J3A1.23 L3A4.4 R3A36.2(B)
USB2_P3_DN: L3A3.2(OUT_2) R3A41.1 U6E1.K4
USB2_P3_DP: L3A3.1 R3A29.1 U6E1.K3
USB2_P3_L_DN: CR3A9.1 J3A1.32 L3A3.3 R3A41.2(B)
USB2_P3_L_DP: CR3A8.1 J3A1.33 L3A3.4 R3A29.2(B)
USB2_P4_DN: L3A2.2(OUT_2) R3A27.1 U6E1.M10
USB2_P4_DP: L3A2.1 R3A26.1 U6E1.L9
USB2_P4_L_DN: CR3A10.1 J3A1.36 L3A2.3 R3A27.2(B)
USB2_P4_L_DP: CR3A7.1 J3A1.37 L3A2.4 R3A26.2(B)
USB2_P5_DN: LP4A1.1 R4A8.1 U6E1.M1
USB2_P5_DP: LP4A1.2(OUT_2) R4A7.1 U6E1.L2
USB2_P5_L_DN: CR4A9.1 J4A2.2 LP4A1.4 R4A8.2(B)
USB2_P5_L_DP: CR4A8.1 J4A2.3 LP4A1.3 R4A7.2(B)
USB2_P6_DN: LP4A2.2(OUT_2) R4A9.1 U6E1.K7
USB2_P6_DP: LP4A2.1 R4A10.1 U6E1.K6
USB2_P6_L_DN: CR4A10.1 J4A2.11 LP4A2.3 R4A9.2(B)
USB2_P6_L_DP: CR4A11.1 J4A2.12 LP4A2.4 R4A10.2(B)
USB2_P7_DN: L5A1.3 R5A11.1 U6E1.L4
USB2_P7_DP: L5A1.4 R5A12.1 U6E1.L3
USB2_P8_DN: L6C1.3 R6C11.1 U6E1.G4
USB2_P8_DP: L6C1.4 R6C12.1 U6E1.G5
USB2_P8_L_DN: CR6C1.2(A2) J6B5.2 L6C1.2(OUT_2) R6C11.2(B)
USB2_P8_L_DP: CR6C2.2(A2) J6B5.3 L6C1.1 R6C12.2(B)
USB2_P9_CMC_ESD_DN: CR6D4.2(A2) J6C4.P18 L6D1.1 R6D2.1
USB2_P9_CMC_ESD_DP: CR6D3.2(A2) J6C4.P19 L6D1.2(OUT_2) R6D1.1
USB2_P9_DN: L6D1.4 R6D2.2(B) U6E1.M6
USB2_P9_DP: L6D1.3 R6D1.2(B) U6E1.N8
USB2_P10_CMC_ESD_DN: CR6C7.1 J6C3.P9 L6C4.1 R6C16.1
USB2_P10_CMC_ESD_DP: CR6C5.1 J6C3.P8 L6C4.2(OUT_2) R6C18.1
USB2_P10_DN: L6C4.4 R6C16.2(B) U6E1.H3
USB2_P10_DP: L6C4.3 R6C18.2(B) U6E1.H2
USB2_P11_DN: R7C40.1 R7C48.1 U6E1.R10
USB2_P11_DP: R7C39.1 R7C47.1 U6E1.P9
USB2_P11_ESD_DN: CR7C6.2(A2) J7C7.8 LP7C2.3 R7C33.2(B)
USB2_P11_ESD_DP: CR7C5.2(A2) J7C7.6 LP7C2.4 R7C32.2(B)
USB2_P11_R_DN: LP7C2.2(OUT_2) R7C33.1 R7C40.2(B)
USB2_P11_R_DP: LP7C2.1 R7C32.1 R7C39.2(B)
USB2_P11_TTK3_DN: R7C48.2(B) R7H5.1
USB2_P11_TTK3_DP: R7C47.2(B) R7H4.1
USB2_P12_DN: LP7C3.2(OUT_2) R7C35.1 U6E1.G1
USB2_P12_DP: LP7C3.1 R7C34.1 U6E1.G2
USB2_P12_ESD_DN: CR7C8.2(A2) J7C7.7 LP7C3.3 R7C35.2(B)
USB2_P12_ESD_DP: CR7C7.2(A2) J7C7.5 LP7C3.4 R7C34.2(B)
USB2_P13_CMC_ESD_DN: CR6C3.1 J6C3.P19 L6C3.1 R6C14.1
USB2_P13_CMC_ESD_DP: CR6C4.1 J6C3.P18 L6C3.2(OUT_2) R6C15.1
USB2_P13_DN: L6C3.4 R6C14.2(B) U6E1.N3
USB2_P13_DP: L6C3.3 R6C15.2(B) U6E1.N2
USB2_P14_DN: LP7C1.1 R7C8.1 U6E1.E5
USB2_P14_DP: LP7C1.2(OUT_2) R7C9.1 U6E1.F6
USB2_P14_M.2_BT_L_DN: J7C1.5 LP7C1.4 R7C8.2(B)
USB2_P14_M.2_BT_L_DP: J7C1.3 LP7C1.3 R7C9.2(B)
USB2_TTK_DN: J7G1.3 R7H5.2(B)
USB2_TTK_DP: J7G1.1 R7H4.2(B)
USB2_USBC_BP_CMC_ESD_DN: CR5A3.2(A2) J4A1.A7 J4A1.B7 L5A1.2(OUT_2) R5A11.2(B)
USB2_USBC_BP_CMC_ESD_DP: CR5A4.2(A2) J4A1.A6 J4A1.B6 L5A1.1 R5A12.2(B)
USB2_VBUSSENSE: R6D45.1 R6D48.2(B) R6D53.1 R6D56.1 U6E1.F3
USB31_P1_RX_DN: R6C13.1 U6E1.D11
USB31_P1_RX_DP: R6C10.1 U6E1.C11
USB31_P1_RX_ESD_DN: J6B5.5 R6C13.2(B) U6C1.1 U6C1.10
USB31_P1_RX_ESD_DP: J6B5.6 R6C10.2(B) U6C1.2 U6C1.9(NC_9)
USB31_P1_TX_C_DN: C6C2.2(B) L6C2.1 R6C9.1
USB31_P1_TX_C_DP: C6C1.2(B) L6C2.4(PIN4) R6C7.2(B)
USB31_P1_TX_DN: C6C2.1 U6E1.F9
USB31_P1_TX_DP: C6C1.1 U6E1.F7
USB31_P1_TX_ESD_DN: J6B5.8 L6C2.2 R6C9.2(B) U6C1.4 U6C1.7
USB31_P1_TX_ESD_DP: J6B5.9 L6C2.3 R6C7.1 U6C1.5 U6C1.6
USB31_P2_RX_C_DN: C3B13.1 EU3B4.9
USB31_P2_RX_C_DP: C3B12.1 EU3B4.8
USB31_P2_RX_DN: C3B13.2(B) U6E1.B9
USB31_P2_RX_DP: C3B12.2(B) U6E1.C9
USB31_P2_RX_ESD_DN: C3A30.2(B) J3A1.15 R3A32.1 U3A7.5 U3A7.6
USB31_P2_RX_ESD_DP: C3A29.2(B) J3A1.16 R3A31.1 U3A7.4 U3A7.7
USB31_P2_RX_RD_DN: C3A30.1 EU3B4.30
USB31_P2_RX_RD_DP: C3A29.1 EU3B4.31
USB31_P2_TX_C_DN: C3B19.2(B) EU3B4.5
USB31_P2_TX_C_DP: C3B16.2(B) EU3B4.4
USB31_P2_TX_CMC_DN: C3A28.2(B) L3A6.4(PIN4) R3A30.2(B)
USB31_P2_TX_CMC_DP: C3A27.2(B) L3A6.1 R3A42.1
USB31_P2_TX_DN: C3B19.1 U6E1.C3
USB31_P2_TX_DP: C3B16.1 U6E1.D4
USB31_P2_TX_ESD_DN: J3A1.18 L3A6.3 R3A30.1 U3A7.2 U3A7.9(NC_9)
USB31_P2_TX_ESD_DP: J3A1.19 L3A6.2 R3A42.2(B) U3A7.1 U3A7.10
USB31_P2_TX_RD_DN: C3A28.1 EU3B4.34
USB31_P2_TX_RD_DP: C3A27.1 EU3B4.35
USB31_P3_RX_C_DN: C3B14.1 EU3B4.16
USB31_P3_RX_C_DP: C3B15.1 EU3B4.17
USB31_P3_RX_DN: C3B14.2(B) U6E1.B10
USB31_P3_RX_DP: C3B15.2(B) U6E1.C10
USB31_P3_RX_ESD_DN: C3A33.2(B) J3A1.25 R3A34.1 U3A6.4 U3A6.7
USB31_P3_RX_ESD_DP: C3A34.2(B) J3A1.26 R3A35.1 U3A6.5 U3A6.6
USB31_P3_RX_RD_DN: C3A33.1 EU3B4.23
USB31_P3_RX_RD_DP: C3A34.1 EU3B4.22
USB31_P3_TX_C_DN: C3B17.2(B) EU3B4.12
USB31_P3_TX_C_DP: C3B18.2(B) EU3B4.13
USB31_P3_TX_CMC_DN: C3A31.2(B) L3A7.1 R3A43.1
USB31_P3_TX_CMC_DP: C3A32.2(B) L3A7.4(PIN4) R3A33.2(B)
USB31_P3_TX_DN: C3B17.1 U6E1.F11
USB31_P3_TX_DP: C3B18.1 U6E1.G12
USB31_P3_TX_ESD_DN: J3A1.28 L3A7.2 R3A43.2(B) U3A6.1 U3A6.10
USB31_P3_TX_ESD_DP: J3A1.29 L3A7.3 R3A33.1 U3A6.2 U3A6.9(NC_9)
USB31_P3_TX_RD_DN: C3A31.1 EU3B4.27
USB31_P3_TX_RD_DP: C3A32.1 EU3B4.26
USB31_P4_RX_C_DN: C4B14.1 EU4B5.9
USB31_P4_RX_C_DP: C4B13.1 EU4B5.8
USB31_P4_RX_DN: C4B14.2(B) U6E1.K16
USB31_P4_RX_DP: C4B13.2(B) U6E1.J15
USB31_P4_RX_ESD_DN: C4A40.2(B) J4A2.5 R4A14.1 U4A1.1 U4A1.10
USB31_P4_RX_ESD_DP: C4A39.2(B) J4A2.6 R4A13.1 U4A1.2 U4A1.9(NC_9)
USB31_P4_RX_RD_DN: C4A40.1 EU4B5.30
USB31_P4_RX_RD_DP: C4A39.1 EU4B5.31
USB31_P4_TX_C_DN: C4B18.2(B) EU4B5.5
USB31_P4_TX_C_DP: C4B15.2(B) EU4B5.4
USB31_P4_TX_CMC_DN: C4A38.2(B) L4A1.4(PIN4) R4A12.2(B)
USB31_P4_TX_CMC_DP: C4A37.2(B) L4A1.1 R4A20.1
USB31_P4_TX_DN: C4B18.1 U6E1.B14
USB31_P4_TX_DP: C4B15.1 U6E1.C14
USB31_P4_TX_ESD_DN: J4A2.8 L4A1.3 R4A12.1 U4A1.4 U4A1.7
USB31_P4_TX_ESD_DP: J4A2.9 L4A1.2 R4A20.2(B) U4A1.5 U4A1.6
USB31_P4_TX_RD_DN: C4A38.1 EU4B5.34
USB31_P4_TX_RD_DP: C4A37.1 EU4B5.35
USB31_P5_RX_DN: R6D17.1 U6E1.J13
USB31_P5_RX_DP: R6D16.1 U6E1.K13
USB31_P5_RX_R_DN: J6C3.P6 R6D17.2(B) U6D3.5 U6D3.6
USB31_P5_RX_R_DP: J6C3.P5 R6D16.2(B) U6D3.4 U6D3.7
USB31_P5_TX_C_CMC_ESD_DN: J6C3.P3 R6D14.2(B) U6D3.2 U6D3.9(NC_9) U6D4.2
USB31_P5_TX_C_CMC_ESD_DP: J6C3.P2 R6D15.2(B) U6D3.1 U6D3.10 U6D4.3
USB31_P5_TX_C_DN: C6D8.2(B) R6D14.1 U6D4.1
USB31_P5_TX_C_DP: C6D7.2(B) R6D15.1 U6D4.4(PIN4)
USB31_P5_TX_DN: C6D8.1 U6E1.C15
USB31_P5_TX_DP: C6D7.1 U6E1.B15
USB31_P6_RX_DN: C6D19.1 U6E1.G14
USB31_P6_RX_DP: C6D18.1 U6E1.F14
USB31_P6_RX_FP3_DN: C6D19.2(B) EU6D1.5
USB31_P6_RX_FP3_DP: C6D18.2(B) EU6D1.4
USB31_P6_TX_DN: C5D13.1 U6E1.C17
USB31_P6_TX_DP: C6D20.1 U6E1.C16
USB31_P6_TX_FP3_DN: C5D13.2(B) EU6D1.8
USB31_P6_TX_FP3_DP: C6D20.2(B) EU6D1.7
USB31_P7_RX_C_DN: C3B10.1 EU4B5.16
USB31_P7_RX_C_DP: C3B11.1 EU4B5.17
USB31_P7_RX_DN: C3B10.2(B) U6E1.G17
USB31_P7_RX_DP: C3B11.2(B) U6E1.F16
USB31_P7_RX_ESD_DN: C3A25.2(B) J4A2.14 R4A16.1 U4A2.4 U4A2.7
USB31_P7_RX_ESD_DP: C3A26.2(B) J4A2.15 R4A17.1 U4A2.5 U4A2.6
USB31_P7_RX_RD_DN: C3A25.1 EU4B5.23
USB31_P7_RX_RD_DP: C3A26.1 EU4B5.22
USB31_P7_TX_C_DN: C4B16.2(B) EU4B5.12
USB31_P7_TX_C_DP: C4B17.2(B) EU4B5.13
USB31_P7_TX_CMC_DN: C4A41.2(B) L4A2.1 R4A21.1
USB31_P7_TX_CMC_DP: C4A42.2(B) L4A2.4(PIN4) R4A15.2(B)
USB31_P7_TX_DN: C4B16.1 U6E1.A17
USB31_P7_TX_DP: C4B17.1 U6E1.B17
USB31_P7_TX_ESD_DN: J4A2.17 L4A2.2 R4A21.2(B) U4A2.1 U4A2.10
USB31_P7_TX_ESD_DP: J4A2.18 L4A2.3 R4A15.1 U4A2.2 U4A2.9(NC_9)
USB31_P7_TX_RD_DN: C4A41.1 EU4B5.27
USB31_P7_TX_RD_DP: C4A42.1 EU4B5.26
USB31_P8_RX_DN: R6D11.1 U6E1.R21
USB31_P8_RX_DP: R6D10.1 U6E1.P21
USB31_P8_RX_R_DN: J6C3.P15 R6D11.2(B) U6D7.4 U6D7.7
USB31_P8_RX_R_DP: J6C3.P16 R6D10.2(B) U6D7.5 U6D7.6
USB31_P8_TX_C_CMC_ESD_DN: J6C3.P12 R6D13.2(B) U6D5.3 U6D7.1 U6D7.10
USB31_P8_TX_C_CMC_ESD_DP: J6C3.P13 R6D12.2(B) U6D5.2 U6D7.2 U6D7.9(NC_9)
USB31_P8_TX_C_DN: C6D6.2(B) R6D13.1 U6D5.4(PIN4)
USB31_P8_TX_C_DP: C6D5.2(B) R6D12.1 U6D5.1
USB31_P8_TX_DN: C6D6.1 U6E1.B18
USB31_P8_TX_DP: C6D5.1 U6E1.C18
USB_FORCE_PWR: R5L24.2(B) R5L25.2(B) U6E1.AA45
USB_OC_BACK0_N: R3A2.1 R3A3.2(B) R6T5.1
USB_OC_BACK1_N: R3B11.2(B) R3B15.1 R3B16.1
USB_OC_BACK2_N: R4A3.2(B) R4A4.1 R7T27.1
USB_OC_USB2_FP_N: R7C13.2(B) R7C15.1 R7T3.1
USB_OC_USB31_FP1_N: R6C20.2(B) R6C21.1 R6T19.1
USB_OC_USB31_FP2_N: R6B25.1 R6B26.2(B) R7F35.1
USBC_BP_ESD_CC1: C5A20.1 CR4A6.1 J4A1.A5 R5A22.2(B)
USBC_BP_ESD_CC2: C5A19.1 CR4L1.1 J4A1.B5 R5A21.2(B)
USBC_BP_OC_EC_N: CR8F2.1(CATHODE) U8F6.10
USBC_BP_OC_PD_N: CR7T1.1(CATHODE) EU5A1.41
USBC_BP_PD_CC1: EU5A1.24 R5A22.1
USBC_BP_PD_CC2: EU5A1.26 R5A21.1
USBC_BP_SBU1: R4A2.1 R5L4.1
USBC_BP_SBU1_R_ESD: CR4A5.1 J4A1.A8 R4A2.2(B)
USBC_BP_SBU2: R4L1.1 R5L7.1
USBC_BP_SBU2_R_ESD: CR4L2.1 J4A1.B8 R4L1.2(B)
USBC_FP3_ACTVSW_DCI_CLK: EU6D1.32 R6D30.1
USBC_FP3_ACTVSW_DCI_DATA: EU6D1.29 R6D25.1
USBC_FP3_ACTVSW_I2C_EN: EU6D1.17 R5D10.1 R5D11.2(B)
USBC_FP3_CC1: EU5A1.45 R5A53.1
USBC_FP3_CC2: EU5A1.47 R5A54.1
USBC_FP3_CTL0: EU5A1.53 R6D8.1
USBC_FP3_CTL0_SDA_R: EU6D1.22 R6D8.2(B) R6D9.2(B) R6D24.2(B) R6D27.1
USBC_FP3_CTL1: EU6D1.23 R6D7.2(B) R6D22.1 R6D23.2(B) R6D26.1
USBC_FP3_DCI_CLK: R7D7.2(B) R7D9.1 R9D40.2(B) U7D1.4
USBC_FP3_DCI_CLK_LT: R6D22.2(B) R6D30.2(B) R7C46.2(B) R7D9.2(B) U7D1.5
USBC_FP3_DCI_DATA: R7D6.2(B) R7D8.1 R9D38.2(B) U7D1.3
USBC_FP3_DCI_DATA_LT: R6D25.2(B) R7C42.2(B) R7D8.2(B) U7D1.6
USBC_FP3_DPEQ0_A1: EU6D1.14 R5D12.2(B) R5D13.1
USBC_FP3_DPEQ1: EU6D1.2 R6D43.1 R6D46.2(B)
USBC_FP3_EQ0: EU6D1.38 R6D36.1 R6D37.2(B)
USBC_FP3_EQ1: EU6D1.35 R6D32.1 R6D35.2(B)
USBC_FP3_ESD_CC1: C5B9.1 C6C6.1 CR6C6.2(K2) J6C4.P8 R5A53.2(B)
USBC_FP3_ESD_CC2: C5B10.1 C6C10.1 CR6C8.2(K2) J6C4.P20(VCONN) R5A54.2(B)
USBC_FP3_FLIP: EU5A1.54 R5D9.1
USBC_FP3_FLIP_SCL_R: EU6D1.21 R5D6.2(B) R5D8.2(B) R5D9.2(B) R6D28.1
USBC_FP3_OC_EC_N: CR8F1.1(CATHODE) U8F6.20
USBC_FP3_OC_PD_N: CR6H2.1(CATHODE) EU5A1.55
USBC_FP3_RX1_DN: C6D2.1 EU6D1.30
USBC_FP3_RX1_DP: C6D1.1 EU6D1.31
USBC_FP3_RX1_R_DN: C6D2.2(B) J6C4.P6 R6D6.1 U6D2.5 U6D2.6
USBC_FP3_RX1_R_DP: C6D1.2(B) J6C4.P5 R6D5.1 U6D2.4 U6D2.7
USBC_FP3_RX2_DN: C6D3.1 EU6D1.40
USBC_FP3_RX2_DP: C6D4.1 EU6D1.39
USBC_FP3_RX2_R_DN: C6D3.2(B) J6C4.P16 R6D3.1 U6D1.5 U6D1.6
USBC_FP3_RX2_R_DP: C6D4.2(B) J6C4.P15 R6D4.1 U6D1.4 U6D1.7
USBC_FP3_SSEQ0_A0: EU6D1.11 R5D14.1 R5D15.2(B)
USBC_FP3_SSEQ1: EU6D1.3 R6D44.1 R6D47.2(B)
USBC_FP3_TX1_C_CMC_ESD_DN: J6C4.P3 R6D21.2(B) U6D2.2 U6D2.9(NC_9) U6D6.3
USBC_FP3_TX1_C_CMC_ESD_DP: J6C4.P2 R6D20.2(B) U6D2.1 U6D2.10 U6D6.2
USBC_FP3_TX1_C_DN: C6D12.2(B) R6D21.1 U6D6.4(PIN4)
USBC_FP3_TX1_C_DP: C6D11.2(B) R6D20.1 U6D6.1
USBC_FP3_TX1_DN: C6D12.1 EU6D1.33
USBC_FP3_TX1_DP: C6D11.1 EU6D1.34
USBC_FP3_TX2_C_CMC_ESD_DN: J6C4.P13 L6D2.2 R6D18.2(B) U6D1.2 U6D1.9(NC_9)
USBC_FP3_TX2_C_CMC_ESD_DP: J6C4.P12 L6D2.3 R6D19.2(B) U6D1.1 U6D1.10
USBC_FP3_TX2_C_DN: C6D9.2(B) L6D2.1 R6D18.1
USBC_FP3_TX2_C_DP: C6D10.2(B) L6D2.4(PIN4) R6D19.1
USBC_FP3_TX2_DN: C6D9.1 EU6D1.37
USBC_FP3_TX2_DP: C6D10.1 EU6D1.36
USBC_FP_OTG_ID_PD_AIC: R6D55.2(B)
USBC_FP_VBUS_SENSE_EC: R6D56.2(B) U8F6.3
USBC_FP_VBUS_SENSE_PD: R6D45.2(B)
USBC_FPAIC_OC_N: CR6H1.1(CATHODE) J6J1.11
USBC_PD_ALRT_P3: J6J2.130
USBC_PD_ALRT_P4: J6J2.188
USBC_PD_I2C2_CLK: J6J1.3 R8E51.2(B)
USBC_PD_I2C2_DATA: J6J1.1 R8F7.2(B)
USBC_PD_I2C_CLK: R5A61.1 R8E51.1 R8E54.1 R8E55.1
USBC_PD_I2C_CLK_EC: Q8G2.2(S) R8E54.2(B)
USBC_PD_I2C_CLK_PCH: Q8E9.3 R8E55.2(B)
USBC_PD_I2C_DATA: R5A62.1 R8F1.1 R8F2.1 R8F7.1
USBC_PD_I2C_DATA_EC: Q8G3.2(S) R8F2.2(B)
USBC_PD_I2C_DATA_PCH: Q8E10.3 R8F1.2(B)
V_0P9_LAN: C4A24.1 C4A26.1 C4A29.1 C4A36.1 C4B2.1 C4B7.1 C4B8.1 EU4B1.8 EU4B1.11 EU4B1.16 EU4B1.22 EU4B1.37 EU4B1.40 EU4B1.43 EU4B1.46 EU4B1.47 L4B1.2(INB)
V_3P3_A_APS: J9H3.3 R9H15.2(B)
V_5P0_STBY_R117BV: CR7B1.1(C) Q7B5.3 R7B7.2(B) R7B8.1
V_C_2: C9C1.1 U9C1.2(VP)
V_C_6: C9C4.1 U9C1.6
V_CPU_VCCIO_R119BV: Q8C7.2 Q8C7.5 Q8C9.2 Q8C9.3 R8C50.2(B)
V_HDMID_SCL: CR2A2.1 R2A3.1
V_HDMID_SDA: CR2A2.2(C2) R2A5.1
V_PPHV_EN-1: Q6A2.5 R6A73.2(B) R6A75.1
V_PPHV_EN-2: Q6A1.2 Q6A2.3 R6A56.2(B)
V_SA0_DIMM0_CHA: J1E5.139 R5E49.2(B) R5E51.1
V_SA0_DIMM0_CHB: J1F2.139 R5F3.2(B) R5F4.1
V_SA0_DIMM1_CHA: J1F1.139 R5E54.1 R5E55.2(B)
V_SA0_DIMM1_CHB: J1F3.139 R5F14.2(B) R5F15.1
V_SA1_DIMM0_CHA: J1E5.140 R5E48.2(B) R5E50.1
V_SA1_DIMM0_CHB: J1F2.140 R5F7.2(B) R5F8.1
V_SA1_DIMM1_CHA: J1F1.140 R5E52.1 R5E53.2(B)
V_SA1_DIMM1_CHB: J1F3.140 R5F16.2(B) R5F17.1
V_VDDQ_VR_OUT_R: C2G23.1 C2G24.1 R2G22.1 R2G25.1 R2G31.2(B)
VBOOT_TYPEC_PG_BP: C6A36.1 EU6A2.13
VCORE_BT1: C2B7.1 EU2B3.5
VCORE_BT1_R: C2B7.2(B) R3B35.2(B)
VCORE_BT2: C3B23.1 EU3B2.5
VCORE_BT2_R: C3B23.2(B) R3B34.2(B)
VCORE_BT3: C3B21.1 EU3B3.5
VCORE_BT3_R: C3B21.2(B) R3B33.2(B)
VCORE_BT4: C3B20.1 EU3B1.5
VCORE_BT4_R: C3B20.2(B) R4B26.2(B)
VCORE_BT5: C2B10.1 EU2B4.5
VCORE_BT5_R: C2B10.2(B) R2B11.2(B)
VCORE_BT6: C2B9.1 EU2B2.5
VCORE_BT6_R: C2B9.2(B) R2B10.2(B)
VCORE_BT7: C4B21.1 EU4B4.5
VCORE_BT7_R: C4B21.2(B) R4B25.2(B)
VCORE_BT8: C4B20.1 EU4B3.5
VCORE_BT8_R: C4B20.2(B) R4B24.2(B)
VCORE_COMP: C2B20.1 EU1B1.14 R2B29.1
VCORE_DB_VREF1: EU3M1.16 R1B25.1 R3M25.1
VCORE_DB_VREF2: EU3M2.16 R1B24.1 R3M24.1
VCORE_DB_VREF3: EU2M1.16 R1B26.1 R2M9.1
VCORE_DB_VREF4: EU4M1.16 R1B28.1 R4M17.1
VCORE_IC_FB: C1B6.1 C1B10.1 C2B20.2(B) EU1B1.13 R1B17.1 R1B19.1 R1B21.1 R2B29.2(B)
VCORE_IMON: EU1B1.25 R2B54.2(B)
VCORE_ISEN1N: C3M20.1 C3M25.1 EU3M1.2 ISO3B8.2(B<0>) R3M27.1
VCORE_ISEN1N_SUM: EU1B1.6 R1B25.2(B)
VCORE_ISEN1P: C3M20.2(B) EU3M1.1 R3M27.2(B) R3M31.2(B)
VCORE_ISEN1P_SUM: EU1B1.5 EU3M1.15
VCORE_ISEN2N: C3M19.1 C3M26.1 EU3M1.3 ISO3B7.2(B<0>) R3M26.1
VCORE_ISEN2N_SUM: EU1B1.8 R1B24.2(B)
VCORE_ISEN2P: C3M19.2(B) EU3M1.4 R3M26.2(B) R3M32.2(B)
VCORE_ISEN2P_SUM: EU1B1.7 EU3M2.15
VCORE_ISEN3N: C3M22.1 C3M29.1 EU3M2.2 ISO3B6.2(B<0>) R3M29.1
VCORE_ISEN3N_SUM: EU1B1.4 R1B26.2(B)
VCORE_ISEN3P: C3M22.2(B) EU3M2.1 R3M29.2(B) R3M30.2(B)
VCORE_ISEN3P_SUM: EU1B1.3 EU2M1.15
VCORE_ISEN4N: C3M21.1 C3M30.1 EU3M2.3 ISO3B5.2(B<0>) R3M28.1
VCORE_ISEN4N_SUM: EU1B1.10 R1B28.2(B)
